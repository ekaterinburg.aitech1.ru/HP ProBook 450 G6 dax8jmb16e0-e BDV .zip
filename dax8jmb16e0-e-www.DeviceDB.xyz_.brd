# Allegro board dax8jmb16e0-e-www.DeviceDB.xyz_.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
AGND on BOTTOM (solid shape): 236.64,22.2 238.89,22.2 238.89,21.98 238.93,21.7 239.05,21.44 239.41,21.1 239.9,20.97 240.44,20.97 240.44,20.49 240.3,20.15 239.95,20 237.19,20 236.96,20.22 236.96,20.96 236.2,21.72 229.85,21.72 228.91,20.78 228.91,19.88 228.39,19.01 228.89,18.12 228.89,13.41 228.43,12.28 229.4,11.53 231.58,11.53 231.58,10.72 231.58,10.72 231.58,9.48 231.45,9.35 229.78,9.35 229.45,9.02 229.26,9.02 229.14,8.92 229.03,8.81 228.93,8.79 228.86,8.87 228.45,9.17 228.16,8.76 228.13,8.68 228.06,8.64 226.35,8.64 225.97,8.26 224.47,8.26 224.42,8.31 224.42,9.05 225.03,9.66 225.03,9.81 225.04,9.85 225.08,9.86 225.36,9.86 226.12,10.62 226.41,10.62 226.44,10.61 226.46,10.58 226.75,10.3 227.11,10.47 227.18,10.53 227.18,12.3 227.2,12.71 227.31,13.1 227.74,13.53 227.81,13.62 227.88,13.7 227.88,17.64 227.68,17.84 227.34,18.36 227.19,18.96 227.19,19.37 227.21,19.55 227.25,19.72 227.24,19.72 227.24,20.82 229.61,23.19 233.28,23.19 233.28,23.2 235.64,23.2
AGND on SVCC (solid shape): outline of 150 points within 216.92,5.74 240.44,23.7
AGND on IN1 (solid shape): 226.27,23.32 226.27,22.89 226.24,22.81 226.16,22.78 225.92,22.71 225.78,22.5 225.78,22.49 225.68,22.39 225.68,21.55 225.69,21.54 225.69,21.5 225.2,21.02 225.2,20.84 225.19,20.79 225.18,20.68 225.18,18.35 224.77,17.94 224.77,17.73 223.58,16.54 222.97,16.54 221.72,15.3 221.24,15.3 220.81,15.73 220.81,15.91 221.17,16.26 221.17,16.55 222.18,17.56 222.18,17.73 222.21,17.76 223.45,17.76 223.91,18.22 223.91,22.76 224.67,23.53 226.07,23.53
AGND on IN1 (solid shape): 228.95,20.95 228.95,19.9 228.39,19.03 228.89,18.12 228.89,13.52 228.89,13.41 228.87,13.4 228.43,12.27 229.4,11.53 231.46,11.53 231.5,11.49 231.5,10.47 231.38,10.34 229.4,10.34 227.89,11.02 227.39,12.6 228.19,13.39 228.19,18.58 227.44,19.33 227.44,19.67 227.89,20.52 228.69,21.06 228.84,21.06
AGND on IN2 (solid shape): outline of 297 points within 220.84,10.62 240.44,23.53
AGND on SGND (solid shape): outline of 151 points within 216.92,5.74 240.44,23.7
GND on TOP (solid shape): 23.45,126.78 23.45,125.41 23.05,125 22.21,125 22.06,125.15 22.06,126.7 22.28,126.93 23.3,126.93
GND on TOP (solid shape): 43.8,102.16 43.8,98.76 43.67,98.63 39.25,98.63 39.15,98.74 39.15,102.14 39.28,102.27 43.7,102.27
GND on TOP (solid shape): 44.71,31.3 44.71,28.96 44.56,28.81 42.22,28.81 42.07,28.96 42.07,31.3 42.22,31.45 44.56,31.45
GND on TOP (solid shape): 124.29,115.09 124.29,113.37 124.11,113.19 119.03,113.19 118.8,113.42 118.8,114.89 119.19,115.27 124.11,115.27
GND on TOP (solid shape): 156,28.05 156,27.2 155.81,27.01 154.26,27.01 153.4,27.87 153.4,28.13 153.58,28.3 155.74,28.3
GND on TOP (solid shape): 156.24,22.48 156.24,21.93 156.12,21.8 152.89,21.8 152.66,22.03 152.66,22.38 152.87,22.59 156.14,22.59
GND on TOP (solid shape): 169.3,35.72 169.3,34.88 169.12,34.7 167.78,34.7 167.67,34.8 167.67,35.44 168.18,35.95 169.07,35.95
GND on TOP (solid shape): 191.47,112.04 191.47,107.52 191.4,107.45 186.83,107.45 186.75,107.52 186.75,112.07 186.85,112.17 191.35,112.17
GND on TOP (solid shape): 194.95,115.63 194.95,114.86 194.81,114.71 192.39,114.71 192.16,114.94 192.16,115.78 192.24,115.86 194.72,115.86
GND on TOP (solid shape): 207.7,112.04 207.7,107.55 207.6,107.45 205.06,107.45 205.04,107.47 205.04,112.04 205.11,112.12 207.63,112.12
GND on TOP (solid shape): 214.23,91.78 214.23,87.46 214.13,87.36 212.63,87.36 212.53,87.46 212.53,91.7 212.71,91.88 214.13,91.88
GND on TOP (solid shape): 220.99,14.23 220.99,10.93 220.79,10.72 217.46,10.72 217.33,10.85 217.33,14.33 217.41,14.41 220.81,14.41
GND on TOP (solid shape): 129.56,111.32 129.56,110.15 129.51,110.1 129.51,108.48 129.12,108.09 128.19,108.09 128.19,111.4 128.29,111.5 129.38,111.5
GND on TOP (solid shape): 56.93,97.9 56.93,94.77 56.73,94.57 54.92,94.57 54.64,94.85 54.64,97.54 54.81,97.71 56.31,97.71 56.57,97.97 56.85,97.97
GND on TOP (solid shape): 106.5,119.65 106.5,118.83 106.12,118.45 102.66,118.45 102.51,118.6 102.51,119.59 102.69,119.77 106.37,119.77
GND on TOP (solid shape): 112.86,107.8 112.86,107.02 113.19,106.69 113.19,105.26 112.89,104.96 111.29,104.96 110.96,105.29 110.96,107.47 111.43,107.94 112.72,107.94
GND on TOP (solid shape): 142.22,31.7 142.22,31.12 141.94,30.84 136.46,30.84 135.77,31.53 135.77,32.59 136.38,33.2 140.72,33.2
GND on TOP (solid shape): 156.62,34.57 156.62,34.14 156.42,33.94 155.53,33.94 155.33,34.14 153.86,34.14 153.7,34.3 153.7,34.52 153.86,34.68 156.52,34.68
GND on TOP (solid shape): 90.46,94.62 90.46,92.94 90.28,92.77 86.5,92.77 86.34,92.92 86.34,93.45 85.86,93.93 85.86,94.75 85.94,94.82 90.25,94.82
GND on TOP (solid shape): 187.56,28 188.96,28 189.09,27.87 189.09,27.23 188.96,27.11 186.55,27.11 186.42,27.23 186.42,27.74 186.55,27.87 186.8,27.87 187.18,28.25 187.31,28.25
GND on TOP (solid shape): 228.05,8.21 228.05,7.55 227.64,7.55 226.98,6.89 226.98,6.15 224.72,6.15 224.57,6.3 224.57,7.8 224.72,7.96 226.14,7.96 226.47,8.29 227.97,8.29
GND on TOP (solid shape): 45.7,71.69 45.7,71.13 46.59,70.23 46.59,69.65 46.48,69.54 44.83,69.54 44.62,69.75 43.62,69.75 43.34,70.03 43.34,72.45 43.77,72.88 44.51,72.88
GND on TOP (solid shape): 128.21,106.72 128.21,105.97 128.03,105.79 127.62,105.79 127.6,105.81 127.54,105.75 126.86,105.75 126.65,105.95 126.65,106.2 126.53,106.33 126.53,106.78 126.72,106.97 127.96,106.97
GND on TOP (solid shape): 225.03,97.41 225.03,97.11 224.93,97.01 223.33,97.01 223.25,97.08 221.88,97.08 221.83,97.13 221.83,97.29 221.88,97.34 223.2,97.34 223.4,97.54 224.9,97.54
GND on TOP (solid shape): 75.22,81.13 75.22,79.71 74.84,79.33 74.38,79.33 73.92,79.79 72.7,79.79 72.45,79.53 72.45,78.57 72.25,78.36 69.55,78.36 67.52,80.4 67.52,81.97 69.07,83.52 72.83,83.52
GND on TOP (solid shape): 103.16,95.89 103.16,95.71 103.64,95.23 104.53,95.23 104.83,94.93 104.83,89.64 104.53,89.34 102.29,89.34 101.99,89.64 101.99,92.84 102.19,93.05 102.19,95.97 102.29,96.07 102.98,96.07
GND on TOP (solid shape): 144.43,69.63 144.89,69.63 145.04,69.47 145.04,69.19 144.79,68.94 143.16,68.94 143.04,69.07 143.04,69.37 143.18,69.51 143.4,69.51 143.59,69.7 143.59,69.83 143.72,69.96 144.1,69.96
GND on TOP (solid shape): 150.57,102.64 150.57,102.38 150.75,102.21 151.77,102.21 152.01,101.97 152.01,100.09 151.81,99.89 149.97,99.89 149.91,99.84 149.61,99.84 149.29,100.15 149.29,102.01 150.05,102.76 150.46,102.76
GND on TOP (solid shape): 165.39,22.74 167.78,22.74 167.93,22.59 167.93,22.25 167.9,22.21 167.87,22.15 167.52,21.8 164.45,21.8 164.19,22.05 164.19,23.09 164.35,23.25 164.88,23.25
GND on TOP (solid shape): 117.97,37.01 117.97,36 117.84,35.87 115.68,35.87 115.55,36 115.51,36 114.88,36.63 112.3,36.63 112.23,36.71 112.23,37.09 112.28,37.14 117.84,37.14
GND on TOP (solid shape): 172.68,11.18 172.68,10.8 172.45,10.57 170.11,10.57 169.96,10.72 168.72,10.72 168.66,10.67 168.66,10.32 168.46,10.12 167.93,10.12 167.85,10.19 167.85,11.54 167.9,11.59 172.27,11.59
GND on TOP (solid shape): 179.74,23.09 180.3,23.09 180.45,22.94 180.45,22.05 179.99,21.6 177.33,21.6 177.33,22.08 177.4,22.15 177.83,22.15 178.04,22.36 178.04,23.14 178.21,23.32 179.51,23.32
GND on TOP (solid shape): 224.72,94.52 225.56,94.52 225.66,94.42 225.66,93.15 225.53,93.02 225.18,93.02 224.44,92.28 224.44,90.84 224.42,90.81 223.68,90.81 223.55,90.94 223.55,91.62 223.1,92.08 223.1,94.47 223.15,94.52
GND on TOP (solid shape): 36.66,109.35 36.66,108.18 36.36,107.88 36.26,107.88 36.26,107.88 36.05,107.92 35.85,107.88 35.84,107.88 35.26,107.88 34.93,108.21 34.25,108.21 34.15,108.31 34.15,109.23 34.37,109.45 36.56,109.45
GND on TOP (solid shape): 192.41,41.62 192.41,41.31 192.4,41.27 192.36,41.25 192.06,41.25 191.55,40.75 191.12,40.75 191.07,40.8 191.07,41.23 191.27,41.43 191.27,41.91 191.29,41.95 191.32,41.97 192.06,41.97
GND on TOP (solid shape): 40.62,35.39 43.65,35.39 43.7,35.34 43.7,34.78 43.54,34.63 41.55,34.63 40.1,34.63 40.04,34.63 39.81,34.39 38.73,34.39 38.57,34.23 38.57,34.02 38.42,33.88 37.92,33.88 37.75,34.05 37.75,35.59 37.93,35.77 40.24,35.77
GND on TOP (solid shape): 110.82,122.03 110.82,121.22 110.85,121.19 111.34,121.19 111.39,121.14 111.39,120.25 111.34,120.2 109.56,120.2 109.48,120.27 109.48,121.14 109.51,121.16 110.54,121.16 110.57,121.19 110.57,122.02 110.6,122.05 110.8,122.05
GND on TOP (solid shape): 171.64,73.31 171.67,73.29 171.69,73.26 171.69,69.93 171.56,69.8 168.59,69.8 168.28,69.5 168.28,69.46 168.26,69.44 168.26,68.87 168.21,68.81 168.11,68.81 168.05,68.86 168.05,69.78 168.19,69.92 168.18,69.93 168.18,73.21 168.28,73.31
GND on TOP (solid shape): 46.82,55.02 46.82,54.34 47.26,54.34 47.29,54.32 47.3,54.29 47.3,53.5 47.2,53.4 45.14,53.4 45.13,53.41 45.13,53.69 44.92,53.89 44.26,53.89 44.02,53.66 43.3,53.66 43.17,53.79 43.17,54.39 43.28,54.51 44.55,54.51 45.21,55.16 46.68,55.16
GND on TOP (solid shape): 33.85,123.92 33.85,123.42 33.77,123.34 32.57,123.34 32.46,123.22 32.46,122.78 32.18,122.51 31.2,122.51 30.34,123.37 29.07,123.37 28.94,123.5 28.94,123.88 29.07,124.01 29.7,124.01 29.95,123.75 30.97,123.75 31.26,123.47 32.03,123.47 32.58,124.02 33.74,124.02
GND on TOP (solid shape): 112.66,117.47 112.66,116.2 113.1,115.75 117.74,115.75 117.94,115.55 117.94,113.26 117.74,113.06 114,113.06 113.55,113.52 112.11,113.52 112.07,113.52 111.64,113.09 108.77,113.09 108.58,113.28 108.58,114.27 110.39,116.09 111.18,116.09 111.83,116.73 111.83,117.46 111.95,117.58 112.55,117.58
GND on TOP (solid shape): 117.78,30.58 117.78,30.18 117.84,30.12 118.81,30.12 118.85,30.07 118.85,29.6 118.09,28.83 118.09,27.74 117.76,27.41 114.71,27.41 114.64,27.49 114.64,28.35 114.38,28.61 113.34,28.61 113.27,28.68 113.27,29.19 113.37,29.29 115.2,29.29 115.57,29.66 116.12,29.66 116.62,30.15 116.62,30.68 116.72,30.78 117.59,30.78
GND on TOP (solid shape): 156.85,12.27 156.85,11.41 156.7,11.26 155.1,11.26 154.92,11.44 154.93,11.48 154.95,11.57 154.94,11.67 154.94,11.7 154.95,11.72 155.2,11.97 155.2,12.6 155.05,12.76 153.12,12.76 152.79,13.09 152.79,14.15 152.92,14.28 154.85,14.28
GND on TOP (solid shape): 214.23,81.77 214.23,81.23 214.16,81.16 214.16,78.36 214.03,78.24 210.51,78.24 209.68,79.07 209.67,79.07 209.63,79.1 207.04,79.1 207.01,79.07 206.21,79.07 206.07,78.92 206,78.92 205.85,79.08 205.85,80.07 205.9,80.12 207.81,80.12 208.92,81.23 212.4,81.23 213.02,81.86 213.16,81.86 213.2,81.89 214.1,81.89
GND on TOP (solid shape): 45.63,52.33 46.11,52.33 46.35,52.57 46.59,52.57 46.65,52.56 47.45,52.56 47.81,52.2 47.81,50.78 47.48,50.45 47.14,50.45 47,50.59 47,50.93 46.75,51.18 45.01,51.18 44.86,51.33 44.85,51.35 44.85,51.36 44.85,52.42 45.04,52.62 45.34,52.62
GND on TOP (solid shape): 212.89,24.82 212.89,24.28 212.61,24.01 212.61,22.47 212.35,22.2 211.54,22.2 209.69,24.05 209.68,24.08 209.68,24.11 209.78,24.61 209.66,25.1 209.66,25.11 209.66,25.43 209.79,25.56 212.15,25.56
GND on TOP (solid shape): 159.98,23.47 159.98,21.85 160.28,21.54 161.5,21.54 161.7,21.75 162.1,21.75 162.34,21.98 162.34,22 162.42,22.08 162.42,23.37 162.52,23.47 162.95,23.47 163.03,23.4 163.03,21.52 162.57,21.06 158.4,21.06 158.15,21.32 158.15,22.74 158.3,22.89 159.01,22.89 159.22,23.09 159.22,23.42 159.37,23.58 159.88,23.58
GND on TOP (solid shape): 132.19,107.9 132.19,107.24 132.7,106.74 132.7,106.23 132.6,106.13 132.14,106.13 132.09,106.18 132.09,106.56 131.86,106.79 131.61,106.79 131.38,107.02 131.37,107.05 131.38,107.07 131.43,107.27 131.35,107.47 131.35,107.68 131.25,107.78 130.46,107.78 130.28,107.96 130.28,108.62 130.39,108.72 131.38,108.72
GND on TOP (solid shape): 163.39,60.43 163.39,60.28 163.59,60.08 163.66,60.08 163.74,60 166.2,60 166.3,59.9 166.3,59.39 166.05,59.14 165.08,59.14 164.4,58.45 164.4,57.69 164.75,57.33 165.9,57.33 165.95,57.28 165.95,56.88 165.92,56.85 164.4,56.85 163.97,57.28 163.74,57.28 163.58,57.43 163.58,58.45 163.1,58.93 162.8,58.93 162.52,59.21 162.52,60.48 162.64,60.61 163.2,60.61
GND on TOP (solid shape): 167.6,28.58 169.35,28.58 169.5,28.43 169.5,28.4 169.63,28.28 170.34,28.28 170.51,28.45 171.02,28.45 171.33,28.76 172.24,28.76 172.27,28.73 172.27,28.48 171.24,27.45 170.64,27.45 170.62,27.44 167.38,27.44 166.9,27.92 166.9,27.93 166.82,28.05 166.7,28.13 166.69,28.13 166.61,28.21 166.61,28.68 166.78,28.86 167.32,28.86
GND on TOP (solid shape): 211.44,6.98 211.45,6.97 211.45,6.94 211.48,6.94 211.49,6.93 211.84,6.93 211.93,6.84 211.93,6.77 212.15,6.55 212.15,6.13 211.97,5.95 210.43,5.95 210.43,5.95 210.24,5.95 210.14,6.05 210.14,6.33 210.27,6.46 210.35,6.46 210.44,6.55 210.46,6.62 210.47,6.67 210.47,6.84 210.67,7.04 211.38,7.04
GND on TOP (solid shape): 98.69,34.85 98.69,34.31 98.8,34.19 99.66,34.19 99.77,34.3 99.77,34.78 99.85,34.85 100.32,34.85 100.41,34.77 100.41,34.34 100.55,34.19 101.1,34.19 101.89,33.41 101.89,33.05 101.71,32.87 100.9,32.87 100.52,33.25 98.26,33.25 98.24,33.27 95.59,33.27 95.31,33.55 95.31,34.68 95.56,34.93 98.61,34.93
GND on TOP (solid shape): 198.13,78.08 198.11,78 198.11,77.91 198.1,77.91 198.1,76.38 198.86,75.62 198.93,75.62 198.94,75.61 199.12,75.54 199.31,75.53 199.33,75.54 199.37,75.49 199.37,75.24 199.25,75.11 197.72,75.11 197.54,75.29 197.54,76.34 196.66,77.23 196.66,78.06 196.73,78.14 197.34,78.14 197.85,78.64 197.85,78.8 198.13,78.8
GND on TOP (solid shape): 200.03,63.65 200.03,62.95 199.95,62.87 198.33,62.87 197.9,63.3 197.34,63.3 196.71,62.67 196.69,62.67 196.34,62.32 196.34,61.97 196.34,61.95 196.33,61.93 196.12,61.73 194.62,61.73 194.37,61.98 194.37,62.36 195.03,63.02 195.31,63.02 195.34,63.02 195.99,63.02 196.02,63.02 196.32,63.02 196.4,63.02 196.43,63.05 196.58,63.05 197.09,63.56 197.09,63.68 197.24,63.84 199.84,63.84
GND on TOP (solid shape): 81.92,87.76 81.96,87.75 81.97,87.71 81.97,86.97 81.21,86.21 80.63,86.21 80.61,86.22 80.59,86.24 80.27,86.45 79.95,86.25 79.94,86.24 79.89,86.21 74.23,86.21 74.02,86.42 74.02,87.18 74.4,87.56 81.13,87.56 81.15,87.58 81.29,87.58 81.47,87.76
GND on TOP (solid shape): 113.52,97.77 113.52,97.61 112.8,96.88 112.8,96.34 112.81,96.33 112.81,96.25 112.94,96.12 112.94,95.61 113.17,95.38 113.17,94.75 113.09,94.67 110.85,94.67 110.75,94.77 110.75,95.15 110.98,95.38 112,95.38 112.18,95.56 112.18,96.27 112.12,96.32 112.12,96.35 112.11,96.38 112.08,96.43 112.07,96.49 112.08,96.56 112.08,96.88 113.05,97.86 113.08,97.88 113.12,97.9 113.16,97.95 113.34,97.95
GND on TOP (solid shape): 122.41,96.58 122.41,85.98 122.23,85.81 122.23,85.81 122.14,85.81 122.09,85.76 121.6,85.76 121.59,85.76 121.47,85.78 121.35,85.76 121.34,85.76 120.99,85.76 120.91,85.83 120.91,87.23 121.01,87.33 121.01,87.88 121.01,87.94 120.86,88.09 120.66,88.09 120.56,88.19 120.56,90.3 120.48,90.38 120.48,93.83 120.87,94.23 120.87,96.17 120.87,96.18 120.87,96.47 120.73,96.6 120.73,97.06 120.84,97.16 121.83,97.16
GND on TOP (solid shape): 136.32,128.76 136.32,127.96 135.39,127.03 135.39,125.51 134.58,124.69 132.67,124.69 132.44,124.92 132.44,128.45 132.37,128.53 132.21,128.53 131.91,128.53 131.88,128.53 130.95,128.53 130.92,128.53 130.62,128.53 130.58,128.53 129.66,128.53 129.62,128.53 129.39,128.53 129.22,128.71 129.22,129.14 129.29,129.22 135.86,129.22
GND on TOP (solid shape): 222.99,22.74 223.43,22.74 223.6,22.56 223.6,22.31 223.66,22.26 223.66,18.34 223.43,18.12 222.59,18.12 222.46,18.24 222.46,19.08 223.05,19.66 223.05,20.6 222.74,20.91 222.74,21.77 222.36,22.15 221.88,22.15 221.51,21.79 221.51,21.56 220.76,20.81 220.76,20.43 220.68,20.35 220.28,20.35 220.23,20.4 220.23,21.04 219.87,21.39 219.87,22.89 219.95,22.97 220.58,22.97 220.94,23.32 222.41,23.32
GND on TOP (solid shape): 30.76,130.45 30.81,130.41 30.87,130.38 30.89,130.35 30.89,128.83 31.22,128.5 31.22,126.93 30.89,126.6 30.89,125.94 30.68,125.73 30.02,125.73 29.45,126.29 29.19,126.29 29.08,126.41 29.08,126.92 29.35,127.18 29.35,127.34 29.7,127.69 29.7,128.33 29.83,128.45 30.11,128.45 30.19,128.53 30.24,128.56 30.27,128.59 30.38,128.77 30.37,128.98 30.35,129.01 30.34,129.05 30.34,130.32 30.46,130.45
GND on TOP (solid shape): 134.37,115.41 134.37,114.16 134.41,114.13 135.71,114.13 136.19,114.61 137.2,114.61 137.4,114.43 137.66,114.43 137.76,114.43 137.8,114.34 137.8,112.93 137.68,112.81 137.45,112.81 137.35,112.91 137.35,113.22 137.07,113.49 136.76,113.49 136.71,113.54 136.2,113.54 136.05,113.7 133.84,113.7 133.76,113.78 133.76,114.92 133.81,115.07 133.8,115.24 134.07,115.51 134.27,115.51
GND on TOP (solid shape): 224.65,25.28 225.43,25.28 225.59,25.43 227.54,25.43 227.97,25 228.48,25 228.64,24.84 228.64,24.83 228.86,24.4 229.17,24.02 229.17,23.14 229.01,22.99 228.63,22.99 228.46,23.17 228.46,23.42 228.07,23.81 224.72,23.81 224.66,23.87 224.65,23.89 224.65,23.91 224.64,24 224.61,24.08 224.61,24.09 224.61,24.29 223.86,25.03 223.86,25.16 223.84,25.19 223.84,25.22 223.6,25.46 223.57,25.46 223.55,25.48 223.12,25.48 223.05,25.56 223.05,25.94 223.17,26.06 223.37,26.12 223.81,26.12
GND on TOP (solid shape): 76.13,131.86 76.13,130.87 75.98,130.72 75.41,130.72 75.31,130.62 75.31,130.52 75.1,130.31 75,130.31 74.97,130.32 74.92,130.34 74.87,130.35 74.82,130.36 74.76,130.36 74.71,130.35 74.66,130.33 74.63,130.31 74.51,130.31 74.48,130.28 74.02,130.28 74,130.31 74.01,130.52 74.02,130.53 74.05,130.54 74.43,130.54 74.43,130.79 74.05,130.79 74.02,130.79 74.01,130.81 74,130.87 73.64,131.22 74.06,131.22 74.06,131.63 73.87,131.63 73.87,131.22 73.59,131.22 73.57,131.25 73.57,131.65 73.49,131.73 73.49,132.64 73.92,133.08 74.91,133.08
GND on TOP (solid shape): 114.84,97.11 114.84,96.96 115.07,96.73 115.43,96.73 116.01,96.14 116.75,96.14 116.98,96.37 116.98,97.08 117.05,97.16 117.51,97.16 118.07,96.6 118.07,96.4 117.86,96.2 117.86,95.64 117.74,95.51 117.74,92.87 117.59,92.72 117.59,91.45 117.74,91.29 117.74,88.19 117.61,88.07 117.08,88.07 116.98,87.97 116.98,87.48 117.2,87.25 117.2,84.87 117,84.66 115.88,84.66 115.63,84.92 115.63,85.48 115.63,87.35 115.63,87.41 115.25,87.79 115.25,88.6 115.12,88.73 115.12,92.54 115.22,92.64 115.22,93.6 114.79,94.04 114.79,96.04 114.28,96.55 114.28,97.11 114.36,97.19 114.77,97.19
GND on TOP (solid shape): 6.23,110.5 6.72,110.5 6.72,110.49 7.61,110.49 7.7,110.49 7.7,110.5 7.98,110.5 8.11,110.37 8.11,109.73 7.88,109.5 7.88,108.82 7.88,108.79 7.87,108.78 7.84,108.77 7.23,108.77 7.13,108.77 7.07,108.76 7,108.74 6.95,108.71 6.92,108.69 6.56,108.69 6.46,108.59 6.46,108.08 6.14,107.75 4.86,107.75 4.71,107.9 4.71,108.99 7.7,108.99 7.7,109.19 6.76,109.19 6.76,108.99 4.71,108.99 4.71,109.49 7.7,109.49 7.7,109.69 6.76,109.69 6.76,109.49 4.71,109.49 4.71,109.83 4.86,109.99 7.7,109.99 7.7,110.19 6.76,110.19 6.76,109.99 4.86,109.99 5.55,110.67 6.05,110.67
GND on TOP (solid shape): 192.4,78.83 193.65,78.83 194.38,78.83 194.42,78.8 194.42,78.16 194.37,78.11 194.19,78.11 194.09,78.11 194.07,78.09 194.06,78.09 193.94,78.01 193.86,77.89 193.86,77.88 193.71,77.73 192.77,77.73 192.74,77.75 192.74,77.77 192.6,77.99 192.36,78.06 192.29,78.09 192.25,78.16 192.25,78.17 191.38,79.04 190.84,79.04 190.8,79.06 190.79,79.09 190.79,79.51 190.97,79.69 191.55,79.69
GND on TOP (solid shape): 173.91,114.29 173.91,113.72 173.89,113.69 173.86,113.67 173.8,113.67 173.78,113.67 173.76,113.69 173.15,113.44 173.76,113.2 173.78,113.21 173.8,113.21 173.88,113.21 174.27,112.82 175.18,112.82 175.29,112.71 175.29,112.45 175.19,112.35 172.96,112.35 172.63,112.68 172.63,114.03 173.01,114.41 173.8,114.41
GND on TOP (solid shape): 187.33,64.93 190.2,64.93 190.26,64.86 190.26,64.28 190.08,64.1 187.97,64.1 187.95,64.07 187.87,64.04 187.79,64.09 187.27,64.18 187.24,63.64 187.26,63.61 187.24,63.57 186.9,63.23 186.9,62.96 186.5,62.56 186.48,62.56 186.44,62.56 186.04,62.56 185.87,62.72 185.87,63.14 186.38,63.64 186.38,64.73 186.61,64.96 187.3,64.96
GND on TOP (solid shape): 217.4,49.38 217.53,49.36 217.65,49.38 217.66,49.38 217.74,49.38 217.91,49.21 217.91,48.98 217.54,48.6 217.52,48.6 217.25,48.3 217.43,47.94 217.45,47.92 217.46,47.89 217.46,46.46 217.33,46.33 216.87,46.33 216.8,46.41 216.8,47.04 216.8,48.37 216.34,48.82 215.76,48.82 215.68,48.9 215.68,49.13 215.76,49.21 216.85,49.21 216.89,49.24 216.89,49.25 216.98,49.29 217.04,49.36 217.06,49.38 217.08,49.38 217.39,49.38
GND on TOP (solid shape): 178.01,114.33 178.01,113.92 178.88,113.06 179.36,113.06 179.45,112.97 179.45,112.69 179.38,112.63 177.94,112.63 177.89,112.64 177.86,112.64 177.56,112.64 177.4,112.58 177.34,112.43 177.34,112.15 177.35,112.09 177.38,112.03 177.38,111.42 177.35,111.36 177.34,111.3 177.34,111.22 177.15,111.03 175.88,111.03 175.8,111.1 175.8,111.44 175.88,111.51 176.79,111.51 176.94,111.66 176.94,112.51 177.07,112.63 177.07,113.47 177.06,113.48 177.06,113.78 176.92,113.92 176.92,113.93 176.89,114 176.84,114.04 176.82,114.06 176.82,114.09 176.82,114.31 176.94,114.43 177.91,114.43
GND on TOP (solid shape): 147.66,23.45 147.66,22.89 147.81,22.74 149.06,22.74 149.44,22.36 151.14,22.36 151.21,22.28 151.21,21.8 151.14,21.72 149.82,21.72 149.72,21.82 149.62,21.82 149.61,21.83 149.49,21.85 149.36,21.83 149.35,21.82 149.31,21.82 149.08,21.6 149.08,21.39 148.78,21.09 148.75,21.07 148.73,21.07 148.59,21.07 148.46,21.01 148.25,21.01 147.9,21.05 147.69,20.77 147.69,20.76 147.38,20.45 145.91,20.45 145.83,20.53 145.83,20.86 145.68,21.01 145.27,21.01 144.89,21.39 144.89,23.25 145.19,23.55 147.56,23.55
GND on TOP (solid shape): 98.05,107.57 99.88,107.57 99.98,107.47 99.98,106.55 99.94,106.46 99.85,106.45 99.72,106.47 99.6,106.45 99.52,106.45 99.47,106.5 98.98,106.67 98.84,106.18 98.84,106.08 98.75,106.02 95.84,106.02 95.61,106.25 95.61,106.99 95.92,107.29 96.25,107.29 96.73,107.78 97.85,107.78
GND on TOP (solid shape): 159.06,33.28 159.06,30.84 158.63,30.41 156.32,30.41 155.86,30.87 153.04,30.87 152.61,30.43 152.1,30.43 151.9,30.23 151.9,28.92 151.79,28.81 151.79,28.8 151.62,28.63 151.62,28.57 151.6,28.52 151.6,28.48 151.6,28.25 151.29,27.95 150.27,27.95 150.2,28.02 150.2,29.8 149.64,30.36 149.64,30.82 149.87,31.04 151.11,31.04 151.17,31.02 151.22,31.02 151.52,31.02 151.65,31.07 151.72,31.2 151.72,31.22 152.41,31.91 156.35,31.91 156.57,32.14 156.98,32.14 157.11,32.01 157.11,31.7 157.44,31.37 157.49,31.37 157.54,31.35 157.59,31.35 157.89,31.35 157.94,31.35 158,31.37 158.02,31.37 158.1,31.45 158.1,33.18 158.28,33.36 158.99,33.36
GND on TOP (solid shape): 229.98,25.78 230.28,25.07 230.99,24.77 235.6,24.77 235.6,25.17 238.4,25.17 238.75,25.03 238.89,24.68 238.89,22.84 237.25,22.84 237.11,22.7 236.63,22.7 236.58,22.75 236.58,23.12 235.64,24.06 229.92,24.06 229.4,24.53 229.07,25.14 228.91,25.3 227.92,25.3 227.52,25.71 227.52,26.45 227.9,26.83 229.98,26.83
GND on TOP (solid shape): 222.35,89.62 223.3,89.62 223.34,89.61 223.35,89.57 223.35,88.95 223.78,88.52 223.78,88.04 223.96,87.86 224.32,87.86 224.32,87.86 224.63,87.86 224.76,87.73 224.76,87.11 224.59,86.95 223.66,86.95 223.63,86.96 223.61,86.98 222.6,88.23 221.18,88.98 221.15,89 221.14,89.03 221.14,89.4 221.15,89.43 221.33,89.64 221.39,89.9 221.42,89.97 221.49,90 221.98,90
GND on TOP (solid shape): 211.62,86.64 211.62,86.38 211.57,86.33 211.57,86.26 211.33,86.03 211.01,86.03 211,86.01 210.99,86.01 210.89,85.96 210.84,85.86 210.83,85.85 210.78,85.79 210.78,85.47 210.49,85.19 208.43,85.19 208.18,85.44 208.18,85.89 208.2,85.9 209.18,85.9 209.2,85.89 209.25,85.87 209.31,85.86 209.59,85.86 209.65,85.87 209.7,85.89 209.71,85.9 209.96,85.9 209.98,85.89 210.03,85.87 210.09,85.86 210.37,85.86 210.51,85.92 210.57,86.06 210.57,86.09 210.62,86.15 210.62,86.33 210.63,86.36 210.66,86.38 210.83,86.43 210.97,86.53 211.25,86.81 211.45,86.81
GND on TOP (solid shape): 206.15,88.58 206.15,87.23 207.29,86.09 207.29,84.93 206.49,84.13 205.32,84.13 205.27,84.18 205.27,84.61 205.52,84.86 206.14,84.86 206.17,84.85 206.19,84.83 206.85,85.01 206.19,85.19 206.17,85.17 206.14,85.16 205.39,85.16 205.35,85.13 205.3,85.12 205.27,85.16 205.27,85.76 204.99,86.03 204.99,86.91 205.24,87.15 205.24,88.42 205.25,88.44 205.25,88.66 205.34,88.75 205.98,88.75
GND on TOP (solid shape): 203.94,19.09 203.94,14.15 203.81,14.02 203.69,14.02 203.23,13.57 203.23,12.68 203.01,12.45 202.99,12.45 202.82,12.4 202.68,12.25 202.65,12.25 202.3,11.82 202.78,11.56 202.8,11.57 202.83,11.56 202.94,11.45 202.94,10.95 203.02,10.88 203.02,9.01 202.7,8.69 201.51,8.69 201.25,8.95 201.25,11.18 201.79,11.71 201.79,11.75 201.94,11.9 201.94,13.42 202.45,13.92 202.56,13.92 202.62,13.98 202.63,13.98 202.76,14.11 202.76,14.12 202.78,14.14 202.78,15.54 202.76,15.56 202.76,15.77 201.89,16.64 201.58,16.64 201.43,16.79 201.43,17.43 201.86,17.86 201.86,18.34 202.52,19 202.52,19.31 202.67,19.46 203.56,19.46
GND on TOP (solid shape): 206.22,15.83 206.27,15.79 206.31,15.76 206.33,15.74 206.33,15.72 206.33,13.92 206.01,13.6 205.76,13.6 205.73,13.61 205.73,13.62 205.63,13.7 205.52,13.76 205.33,13.92 205.09,13.98 205.05,14 205.04,14.03 205.04,14.42 205.06,14.47 205.07,14.52 205.07,14.82 205.06,14.87 205.04,14.93 205.04,15.24 204.7,15.58 204.63,15.58 204.61,15.6 204.61,15.81 204.66,15.9 204.76,15.9 205,15.82 205.25,15.86 205.49,15.88 205.7,16.02 205.75,16.07 205.88,16.07 205.93,16.11 205.94,16.11
GND on TOP (solid shape): 229.98,44.84 230.28,44.13 230.99,43.83 235.6,43.83 235.6,44.23 238.9,44.23 239.25,44.09 239.39,43.74 239.39,40.28 239.25,39.93 238.9,39.79 235.6,39.79 235.6,40.19 230.99,40.19 230.28,39.89 229.98,39.18 229.98,38.14 229.93,38.08 228,38.08 227.41,38.66 227.41,39.27 228.66,40.52 228.66,43.62 227.47,44.81 227.47,45.6 228.05,46.18 229.98,46.18
GND on TOP (solid shape): 224.52,109.02 224.52,106.74 224.32,106.54 224.22,106.54 224.01,106.61 223.8,106.54 223.66,106.54 223.63,106.52 223.59,106.53 223.34,106.61 223.1,106.48 223.08,106.47 223.05,106.47 223.03,106.47 223.01,106.48 222.74,106.61 222.47,106.48 222.44,106.47 222.42,106.47 222.39,106.47 222.38,106.48 222,106.59 221.75,106.29 221.75,106.27 221.72,106.25 221.72,104.9 221.47,104.65 220.24,104.65 220.13,104.76 220.13,105.15 219.85,105.44 219.49,105.44 218.96,105.97 218.96,108.69 219.15,108.88 221.72,108.88 222,109.15 224.39,109.15
GND on TOP (solid shape): 179.46,81.67 179.5,81.65 179.51,81.61 179.51,80.08 179.44,80.02 179.41,80 179.37,80.02 179.36,80.02 179.35,80.04 179.36,80.06 179.33,80.22 179.24,80.36 179.21,80.42 179.23,80.5 178.94,81.09 178.72,80.47 178.76,80.4 178.73,80.32 178.65,80.15 178.67,79.96 178.66,79.87 178.57,79.83 177.8,79.83 177.73,79.89 177.73,80.53 178.1,80.89 178.1,81.58 178.18,81.67
GND on TOP (solid shape): 241,11.53 241.35,11.39 241.49,11.04 241.49,1.99 239.56,0.46 237.1,0.59 236.67,0.95 236.51,1.5 236.51,1.83 236.51,2.43 236.4,3.08 236.09,3.66 235.81,4.01 235.28,4.44 234.62,4.6 214.29,4.6 214.29,4.1 209.82,4.1 209.72,4.2 209.72,5.06 209.78,5.11 213.28,5.11 213.28,5.61 217.02,5.61 217.32,5.31 228.92,5.31 229.63,6.02 229.63,8.54 230.03,8.93 235.61,8.93 237.47,10.8 237.47,11.41 237.6,11.53
GND on TOP (solid shape): outline of 118 points within 113.65,38.18 119.24,42.98
GND on TOP (solid shape): outline of 89 points within 181.66,28.08 198.99,35.24
GND on TOP (solid shape): outline of 119 points within 181.49,38 190.91,39.91
GND on TOP (solid shape): 171.15,32.87 173.02,32.87 173.12,32.77 174.67,32.77 174.71,32.76 174.72,32.72 174.72,32.55 174.91,32.55 174.97,32.53 175.01,32.52 175.3,32.52 175.32,32.52 175.34,32.5 175.72,32.41 175.95,32.72 175.96,32.74 175.98,32.77 177.83,32.77 178.04,32.57 178.04,31.07 177.66,30.69 174.99,30.69 174.66,30.36 173.13,30.36 172.27,31.22 172.27,31.24 172.02,31.52 171.66,31.43 171.29,31.43 171.17,31.3 169.83,31.3 169.69,31.36 169.54,31.3 169.43,31.3 169.29,31.36 169.14,31.3 169.03,31.3 168.89,31.36 168.74,31.3 168.63,31.3 168.49,31.36 168.34,31.3 168.23,31.3 168.09,31.36 167.94,31.3 167.83,31.3 167.79,31.33 167.74,31.35 167.72,31.37 166.72,31.37 166.64,31.3 166.58,31.3 166.51,31.22 165.03,31.22 164.96,31.3 164.96,31.83 165.06,31.93 165.51,31.93 166.02,32.44 170.04,32.44 170.39,32.8 170.39,33 170.49,33.1 170.92,33.1
GND on TOP (solid shape): 233.12,86.24 233.2,86.23 233.44,86.13 233.7,86.1 233.77,86.1 233.77,86.03 233.76,86.02 233.68,85.23 234.35,84.81 236.79,84.81 236.79,81.06 239.39,81.06 239.39,80.61 239.39,80.37 239.25,80.02 238.9,79.88 232.55,79.88 231.58,79.13 232.04,78 232.04,77.2 231.03,77.2 231.03,77.54 230.53,78.91 231.08,80.26 231.08,82.23 231.22,82.38 231.22,84.94 231.69,85.4 231.69,85.76 231.74,85.84 231.84,85.84 232.52,85.77 233.06,86.19
GND on TOP (solid shape): 184.56,23.41 184.65,23.36 184.65,23.25 184.95,22.71 185.25,23.25 185.25,23.36 185.34,23.41 186.43,23.41 186.57,23.28 186.57,23.12 186.81,22.87 187.08,22.87 187.16,22.8 187.16,20.15 187.53,19.77 187.53,19.49 187.35,19.31 187.25,19.31 187.24,19.29 186.71,19.29 186.62,19.34 186.62,19.44 186.57,19.88 186.13,19.93 186.05,19.91 185.99,19.95 185.49,20.04 185.4,19.55 185.4,19.44 185.25,19.29 184.71,19.29 184.27,19.74 184.26,19.74 184.2,19.79 183.07,19.79 182.74,20.01 182.41,19.77 182.39,19.75 182.36,19.74 181.5,19.74 181.41,19.83 181.41,20.48 181.56,20.64 183.63,20.64 183.83,20.84 183.83,23.03 184.21,23.41
GND on TOP (solid shape): 232.04,65.24 231.56,64.18 232.4,63.37 232.47,63.36 240,63.36 240.35,63.22 240.49,62.87 240.49,62.17 240.35,61.82 240,61.68 238.49,61.68 238.49,59.34 238.35,58.99 238,58.85 235.6,58.85 235.6,59.25 230.99,59.25 230.28,58.95 229.98,58.24 229.98,57.08 227.87,57.08 227.49,57.46 227.49,58.3 227.97,58.77 229.04,58.77 229.09,58.93 229.15,59.08 229.81,59.89 230.79,60.25 231.05,60.51 231.05,61.52 231.34,61.81 231.34,62.75 230.6,63.82 230.67,65.13 230.83,65.43 231.03,65.7 231.03,65.97 232.04,65.97
GND on TOP (solid shape): 235.52,112.76 235.71,112.41 236.09,112.28 236.16,112.25 236.19,112.18 236.19,111.96 235.73,110.82 236.7,110.08 241.5,110.08 241.85,109.94 241.99,109.59 241.99,109.01 241.85,108.66 241.5,108.52 239.85,108.52 239.85,103.58 239.45,103.18 233.16,103.18 232.65,103.69 232.65,104.72 232.72,104.82 234.14,104.41 234.93,105.52 234.93,106.03 233.75,107.21 232.57,106.03 232.57,105.49 232.52,105.44 231.76,106.2 231.76,107.8 231.86,107.9 234.41,107.9 234.74,108.23 234.74,110.57 234.68,111.06 234.73,111.55 234.77,111.65 234.79,111.75 234.81,111.81 234.83,111.87 234.83,112.71 234.93,112.81 235.51,112.81
GND on TOP (solid shape): 90.58,86.26 90.58,85.69 90.57,85.66 90.55,85.64 90.34,85.1 90.92,85.08 90.99,85.12 91.07,85.08 91.49,85.01 91.63,85.42 91.64,85.51 91.73,85.55 92.31,85.55 92.33,85.54 92.34,85.51 92.34,85.48 92.37,85.17 92.64,85.02 92.71,84.99 92.74,84.92 92.74,84 92.44,83.7 92.07,83.7 91.98,83.75 91.98,83.85 91.7,84.36 91.42,83.85 91.42,83.75 91.34,83.7 90.88,83.7 90.79,83.75 90.79,83.85 90.51,84.36 90.23,83.85 90.23,83.75 90.14,83.7 89.87,83.7 89.67,83.9 89.66,83.93 89.66,83.95 89.57,84.29 89.24,84.37 89.21,84.37 89.19,84.38 89.11,84.46 86.5,84.46 86.34,84.61 86.34,85.98 86.7,86.34 90.51,86.34
GND on TOP (solid shape): outline of 210 points within 64.58,104.68 77.58,121.52
GND on TOP (solid shape): outline of 247 points within 226.81,117.36 240.88,124.78
GND on TOP (solid shape): outline of 972 points within 99.04,83.34 113.95,90.66
GND on TOP (solid shape): outline of 923 points within 124.67,87.89 133.89,97.55
GND on TOP (solid shape): outline of 419 points within 0.51,4.1 215.52,137.18
GND on BOTTOM (solid shape): 44.66,72.7 44.66,70.64 44.23,70.21 40.98,70.21 40.6,70.59 40.6,72.62 40.93,72.95 44.41,72.95
GND on BOTTOM (solid shape): 128.84,25.76 128.84,23.35 128.71,23.22 126.3,23.22 126.07,23.45 126.07,25.84 126.22,25.99 128.61,25.99
GND on BOTTOM (solid shape): 151.87,107.22 151.87,104.96 151.75,104.83 150.6,104.83 149.59,105.85 149.59,107.14 149.92,107.47 151.62,107.47
GND on BOTTOM (solid shape): 155.68,82.83 155.68,81.17 155.42,80.9 152.51,80.9 152.33,81.08 152.33,82.56 152.66,82.89 155.63,82.89
GND on BOTTOM (solid shape): 162.7,122.38 162.7,120.25 162.59,120.15 160.32,120.15 159.77,120.69 159.77,123.32 159.95,123.5 161.58,123.5
GND on BOTTOM (solid shape): 208.19,112.32 208.19,107.5 207.98,107.29 205.01,107.29 204.8,107.51 204.8,111.96 205.32,112.48 208.03,112.48
GND on BOTTOM (solid shape): 219.77,65.64 219.77,65.23 217.89,63.35 216.04,63.35 215.91,63.48 215.91,64.67 217.46,66.22 219.18,66.22
GND on BOTTOM (solid shape): 224.34,60.56 224.34,57.56 224.1,57.32 221.74,57.32 221.6,57.46 221.6,60.66 221.93,60.99 223.91,60.99
GND on BOTTOM (solid shape): 174.37,28.87 174.67,28.87 174.91,28.63 174.91,26.67 174.53,26.29 169.83,26.29 169.43,26.7 169.43,28.33 169.99,28.89 174.35,28.89
GND on BOTTOM (solid shape): 197.44,35.54 197.44,34.98 196.66,34.19 194.24,34.19 194.17,34.27 194.17,35.39 194.85,36.07 196.91,36.07
GND on BOTTOM (solid shape): 225.41,74.61 225.41,74 225.26,73.85 225.26,73.06 224.77,72.57 223.88,72.57 223.76,72.7 223.76,73.72 224.77,74.73 225.28,74.73
GND on BOTTOM (solid shape): 146.03,17.51 146.03,16.53 146.03,16.53 146.03,15.97 145.85,15.79 144.34,15.79 144.26,15.87 144.26,17.47 144.36,17.57 145.97,17.57
GND on BOTTOM (solid shape): 46.59,129.04 46.59,127.01 46.24,126.65 46.24,125.84 46.03,125.63 42.58,125.63 42.12,126.09 42.12,129.01 42.38,129.27 43.52,129.27 43.98,129.72 45.91,129.72
GND on BOTTOM (solid shape): 56.93,98.07 56.93,94.77 56.73,94.57 54.87,94.57 54.62,94.82 54.62,97.41 54.87,97.67 55.61,97.67 55.81,97.87 55.81,98.23 55.94,98.35 56.65,98.35
GND on BOTTOM (solid shape): 84.08,102.2 84.08,99.27 83.7,98.89 79.1,98.89 78.9,99.09 78.9,103.13 79.23,103.47 82.82,103.47
GND on BOTTOM (solid shape): 113.52,119.95 113.52,119.59 113.32,119.39 112.68,119.39 111.89,118.6 108.57,118.6 108.44,118.73 108.44,119.42 108.53,119.51 111.47,119.51 112.12,120.16 113.31,120.16
GND on BOTTOM (solid shape): 118.09,55.4 118.09,52.08 119.24,50.93 119.24,50.68 119.03,50.48 118.68,50.48 118.37,50.78 114.49,50.78 114.44,50.83 114.44,55.4 114.49,55.45 118.04,55.45
GND on BOTTOM (solid shape): 58.51,72.85 58.53,72.85 58.55,72.84 58.6,72.79 61.33,72.79 61.81,72.32 61.81,71.1 61.25,70.54 56.37,70.54 55.74,71.18 55.74,72.47 56.12,72.85
GND on BOTTOM (solid shape): 120.58,29.14 120.58,25.51 120.1,25.02 118.27,25.02 117.28,26.02 117.28,26.78 116.98,27.08 114.74,27.08 114.56,27.26 114.56,27.92 114.57,28.61 115.91,29.95 119.77,29.95
GND on BOTTOM (solid shape): 44.75,30.95 44.75,28.95 45.19,28.5 45.19,28.12 45.07,28 43.8,28 43.73,28.06 43.73,28.74 43.58,28.89 43.13,28.89 42.9,29.11 42.9,31.26 43.05,31.41 44.29,31.41
GND on BOTTOM (solid shape): 76.9,84.59 76.9,84.19 75.88,83.16 75.65,83.16 73.13,85.68 72.7,85.68 72.4,85.37 72.14,85.37 71.76,85.76 71.76,85.98 72.62,86.84 74.65,86.84
GND on BOTTOM (solid shape): 95.2,102.31 95.22,102.28 95.23,102.26 95.23,102.09 94.34,101.2 94.34,100.54 94.21,100.42 93.58,100.42 93.2,100.79 93.2,102.44 93.4,102.65 94.86,102.65
GND on BOTTOM (solid shape): 154.87,103.51 154.87,102.65 154.67,102.45 152.72,102.45 152.71,102.44 152.32,102.44 151.87,102.9 151.87,102.94 151.75,103.06 151.28,103.06 151.12,103.22 151.12,103.56 151.19,103.64 154.75,103.64
GND on BOTTOM (solid shape): 190.99,61.63 190.99,60.76 190.79,60.56 187.84,60.56 187.82,60.55 187.8,60.56 187.77,60.58 187.77,60.61 187.77,62.46 187.62,62.6 187.62,63.13 187.76,63.28 189.35,63.28
GND on BOTTOM (solid shape): 209.5,74.21 209.5,73.15 209.18,72.83 209.18,72.67 208.69,72.18 208.69,71.69 208.55,71.55 207.63,71.55 207.42,71.76 207.42,74.61 207.44,74.64 207.48,74.66 209.05,74.66
GND on BOTTOM (solid shape): 60.95,87.39 60.95,81.81 61.96,80.81 61.96,76.66 61.7,76.4 58.58,76.4 58.07,76.91 58.07,87.28 58.41,87.62 60.72,87.62
GND on BOTTOM (solid shape): 10.19,116.82 10.19,116.29 10.09,116.18 8.03,116.18 8.03,116.19 7.28,116.19 7.17,116.23 7.05,116.23 7.03,116.24 7.01,116.25 6.89,116.36 6.89,116.85 7.04,117 10.02,117
GND on BOTTOM (solid shape): 50.43,55.42 50.43,53.71 50.48,53.67 50.48,50.93 50.26,50.72 46.1,50.72 45.73,51.08 45.73,52.79 44.87,53.65 44.87,54.72 45.3,55.15 46.64,55.15 48.09,56.6 48.12,56.6 48.24,56.72 49.13,56.72
GND on BOTTOM (solid shape): 127.85,55.1 127.85,52.76 128.02,52.58 129.04,52.58 129.07,52.56 129.57,52.56 129.88,52.25 129.88,51.57 129.09,50.78 123.96,50.78 123.89,50.85 123.89,55.53 123.9,55.57 123.94,55.58 127.36,55.58
GND on BOTTOM (solid shape): 143.42,34.93 143.42,34.6 143.32,34.5 142.99,34.5 142.5,34.02 140.34,34.02 140.06,33.74 140.06,32.77 140.17,32.67 140.42,32.67 140.78,32.31 140.78,32.06 140.6,31.88 139.25,31.88 139.02,32.11 139.02,34.68 139.4,35.06 143.29,35.06
GND on BOTTOM (solid shape): 159.74,24.3 159.74,22.69 159.95,22.47 159.95,21.11 159.52,20.68 159.52,19.03 159.44,18.95 159.04,18.95 158.15,19.84 158.15,19.9 158.18,19.93 158.18,21.95 159.09,22.87 159.09,24.26 159.32,24.49 159.55,24.49
GND on BOTTOM (solid shape): 169.5,35.69 169.5,31.58 169.15,31.22 164.09,31.22 163.97,31.35 163.97,34.74 163.97,34.82 164.19,35.04 164.46,35.04 165.38,35.96 166.57,35.96 166.58,35.97 169.22,35.97
GND on BOTTOM (solid shape): 70.32,82.63 70.32,82.48 68.59,80.75 68.59,80.4 68.72,80.27 68.72,71.73 68.54,71.56 67.67,71.56 67.47,71.76 67.47,76.92 67.64,77.09 67.64,77.66 68.11,78.13 68.11,81.11 67.8,81.41 67.8,81.62 69.43,83.24 69.71,83.24
GND on BOTTOM (solid shape): 164.97,23.69 164.97,23.22 165.29,22.91 165.29,22.33 165.03,22.08 164.33,22.08 164.01,22.4 163.46,22.4 163.38,22.48 163.38,22.94 163.58,23.14 164.14,23.14 164.24,23.25 164.24,23.27 164.27,23.3 164.29,23.3 164.29,23.77 164.45,23.93 164.73,23.93
GND on BOTTOM (solid shape): 220.84,109.2 220.84,107.17 221.62,106.38 221.62,104.9 221.38,104.66 220.43,104.66 220.2,104.88 220.2,105.18 219.96,105.42 219.44,105.42 218.72,106.14 218.72,109.24 218.8,109.33 220.71,109.33
GND on BOTTOM (solid shape): 54.14,103.18 54.14,102.68 54.18,102.64 55.03,102.64 55.05,102.62 55.05,102.42 55.02,102.39 54.15,102.39 54.06,102.3 54.06,101.35 53.98,101.28 53.27,101.28 53.2,101.35 53.2,103.18 53.27,103.26 54.06,103.26
GND on BOTTOM (solid shape): 95.59,80.3 95.59,80.09 95.44,79.94 95.44,79.53 95.28,79.38 94.42,79.38 94.37,79.43 92.95,79.43 92.71,79.67 92.71,80.18 92.81,80.28 93.9,80.28 93.98,80.2 94.48,80.2 94.66,80.38 95.14,80.38 95.51,80.38
GND on BOTTOM (solid shape): 129.47,125.79 129.63,125.79 129.63,125.78 130.09,125.78 130.13,125.74 130.13,125.58 130.12,125.55 130.08,125.53 129.24,125.53 129.14,125.43 128.25,125.43 128.13,125.3 126.42,125.3 126.3,125.43 126.3,126.4 126.37,126.47 128.79,126.47
GND on BOTTOM (solid shape): 202.49,11.47 202.81,11.47 202.9,11.38 202.9,11.05 202.45,10.6 202.45,9.99 202.32,9.86 201.4,9.86 201.28,9.99 199.42,9.99 199.35,10.06 199.35,11.11 199.36,11.15 199.4,11.17 201.49,11.17 201.95,11.63 202.33,11.63
GND on BOTTOM (solid shape): 214.49,114.84 214.49,113.52 214.31,113.34 214.31,111.93 214.16,111.78 214.16,111.62 214.07,111.53 213.1,111.53 212.96,111.66 212.96,112.1 212.83,112.22 212.63,112.22 212.6,112.23 212.33,112.5 212.33,114.94 212.56,115.17 214.16,115.17
GND on BOTTOM (solid shape): 42.27,115.98 42.27,114.66 41.92,114.31 41.92,113.49 41.79,113.37 37.27,113.37 36.94,113.04 36.08,113.04 35.92,113.19 35.92,113.47 36.05,113.59 36.84,113.59 37.07,113.82 37.07,114.03 37.17,114.13 38.49,114.13 38.54,114.08 39.89,114.08 40.27,114.46 40.27,115.04 41.49,116.26 41.99,116.26
GND on BOTTOM (solid shape): 140.79,112.44 141.7,112.44 141.87,112.27 141.87,110.37 140.17,108.67 136.89,108.67 136.69,108.87 136.69,109.31 136.75,109.38 138.81,109.38 139.85,110.42 139.85,111.72 140.04,111.91 140.04,112.09 140.05,112.09 140.05,112.6 140.06,112.64 140.1,112.65 140.57,112.65
GND on BOTTOM (solid shape): 146.19,21.93 146.67,21.93 146.79,22.05 146.79,22.54 146.95,22.69 148.42,22.69 148.43,22.67 149.04,22.67 149.21,22.51 149.21,21.72 148.75,21.27 146.82,21.27 146.57,21.01 145.98,21.01 145.49,21.51 145.49,21.61 145.4,21.7 143.49,21.7 143.32,21.87 143.32,22.66 143.34,22.69 145.42,22.69
GND on BOTTOM (solid shape): 84.92,34.88 86.34,34.88 86.93,35.47 92.74,35.47 93.38,34.83 93.38,32.92 93.05,32.59 86.93,32.59 86.83,32.7 86.83,33.46 86.39,33.89 83.7,33.89 83.09,33.28 82.48,33.28 82.18,32.97 80.6,32.97 80.37,33.2 80.37,34.47 80.68,34.78 82.91,34.78 83.61,35.47 84.33,35.47
GND on BOTTOM (solid shape): 135.78,28.66 138.84,28.66 139.71,27.79 141.03,27.79 141.11,27.72 141.11,26.22 141.05,26.17 140.24,26.17 139.52,25.44 136.94,25.44 136.36,26.03 136.11,26.03 135.95,26.19 135.95,26.37 135.9,26.42 135.9,26.47 135.21,27.15 135.21,28.25 134.95,28.52 133.8,28.52 133.71,28.61 133.71,29.11 133.92,29.32 135.12,29.32
GND on BOTTOM (solid shape): 149.56,17.51 149.56,17.2 150.07,16.69 150.07,15.25 150.02,15.19 149.51,15.19 149.36,15.35 148.91,15.35 148.83,15.34 148.73,15.32 148.65,15.32 148.52,15.45 148.52,16.01 148.17,16.36 148.17,16.77 148.22,16.82 148.57,16.82 148.71,16.96 148.71,17.52 148.83,17.63 149.44,17.63
GND on BOTTOM (solid shape): 200.39,43.59 200.39,43.32 200.9,42.81 200.9,40.28 200.25,39.64 199.75,39.64 199.54,39.85 199.54,40.01 199.52,40.19 199.42,40.33 199.4,40.37 199.4,41.61 198.84,42.17 198.84,43.36 199.19,43.72 199.2,43.72 199.4,43.92 200.06,43.92
GND on BOTTOM (solid shape): 39.99,58.86 40.88,58.86 41.16,58.58 41.16,56.72 41,56.57 41,56.57 40.42,55.99 39.94,55.99 39.51,56.42 39.51,57.51 39.02,57.99 38.49,57.99 38.48,58 38.34,58.03 38.2,58 38.19,57.99 37.8,57.99 37.63,58.17 37.63,59.39 37.83,59.59 39.25,59.59
GND on BOTTOM (solid shape): 54.08,119.46 54.08,118.92 54.13,118.87 55,118.87 55.04,118.86 55.05,118.82 55.05,118.67 55.04,118.63 55,118.62 54.21,118.62 54.11,118.52 54.11,117.61 54.06,117.56 53.25,117.56 53.2,117.61 53.2,119.44 53.25,119.49 54.06,119.49
GND on BOTTOM (solid shape): 106.54,129.42 106.54,127.9 106.56,127.88 106.56,127.83 106.67,127.72 107.3,127.72 107.37,127.64 109.28,127.64 109.3,127.62 109.3,126.09 108.86,125.65 108.45,125.65 108.42,125.61 107.76,125.61 106.54,124.39 101.99,124.39 100.47,125.91 92.95,125.91 89.01,121.98 82.66,121.98 82.53,122.1 82.53,125.33 82.66,125.46 84.82,125.46 89.04,129.67 106.28,129.67
GND on BOTTOM (solid shape): 47.73,65.77 47.73,65.55 47.73,65.53 47.71,65.51 47.54,65.21 47.71,64.9 47.73,64.88 47.73,64.86 47.73,64.65 45.07,61.98 41.16,61.98 40.78,62.36 40.78,64.39 42.45,66.07 47.43,66.07
GND on BOTTOM (solid shape): 54.08,111.54 54.08,111.18 54.21,111.05 54.22,111.05 54.26,111.04 54.27,111 54.97,111 55.01,110.98 55.02,110.95 55.02,110.8 55.01,110.76 54.97,110.75 54.11,110.75 54.06,110.7 54.06,109.73 54.01,109.68 53.25,109.68 53.2,109.73 53.2,111.51 53.27,111.59 54.03,111.59
GND on BOTTOM (solid shape): 187.15,25.1 187.15,20.28 187.16,20.27 187.16,20.25 187.43,19.98 187.47,19.93 187.52,19.9 187.56,19.85 187.56,18.47 187.82,18.22 190.74,18.22 191.12,18.6 191.12,19.36 191.37,19.61 191.88,19.61 191.91,19.59 191.91,17.35 191.75,17.2 187.77,17.2 186.88,18.09 186.88,19.88 185.36,21.4 185.36,23.53 185.37,23.54 185.37,24.44 185.36,24.45 185.36,24.62 185.96,25.23 187.02,25.23
GND on BOTTOM (solid shape): 156.37,27.08 156.37,26.32 156.29,26.24 155.76,26.24 155.66,26.14 155.66,25.95 155.02,25.31 155.01,25.31 154.71,25.01 154.71,24.54 155.14,24.11 156.16,24.11 156.24,24.04 156.24,23.45 156.44,23.25 156.44,22.28 156.02,21.86 155.65,21.86 155.65,21.85 155.54,21.85 155.53,21.84 153.58,21.84 153.44,21.98 153.44,23.48 153.89,23.93 153.89,25.63 154.03,25.76 154.65,25.76 154.84,25.95 154.84,27.39 155.01,27.56 155.89,27.56
GND on BOTTOM (solid shape): 12.99,113.12 12.99,112.63 12.53,112.17 12.53,111.77 12.2,111.44 11.84,111.44 11.36,110.95 9.66,110.95 9.46,111.16 9.46,111.92 9.66,112.12 11.08,112.12 11.54,112.58 11.64,112.58 11.65,112.57 12.01,112.64 12.12,113 12.11,113.01 12.12,113.04 12.28,113.2 12.91,113.2
GND on BOTTOM (solid shape): 59.16,34.35 59.16,33.97 59.1,33.69 59.27,33.45 59.28,33.43 59.29,33.41 59.29,33.33 59.28,33.29 59.24,33.28 56.83,33.28 56.59,33.52 56.59,33.85 56.42,34.02 55.02,34.02 54.97,33.97 54.08,33.97 53.96,34.09 53.96,34.35 54.21,34.6 58.91,34.6
GND on BOTTOM (solid shape): 208.34,67.22 208.37,67.21 209.56,66.02 209.56,65.2 209.61,65.15 209.61,64.77 209.5,64.67 209.02,64.67 208.6,65.08 208.6,65.22 208.59,65.27 208.59,65.43 208.17,65.85 207.65,65.85 207.62,65.86 207.53,65.95 207.43,65.98 207.24,65.98 206.93,66.29 206.93,67.11 207.04,67.22
GND on BOTTOM (solid shape): 228.35,8.08 228.35,7.9 228.35,7.88 228.04,7.02 227.97,6.1 227.97,6.08 227.96,6.06 227.84,5.94 227.81,5.93 227.8,5.94 227.24,6.07 226.68,6.12 224.86,6.12 224.49,6.48 224.49,7.7 224.72,7.93 225.89,7.93 226.22,8.26 228.18,8.26
GND on BOTTOM (solid shape): 130.95,121.25 130.95,120.86 130.67,120.58 130.67,120.38 130.49,120.2 128.08,120.2 127.89,120.39 127.89,120.93 128.15,121.18 128.38,121.18 128.49,121.2 128.56,121.28 128.57,121.29 128.59,121.31 129.11,121.31 129.13,121.3 129.15,121.29 129.43,121.2 129.68,121.35 129.7,121.36 129.72,121.37 130.83,121.37
GND on BOTTOM (solid shape): 140.44,122.05 140.44,121.81 140.44,118.99 140.45,118.95 140.62,118.78 141.77,118.78 141.99,119 144.43,119 144.6,118.84 144.6,118.14 144.58,118.11 144.56,118.1 144.4,118.02 144.3,117.87 144.28,117.85 144.25,117.84 142.58,117.84 142.01,118.4 139.88,118.4 139.28,119 136.01,119 135.47,119.55 135.47,122.03 135.67,122.23 140.27,122.23
GND on BOTTOM (solid shape): 196.96,69.65 196.96,69.63 197.06,69.37 197.33,69.21 197.34,69.18 197.34,69.02 197.27,68.95 196.74,68.95 196.55,68.76 196.55,66.3 196.25,65.99 193.54,65.99 193.38,66.15 193.38,68.26 193.51,68.38 194.6,68.38 194.83,68.61 194.92,68.61 195.64,69.33 195.64,69.42 196.12,69.91 196.71,69.91
GND on BOTTOM (solid shape): 198.1,73.49 198.1,73.14 198.1,73.14 198.1,71.6 198.07,71.57 197.83,71.57 197.8,71.6 197.8,73.21 197.77,73.24 196.65,73.24 196.6,73.19 196.6,71.73 196.54,71.63 196.43,71.66 196.3,71.79 196.3,73.2 196.26,73.24 195.41,73.24 195.37,73.25 195.36,73.29 195.36,73.94 195.83,74.4 197.19,74.4
GND on BOTTOM (solid shape): 228.06,107.71 228.81,107.71 228.85,107.7 228.86,107.67 228.89,107.54 228.96,107.44 228.99,107.37 228.86,107.05 228.96,106.81 228.98,106.7 228.89,106.63 227.69,106.63 227.3,107.03 227.3,107.89 227.39,107.98 227.8,107.98
GND on BOTTOM (solid shape): 231.88,107.65 231.88,107.1 231.76,106.98 230.69,106.98 230.59,106.87 230.59,106.43 230.46,106.3 229.73,106.3 229.4,106.63 229.38,106.63 229.35,106.66 229.35,106.69 229.35,106.71 229.37,106.73 229.57,106.99 229.47,107.3 229.45,107.37 229.47,107.44 229.54,107.54 229.57,107.67 229.57,107.69 229.6,107.71 231.82,107.71
GND on BOTTOM (solid shape): 134.63,34.42 134.63,32.25 134.25,31.87 134.23,31.86 134.22,31.86 133.99,31.85 133.93,31.84 133.87,31.82 133.86,31.81 133.62,31.81 133.61,31.82 133.55,31.84 133.49,31.85 133.21,31.85 133.15,31.84 133.09,31.82 133.08,31.81 132.77,31.81 132.73,31.84 132.66,31.87 132.39,32.14 132.39,32.32 132.42,32.47 132.4,32.59 132.39,32.6 132.39,34.45 132.52,34.57 134.48,34.57
GND on BOTTOM (solid shape): 156.9,76.48 156.94,76.46 156.94,76.41 157.08,75.89 157.57,76.08 157.65,76.15 157.74,76.12 157.99,75.87 157.99,75.57 158.07,75.49 158.07,73.92 157.87,73.72 156.78,73.72 156.52,73.97 156.52,76.15 156.85,76.48
GND on BOTTOM (solid shape): 90.86,89.97 90.86,89.24 90.61,88.98 89.06,88.98 88.33,88.97 88.24,88.24 88.25,88.21 88.23,88.18 88.12,88.07 85.82,88.07 82.9,85.14 82.02,85.14 81.9,85.27 81.9,86.16 81.83,86.24 80.73,86.24 80.21,86.76 77.57,86.76 77.16,87.17 77.16,89.86 77.4,90.1 90.74,90.1
GND on BOTTOM (solid shape): 227.06,70.29 227.06,69.65 226.88,69.47 226.88,65.52 226.72,65.37 226.71,65.34 226.35,64.98 226.35,64.62 226.34,64.6 226.33,64.58 226.1,64.17 226.26,63.72 226.39,63.6 226.84,63.6 226.93,63.51 226.93,63.18 226.78,63.03 226.45,63.03 226.31,62.9 226.29,62.9 225.79,62.9 225.69,63 225.69,68.1 225.92,68.33 225.92,68.89 226.55,69.53 226.55,70.29 226.68,70.41 226.93,70.41
GND on BOTTOM (solid shape): 152.78,35.13 152.8,35.13 152.82,35.11 153.21,34.84 153.67,34.95 153.7,34.96 153.73,34.95 154.12,34.83 154.49,34.99 154.63,35.13 156.47,35.13 156.78,34.83 156.78,32.29 157.12,31.95 157.12,31.03 156.78,30.69 152.92,30.69 151.75,31.86 151.75,34.7 152.18,35.13
GND on BOTTOM (solid shape): 215.63,32.31 215.63,27.74 214.36,26.47 208.26,26.47 207.12,25.33 207.12,24.44 206.97,24.29 206.6,24.29 205.66,24.29 205.37,24.58 202.46,24.58 202.39,24.52 202.07,24.52 200.21,26.37 199.64,26.37 199.42,26.45 199.2,26.37 195.89,26.37 195.74,26.52 195.22,26.52 194.51,26.52 193.78,25.8 193.78,25.76 192.74,24.72 192.22,24.72 191.99,24.49 191.99,20.57 191.9,20.48 191.9,19.43 191.75,19.27 191.2,19.27 191.1,19.38 191.1,25.99 191.25,26.14 192.11,26.14 193.18,27.21 193.18,29.09 193.66,29.57 196.02,29.57 196.35,29.57 196.91,29.01 200.16,29.01 204.61,33.46 206.87,33.46 207.75,34.35 213.6,34.35
GND on BOTTOM (solid shape): 229.98,25.78 230.28,25.07 230.99,24.77 235.6,24.77 235.6,25.17 238.4,25.17 238.75,25.03 238.89,24.68 238.89,22.82 237.88,22.82 237.88,24.15 236.61,24.15 236.61,23.75 235.92,23.75 235.62,24.06 230.01,24.06 229.7,23.75 228.46,23.75 228.28,23.93 228.28,24.03 227.97,24.34 227.97,24.39 227.91,24.53 227.77,24.59 227.72,24.59 227.52,24.8 227.52,26.78 227.72,26.98 229.98,26.98
GND on BOTTOM (solid shape): 135.23,101.75 135.4,101.75 135.47,101.68 135.47,100.97 135.87,100.56 135.9,100.56 135.98,100.49 136.32,100.36 136.62,100.54 136.64,100.56 136.67,100.56 136.89,100.56 137.09,100.36 137.09,100.06 137.17,99.98 137.7,99.98 138.02,99.66 138.02,99.61 137.91,99.5 137.66,99.5 137.66,99.5 136.79,99.5 136.69,99.6 136.69,99.8 136.48,100.01 135.52,100.01 135.51,100.01 135.4,100.03 135.28,100.01 135.28,100.01 134.96,100.01 134.6,99.65 134.32,99.65 134.27,99.7 134.27,99.98 134.55,100.26 134.6,100.31 134.86,100.31 135.06,100.51 135.06,101.68 135.14,101.76 135.23,101.76
GND on BOTTOM (solid shape): 149.36,87.74 149.36,86.87 149.16,86.67 148.67,86.67 148.57,86.77 148.57,87.2 148.39,87.39 148.38,87.4 148.33,87.5 148.24,87.55 148.2,87.56 148.2,87.77 147.84,88.35 147.86,87.66 147.9,87.65 147.9,87.56 147.71,87.56 147.58,87.43 147.58,86.9 147.48,86.8 146.69,86.8 146.46,86.57 146.08,86.57 145.98,86.67 145.98,87.12 146.81,87.95 147.22,87.95 147.22,88.36 147.41,88.55 148.55,88.55
GND on BOTTOM (solid shape): 217.12,49.29 217.19,49.27 217.46,49.16 217.75,49.2 217.84,49.19 217.89,49.11 217.89,49.03 217.46,48.6 217.44,48.57 217.43,48.56 217.24,48.26 217.42,47.94 217.44,47.92 217.45,47.9 217.45,47.59 216.87,47.02 215.57,47.02 215.1,46.55 215.1,46.54 214.94,46.39 214.94,45.88 214.75,45.69 213.58,45.69 213.39,45.88 213.39,47.27 215.32,49.21 216.54,49.21 216.81,49.15 217.06,49.27
