# Allegro board dax8jmb16e0-e-www.DeviceDB.xyz_.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MDI0+_1: length 30.6
  IN2 w0.114: CN4000.1 231.24,90.14 231,89.9 231,88.73 228.79,86.52 228.79,76.79 227.21,75.21 227.21,70.09 223.7,66.58 222.9,66.58 v2(222.61,66.29)
  BOTTOM w0.097: U4001.23 221.67,66.17 222.11,66.6 222.5,66.6 222.61,66.49 v2(222.61,66.29)
MDI0-: length 17.6
  TOP w0.097: v2(200.35,66.93) 200.07,66.65 200,66.65 199.75,66.39 199.75,65.92 199.51,65.69 198.96,65.69 198.87,65.79 198.24,65.79 198.05,65.97 197.7,65.97 197.55,66.11 U4000.2
  BOTTOM w0.097: v2(200.35,66.93) 200.59,66.7 201.52,66.7 203.27,68.45 205.15,68.45 205.28,68.58 208.75,68.58 210.61,66.73 210.78,66.73 211.23,67.17 U4001.3
MDI0-_1: length 30.5
  IN2 w0.114: v2(222.61,67.05) 222.85,66.81 223.6,66.81 226.98,70.19 226.98,75.31 228.56,76.88 228.56,86.62 230.77,88.83 230.77,90.13 230.65,90.24 CN4000.2
  BOTTOM w0.097: U4001.22 221.67,67.17 222.04,66.8 222.36,66.8 v2(222.61,67.05)
MDI1+: length 16.6
  TOP w0.097: v2(198.92,66.58) 198.66,66.83 198.22,66.83 198.04,67.01 197.75,67.01 197.65,66.91 U4000.4
  BOTTOM w0.097: v2(198.92,66.58) 199.2,66.86 199.35,66.86 199.97,67.48 199.97,67.64 200.31,67.97 202.12,67.97 203.21,69.06 209.65,69.06 210.19,69.59 210.79,69.59 211.21,69.17 U4001.5
MDI1+_1: length 31.8
  IN2 w0.114: v2(222.56,69.29) 222.56,69.53 222.66,69.63 224.32,69.63 226.04,71.35 226.04,75.52 228.1,77.58 228.1,86.75 229.24,87.9 229.24,89.95 229.45,90.15 v2(229.68,90.15)
  BOTTOM w0.097: CN4000.3 229.72,92.18 229.34,91.8 229.34,90.65 229.27,90.58 229.27,90.25 229.37,90.15 v2(229.68,90.15) ; U4001.20 221.77,69.17 221.83,69.22 221.83,69.45 222,69.63 222.4,69.63 222.56,69.46 v2(222.56,69.29)
MDI1-: length 16.6
  TOP w0.097: v2(198.92,67.34) 198.61,67.03 198.3,67.03 198.13,67.21 197.75,67.21 197.65,67.31 U4000.5
  BOTTOM w0.097: v2(198.92,67.34) 198.92,67.34 199.2,67.06 199.27,67.06 199.78,67.57 199.78,67.72 200.23,68.17 202.04,68.17 203.12,69.26 209.57,69.26 210.1,69.79 210.81,69.79 211.19,70.17 U4001.6
MDI1-_1: length 31.9
  IN2 w0.114: v2(222.56,70.05) 222.76,69.86 224.22,69.86 225.81,71.45 225.81,75.61 227.87,77.67 227.87,86.85 229.01,87.99 229.01,90.01 v2(228.87,90.15)
  BOTTOM w0.097: CN4000.6 230.65,94.63 229.4,93.38 229.4,92.13 229.14,91.88 229.14,90.73 229.07,90.66 229.07,90.36 v2(228.87,90.15) ; v2(222.56,70.05) 222.34,69.82 222.09,69.82 221.74,70.17 U4001.19
MDI2+: length 19.5
  TOP w0.097: v2(198.69,68.02) 198.69,68.12 198.56,68.26 198.28,68.26 197.98,67.95 197.75,67.95 197.51,67.71 U4000.6
  BOTTOM w0.097: v2(198.69,68.02) 198.88,68.21 199.56,68.21 199.94,68.59 199.94,69.25 199.98,69.29 200.37,69.29 200.42,69.24 200.42,68.78 200.55,68.65 201.32,68.65 201.56,68.89 201.56,69.19 201.66,69.29 202,69.29 202.79,70.08 202.93,70.08 203.21,69.8 203.82,69.8 204.1,70.08 206.49,70.08 206.84,69.74 208.61,69.74 210.52,71.65 210.52,72.4 210.66,72.53 210.82,72.53 211.18,72.17 U4001.8
MDI2+_1: length 29.3
  IN2 w0.114: v2(222.61,72.31) 222.61,72.55 222.72,72.65 223.75,72.65 224.6,73.49 224.6,75.34 227.03,77.78 227.03,86.6 228.07,87.65 228.07,92.62 229.45,93.99 230.46,93.99 230.65,93.8 CN4000.4
  BOTTOM w0.097: v2(222.61,72.31) 222.61,72.54 222.45,72.71 222.01,72.71 221.47,72.17 U4001.17
MDI2-: length 19.5
  TOP w0.097: v2(198.69,68.78) 198.36,68.45 198.2,68.45 197.89,68.15 197.67,68.15 197.63,68.11 U4000.7
  BOTTOM w0.097: U4001.9 211.19,73.17 210.75,72.73 210.57,72.73 210.33,72.48 210.33,71.74 208.52,69.93 206.92,69.93 206.58,70.28 204.02,70.28 203.74,70 203.29,70 203.01,70.28 202.71,70.28 201.92,69.49 201.57,69.49 201.36,69.28 201.36,68.97 201.23,68.85 200.64,68.85 200.62,68.87 200.62,69.32 200.45,69.49 199.9,69.49 199.74,69.34 199.74,68.68 199.47,68.41 199.06,68.41 v2(198.69,68.78)
MDI2-_1: length 29.2
  IN2 w0.114: CN4000.5 229.35,94.22 227.85,92.71 227.85,87.74 226.8,86.7 226.8,77.87 224.37,75.44 224.37,73.59 223.66,72.88 222.81,72.88 v2(222.61,73.07)
  BOTTOM w0.097: U4001.16 221.69,73.17 221.95,72.9 222.44,72.9 v2(222.61,73.07)
MDI3+: length 21
  TOP w0.097: U4000.9 196.33,69.81 196.46,69.94 197.28,69.94 197.39,69.83 v2(197.39,69.65)
  BOTTOM w0.097: v2(197.39,69.65) 197.39,69.8 197.55,69.97 201.72,69.97 202.51,70.76 206.98,70.76 207.33,70.41 208.3,70.41 209.81,71.92 209.81,72.57 210.12,72.89 210.12,75.04 210.66,75.58 210.8,75.58 211.2,75.17 U4001.11
MDI3+_1: length 28
  IN2 w0.114: v2(222.56,75.34) 222.84,75.62 223.2,75.62 226.02,78.44 226.02,86.5 227.41,87.9 227.41,92.98 228.86,94.42 228.86,95.23 229.89,96.26 CN4000.7
  BOTTOM w0.097: v2(222.56,75.34) 222.36,75.53 222.1,75.53 221.73,75.17 U4001.14
MDI3-: length 21.2
  TOP w0.097: U4000.10 195.93,69.69 196.38,70.14 197.18,70.14 v2(197.39,70.35)
  BOTTOM w0.097: v2(197.39,70.35) 197.57,70.17 201.64,70.17 202.43,70.96 207.06,70.96 207.41,70.61 208.22,70.61 209.61,72 209.61,72.65 209.93,72.97 209.93,75.13 210.57,75.77 210.8,75.77 211.2,76.17 U4001.12
MDI3-_1: length 27.8
  IN2 w0.114: v2(222.56,76.11) 222.82,75.85 223.1,75.85 225.79,78.54 225.79,86.6 227.19,88 227.19,93.07 228.63,94.52 228.63,95.32 229.8,96.49 230.46,96.49 230.65,96.67 CN4000.8
  BOTTOM w0.097: U4001.13 221.69,76.17 222.12,75.73 222.47,75.73 222.56,75.82 v2(222.56,76.11)
ME_UNLOCK#: length 97.5
  TOP w0.076: U4701.G4 v3(205.23,50.68)
  TOP w0.102: v2(198.26,50.02) 198.18,50.09 R4740.1 197.24,49.92 197.07,49.75 195.69,49.75 194.79,50.65 190.42,50.65 189.67,51.39 187.1,51.39 186.21,52.29 182,52.29 v2(181.46,51.74) ; Q407.2 131.07,61.25
  TOP w0.114: v2(168.74,64.1) 168.64,64.2 156.26,64.2 155.97,63.92 149.82,63.92 148.78,62.87 135.5,62.87 134.91,62.28 134.91,61.51 136.25,60.17 136.25,57.69 135.81,57.25 134.46,57.25 134.13,57.59 134.13,61.27 132.38,63.02 131.5,63.02 131.22,62.74 131.22,61.41 131.07,61.25
  IN1 w0.114: v2(168.74,64.1) 168.75,64.1 171.63,61.22 171.99,61.22 175.24,57.97 175.24,57.59 177.76,55.07 179.41,55.07 180.58,53.9 180.58,53.27 181.46,52.39 v2(181.46,51.74)
  BOTTOM w0.076: 203.67,49.98 204.44,49.98 205.14,50.68 v3(205.23,50.68)
  BOTTOM w0.102: v2(198.26,50.02) 198.29,49.98 203.67,49.98
MIC2-VREFO: length 3.8
  TOP w0.102: v2(225.07,11.2) 224.71,10.85 223.72,10.85 223.46,11.12 R3619.2
  TOP w0.203: U3600.23 222.37,11.53 222.72,11.18 223.43,11.18 R3619.2
MOD_ID1: length 5
  TOP w0.102: U6100.29 193.49,111.53 R6104.1 194.1,111.24 195.27,111.24 195.37,111.34 v2(195.37,111.79) 195.37,112.26 R6101.2
MOD_ID2: length 5.3
  TOP w0.102: U6100.30 192.81,112.03 193.12,112.34 R6105.1 193.12,113.24 193.41,113.54 195.23,113.54 v2(195.44,113.75) 195.51,113.82 R6102.1
MODEM_CLKREQ: length 41.6
  TOP w0.079: v1(135.02,84.84) 135.29,84.84 135.87,84.26 137.17,84.26
  TOP w0.102: R4122.2 164.58,83.48 163.77,84.29 163.23,84.29 v2(162.77,84.75) ; v2(156.3,80.19) 156.64,80.53 R577.1 156.39,80.8 155.82,80.8 155.57,80.56 151.84,80.56 150.36,82.04 149.97,82.04 149.62,82.39 146.59,82.39 146.39,82.19 143.73,82.19 143.15,81.61 140.2,81.61 139.96,81.84 139.53,81.84 139.38,82 138.82,82 137.98,82.84 137.98,83.45 137.17,84.26
  BOTTOM w0.102: v1(135.02,84.84) 135,84.84 134.81,84.66 U400.CH29 ; v2(156.3,80.19) 156.73,80.61 156.73,84.03 157.65,84.96 157.65,85.46 157.41,85.71 157.41,86.11 157.72,86.42 160.35,86.42 160.83,85.93 162.06,85.93 162.77,85.23 v2(162.77,84.75)
MODEM_CLKREQ_L: length 10.9
  TOP w0.102: v2(163.4,84.76) 163.4,85 162.99,85.41 162.58,85.41 162.28,85.11 162.28,84.47 163.39,83.37 R4122.1
  BOTTOM w0.102: CN4100.14 163.95,89.78 163.61,89.44 163.27,89.44 163.13,89.3 163.13,88.74 162.82,88.43 162.82,85.89 163.4,85.31 v2(163.4,84.76)
MP2949A_ALT#: length 2.5
  TOP w0.203: PU8800.27 40.86,96.89 40.37,96.4 PR8820.1
MP2949A_EN: length 5.4
  TOP w0.102: PC8805.1 46.96,96.19 PR8811.1
  TOP w0.178: PU8800.34 43.66,97.63 43.81,97.48 44.17,97.48 44.31,97.61 v2(45.06,97.61) 45.19,97.48 45.36,97.48 46.19,96.65 PC8805.1
MP2949A_IMONA: length 4.9
  TOP w0.102: PR8836.1 34.76,99.22 36.03,99.22 36.23,99.02 PC8809.1
  TOP w0.203: PU8800.20 38.09,99.43 37.39,98.74 v2(36.89,98.74) PC8809.1
MP2949A_IMONB: length 5.1
  TOP w0.102: PC8810.1 36.23,98.15 36.05,98.33 34.89,98.33 PR8838.2
  TOP w0.203: PU8800.21 38.12,99.03 36.98,97.9 PC8810.1
MP2949A_IMONC: length 6.4
  TOP w0.102: PC8811.1 36.23,97.24 35.97,97.49 35.07,97.49 PR8840.2 34.41,96.28 v2(34.07,95.94)
  TOP w0.178: PC8811.1 36.71,97.06 38.29,98.63 PU8800.22
MP2949A_IREF: length 4
  TOP w0.178: PU8800.23 39.26,97.76 39.06,97.55 38,97.55 v2(37.55,97.1) PR8831.2
MP2949A_PE: length 10.1
  TOP w0.102: v2(49.47,94.16) 49,93.69 PR8827.2 PR8830.1 PR8825.2 46.9,94.12 46.9,95.24 PC8807.1
  TOP w0.203: PC8807.1 45.99,96.15 45.99,96.29 45.21,97.07 43.66,97.07 43.26,97.47 PU8800.33
MP2949A_SCL_P: length 3.5
  TOP w0.203: PU8800.31 42.46,97.09 v2(43.05,96.5) 43.33,96.22 43.93,96.22 PR8809.2
MP2949A_SCLK: length 3
  TOP w0.203: PU8800.25 40.06,97.42 PR8823.2
MP2949A_SDA_P: length 3
  TOP w0.203: PR8815.2 43.19,95.92 42.92,95.92 42.25,96.6 42.25,96.87 42.06,97.05 PU8800.30
MP2949A_SDIO: length 2.7
  TOP w0.203: PR8821.2 39.35,96.04 40.46,97.15 PU8800.26
MP2949A_STB: length 3.5
  TOP w0.203: PR8812.1 45.01,96.5 v2(44.4,96.5) 44.23,96.68 43.58,96.68 42.86,97.4 PU8800.32
MP2949A_TEMP: length 7
  TOP w0.102: v2(49.8,100) 49.28,100.52 PR8865.1
  TOP w0.203: PU8800.41 45.33,101.03 45.49,101.2 46.17,101.2 PC8814.2 PR8851.1 PR8865.1 49.03,100.58 PR8847.2
MP2949A_VDD18: length 42.8
  TOP w0.203: PU8800.24 39.66,97.52 39.2,97.06 38.69,97.06
  TOP w0.508: 32.04,100.94 32.04,103.64 33.32,104.92 PR8867.1 33.61,105.15 33.87,105.41 v2(33.87,106.75) ; 32.04,100.94 33.1,99.88 PR8854.1 ; 32.04,100.94 29.78,98.68 29.78,96.28 30.98,95.08 36.48,95.08 37.1,95.7 PC8803.2 38.63,97.06 38.69,97.06 ; PR8860.1 39.93,108.21 40.71,108.99 40.71,110.12 v2(40.93,110.34) 41.48,110.34 41.96,110.83 43.64,110.83 44.81,109.66
  BOTTOM w0.508: v2(40.93,110.34) 37.91,107.32 34.44,107.32 34.3,107.19 v2(33.87,106.75)
  vias: v2(45.5,109.56)
MP2949A_VIN_SEN: length 5.3
  TOP w0.178: PC8804.2 PR8808.2 PR8807.2
  TOP w0.203: PU8800.43 45.07,101.83 45.91,102.68 v2(45.91,103.06) 46.15,103.3 PC8804.2
MP2949A_VRHOT#: length 2.6
  TOP w0.203: PR8810.2 42.4,96.02 v2(41.78,96.63) 41.66,96.75 PU8800.29
MP2949A_VRRDY: length 3.8
  TOP w0.102: v2(41.21,94.67) 40.97,94.92 40.97,95.62 41.13,95.79 PR8818.1
  TOP w0.203: PU8800.28 41.26,96.25 41.38,96.13 PR8818.1
MSATA_DET#: length 177.9
  TOP w0.102: R659.2 153.94,91.64 v2(154.54,91.04) ; Q4300.3 206.98,22.56 R4306.1 205.47,22.15 205.17,21.86 v2(205.17,21.5)
  IN2 w0.114: v2(152.81,74.38) 152.82,74.37 154.56,74.37 155.3,75.11 156.84,75.11 157.59,74.37 160.78,74.37 161.62,75.21 165.09,75.21 165.71,74.59 166.98,74.59 168.11,73.46 171.43,73.46 173.21,71.68 173.99,71.68 174.38,71.3 174.38,71.08 175.28,70.19 177.43,70.19 177.93,70.69 179.11,70.69 179.57,70.23 179.57,69.73 180.5,68.79 180.86,68.43 180.86,64.06 182.61,62.31 182.61,58.23 184.93,55.9 189.07,55.9 189.16,55.99 190.35,55.99 191.74,54.61 191.74,50.72 191.96,50.5 191.96,46.13 193.52,44.56 193.52,43.8 195.28,42.05 195.28,40.53 194.85,40.1 194.85,39.21 193.95,38.31 193.95,35.3 193.3,34.65 189.51,34.65 189.41,34.75 188.4,34.75 187.86,35.29 187.86,35.78 187.52,36.12 184.58,36.12 184.15,35.7 184.15,26.47 185.66,24.96 185.66,24.27 185.21,23.82 184.95,23.56 v2(184.95,23.06)
  BOTTOM w0.079: U400.CP10 138.37,96.58 138.59,96.8 138.65,96.83 138.73,96.86 138.9,96.86 139.05,96.71 139.5,96.71 139.58,96.8 140.97,96.8 141.06,96.71 141.36,96.71 141.39,96.68 141.93,96.68 142.69,95.92 144.16,95.92 145.14,94.93
  BOTTOM w0.102: v2(152.81,74.38) 152.42,74.77 152.42,74.94 151.76,75.6 151.76,76.38 150.91,77.24 150.91,80.68 151.53,81.3 151.53,82.91 154.23,85.6 154.23,88.51 154.54,88.83 v2(154.54,91.04) 154.54,92.29 153.48,93.36 152.89,93.36 152.55,93.7 149.48,93.7 R554.2 149.07,94.14 148.28,94.93 145.14,94.93 ; v2(184.95,23.06) 184.95,22.44 185.08,22.31 185.08,21.46 186.72,19.82 186.72,19.46 186.24,18.97 186.24,17.86 187.61,16.49 188.5,16.49 189.06,17.05 192.13,17.05 195.05,14.13 198.23,14.13 198.8,13.55 200.5,13.55 201.92,14.97 201.92,16.45 204.72,19.25 204.72,21.05 v2(205.17,21.5)
MSATA_DET#_R: length 12.5
  TOP w0.102: v2(208.64,21.93) 208.39,22.18 207.38,22.18 R4306.2 R4305.1 207.61,20.93 209.38,20.93 209.99,21.54 Q4300.2
  BOTTOM w0.102: CN4300.69 213.02,22.34 212.61,21.93 v2(208.64,21.93)
MSR_ENABLE_N: length 342.9
  TOP w0.102: v2(174.35,76.76) 173.97,76.38 R7724.1 ; v2(46.98,79.45) 46.98,80.58 43.65,83.91 43.65,86.4 40.09,89.96 26.39,89.96 23.48,92.87 23.48,110.23 v2(23.68,110.43) 24.94,111.69 26.19,111.69 26.26,111.75 CN7700.60
  IN1 w0.127: v2(46.98,79.45) 46.98,77.47 48.45,76 48.45,74.83 48.19,74.58 48.19,70.67 47.12,69.6 47.12,64.22 48.09,63.25 48.09,51.34 46.66,49.91 46.66,44.27 45.32,42.93 45.32,39.43 49.71,35.04 60.43,35.04 61.71,33.77 65.79,33.77 65.99,33.97 83.01,33.97 83.23,33.75 86.41,33.75 87.71,35.04 93.19,35.04 93.3,35.16 103.8,35.16 104.46,34.5 113.8,34.5 114.44,33.85 119.61,33.85 121.33,32.13 129.24,32.13 132.54,28.83 133.31,28.83 134.3,27.84 134.3,25.05 135.2,24.15 137.49,24.15 139.07,22.57 139.07,21.83 142.82,18.09 146.73,18.09 147.03,17.79 156.69,17.79 157.71,18.8 163.26,18.8 164.56,20.11 164.56,21.28 166.23,22.94 171.84,22.94 171.99,22.79 172.94,22.79 173.23,23.08 174.42,23.08 175.04,22.46 175.04,20.88 175.47,20.45 175.47,19.87 176.2,19.14 181.28,19.14 181.92,19.79 181.92,20.77 182.18,21.02 183.79,21.02 183.97,21.2 185.01,21.2 185.2,21.01 186.93,21.01 188.2,19.73 190.24,19.73 191.06,20.55 191.92,20.55 192.06,20.69 192.45,20.69 194.29,22.54 194.29,24.44 196.14,26.29 196.14,30.24 195.26,31.12 195.26,35.84 194.38,36.73 194.38,38.61 195.04,39.28 195.04,39.96 195.47,40.39 195.47,42.71 191.2,46.98 188.99,46.98 187.88,48.09 187.69,48.09 186.61,49.17 185.76,49.17 182.52,52.41 181.98,52.41 180.83,53.56 180.83,54.16 178.71,56.28 177.53,56.28 172.17,61.64 171.81,61.64 170.54,62.91 170.54,64.6 170.18,64.96 170.18,65.99 172.54,68.34 173.83,68.34 174.21,68.72 174.21,69.26 172.79,70.69 172.79,71.65 173.85,72.7 173.85,73.72 174.48,74.35 175.24,74.35 175.62,74.73 175.62,76.26 175.12,76.76 v2(174.35,76.76)
MUX_I2C_SCL: length 4.8
  TOP w0.102: U5800.21 204.96,106.36 204.81,106.21 204.81,105.86 204.44,105.49 R5803.2 204.13,105.49 203.51,106.1 202.75,106.1 202.11,105.46 Q5800.1
MUX_I2C_SDA: length 6.6
  TOP w0.102: U5800.22 205.36,106.4 205.01,106.05 205.01,105.62 205.39,105.24 205.39,104.76 205.15,104.53 204.88,104.53 R5802.2 204.94,104.3 205.15,104.09 v2(205.15,103.51) 204.84,103.82 203.93,103.82 203.59,104.16 Q5800.4
MUX_SBU1: length 69
  TOP w0.097: v2(188.65,115.58) 188.43,115.35 188.43,114.97 188.71,114.68 188.71,113.65 188.86,113.5 U6100.36 ; v2(223.4,109.74) 223.19,109.95 223.19,110.2 222.98,110.41 222.24,110.41 221.24,109.42 217.41,109.42 217.17,109.66 216.17,109.66 215.91,109.93 214.08,109.93 213.58,109.43 213.58,107.68 209.96,104.06 208.65,104.06 208.28,104.43 208.28,105.21 207.25,106.25 207.25,106.3 207.36,106.41 U5800.27
  IN2 w0.114: v2(188.65,115.58) 188.45,115.38 188.45,115.07 189.37,114.15 199.28,114.15 199.43,114.31 209.61,114.31 209.84,114.53 210.97,114.53 211.27,114.84 214.94,114.84 215.25,115.15 223.51,115.15 225.13,113.53 225.13,112.29 223.22,110.38 223.22,109.92 v2(223.4,109.74)
MUX_SBU2: length 69
  TOP w0.097: v2(188.01,115.58) 188.23,115.36 188.23,114.88 188.51,114.6 188.51,113.65 188.36,113.5 U6100.37 ; v2(222.77,109.74) 222.99,109.97 222.99,110.11 222.89,110.22 222.32,110.22 221.33,109.23 217.33,109.23 217.09,109.47 216.09,109.47 215.82,109.73 214.16,109.73 213.77,109.34 213.77,107.6 210.04,103.87 208.57,103.87 208.09,104.35 208.09,105.13 207.04,106.17 207.04,106.33 206.96,106.41 U5800.26
  IN2 w0.114: v2(222.77,109.74) 222.99,109.97 222.99,110.48 224.9,112.38 224.9,113.43 223.41,114.92 215.34,114.92 215.03,114.61 211.37,114.61 211.06,114.31 209.93,114.31 209.71,114.08 199.53,114.08 199.37,113.92 189.27,113.92 188.22,114.97 188.22,115.37 v2(188.01,115.58)
NFC_DWL_REQ: length 23.3
  TOP w0.079: 134.22,82.94 134.09,82.94 133.84,83.19 133.84,84 133.59,84.26 133.08,84.26 133.08,84.26 132.81,84.53 132.81,84.94 v1(132.36,85.38)
  TOP w0.102: 134.22,82.94 134.65,82.94 135.8,81.79 135.8,80.9 137.02,79.69 137.02,79.13 139.99,76.16 139.99,72.27 140.55,71.7 v2(140.85,71.7) 142.02,70.54 142.86,70.54 142.98,70.67 143.71,70.67 143.9,70.48 R491.1 R490.1
  BOTTOM w0.079: v1(132.36,85.38) 131.94,85.8 U400.CC27
NGFF_RESET#_R: length 13.6
  TOP w0.102: v2(203.81,77.32) 203.86,77.27 204.79,77.27 R4242.1 205.2,78.26 205.07,78.39 R4246.2 C4208.1 205.07,80.06 204.71,80.42 v2(203.27,80.42) 203.12,80.27 Q4200.3
  BOTTOM w0.102: v2(203.81,77.32) 203.8,77.32 203.31,76.83 203.31,76.34 203.75,75.9 204.26,75.9 205.03,75.13 205.03,73.14 204.95,73.06 CN4200.67
NMI_SMI_DBG#: length 92.2
  TOP w0.079: 133.08,81.87 132.81,82.14 132.81,83.13 132.44,83.5 132.19,83.5 131.94,83.75 131.94,84.32 v1(132.42,84.8)
  TOP w0.102: Q4701.1 179.09,56.52 178.69,56.12 178.01,55.44 177.85,55.44 v2(174.52,52.11) ; v2(159.5,75.29) 159.5,75.07 155.86,71.43 146.26,71.43 145.81,70.98 145.81,68.88 145.11,68.18 142.83,68.18 142.13,67.48 139.65,67.48 R484.1 138.54,68.98 C404.2 139.43,68.98 140.2,69.76 140.2,70.77 139.89,71.09 139.34,71.09 139.13,71.3 139.13,74.77 135.23,78.67 135.23,79.51 133.42,81.32 133.42,81.53 133.08,81.87
  BOTTOM w0.102: v2(174.52,52.11) 174.13,52.11 168.64,57.6 168.64,58.11 163.42,63.33 161.53,63.33 159.7,65.16 159.7,67.38 159.7,67.39 159.7,69.22 160.03,69.54 160.03,71.38 160.51,71.87 160.71,71.87 161.03,72.19 CN7701.10 161.03,73.41 159.5,74.94 v2(159.5,75.29) ; U400.CC29 132.23,84.8 v1(132.42,84.8)
NPCE576H_AGND: length 45.3
  TOP w0.254: 203.84,47.67 203.84,48.16 203.6,48.39 U4701.E1
  TOP w0.305: C4727.1 202.46,44.51 v2(202.41,44.56) ; 203.84,47.67 203.84,46.77 203.8,46.72 C4726.1 203.32,45.63 202.7,45.63 202.41,45.92 v2(202.41,46.14) 202.38,46.12 201.82,46.12 R4716.2 201.03,45.95 200.67,45.95 199.64,44.92 199.09,44.92 C4710.1 198.27,44.49 198.13,44.63 C4719.1 C4718.2 197.71,43.24 197.5,43.03 196.73,43.03 196.6,42.91 196.6,42.68 196.32,42.4 194.59,42.4 194.23,42.76 194.23,43.37 194.64,43.78 194.64,44.86 194.53,44.96 192.03,44.96 191.73,45.27 191.73,45.42 190.81,46.33 185.92,46.33 v2(185.55,46.7) ; v2(182.37,49.46) 183.15,50.23 188.98,50.23 189.94,49.28 C4711.1
  IN1 w0.305: v2(182.37,49.46) 183.03,49.46 185.55,46.94 v2(185.55,46.7) ; v2(202.41,44.56) v2(202.41,46.14)
NUM_LOCK_LED#: length 245.5
  TOP w0.102: v2(44.29,52.59) 44.5,52.59 44.97,53.06 44.97,53.62 44.86,53.74 44.32,53.74 43.79,53.21 C5024.2 42.89,53.84 42.89,54.15 42.71,54.34 R5006.1 ; v2(164.96,74.74) 165.23,75.01 165.89,75.01 166.49,75.61 166.49,76.5 166.76,76.78 170.5,76.78 170.87,77.15 170.87,77.34 171.2,77.68 171.2,78.02 171,78.22 171,79.14 171.31,79.45 172.4,80.55 173.43,80.55 173.67,80.78 177.48,80.78 177.74,81.04 177.74,81.73 178.04,82.02 182.57,82.02 183.44,81.15 183.44,80.13 182.84,79.53 180.25,79.53 179.49,78.78 179.49,77.88 180.02,77.35 180.02,76.91 181.01,75.92 181.01,74.48 180.78,74.25 179.4,74.25 178.92,73.77 178.92,70.82 179.48,70.25 179.48,69.12 179.2,68.84 178.43,68.84 178.3,68.7 178.08,68.49 178.08,67.26 175.67,64.85 175.67,63.16 174.52,62.02 174.52,61.16 174.09,60.72 173.29,59.92 v2(171.89,59.92) ; v2(51.18,51.66) 51.99,50.86 52.56,50.86 52.74,50.68 53.88,50.68 54.09,50.47 56.59,50.47 56.79,50.68 57.87,50.68 58.79,49.75 102.28,49.75 105.09,46.94 113.22,46.94 113.78,47.5 116.81,47.5 117.47,46.84 144.12,46.84 144.88,47.6 178.27,47.6 180.88,50.21 v2(180.88,52.01) 181.36,52.49 186.29,52.49 187.19,51.6 189.76,51.6 189.86,51.49 190.96,51.49 191.11,51.34 195.05,51.34 195.99,50.4 R4745.1 196.4,50.4 196.5,50.5 197.53,50.5 v2(197.65,50.63) ; U4701.D7 v3(202.63,53.28)
  IN1 w0.114: v2(171.89,59.92) 174.17,57.64 174.86,57.64 177.66,54.84 179.26,54.84 180.32,53.78 180.32,53.14 180.88,52.58 v2(180.88,52.01)
  BOTTOM w0.076: 201.4,52.74 201.62,52.95 202.3,52.95 v3(202.63,53.28)
  BOTTOM w0.102: CN7701.29 165.03,75.37 164.96,75.3 164.96,74.74 v2(164.96,74.74) ; v2(197.65,50.63) 197.65,50.91 197.8,51.06 200.52,51.06 201.4,51.95 201.4,52.74 ; v2(51.18,51.66) 50.91,51.39 50.91,50.75 50.51,50.35 45.53,50.35 44.44,51.44 44.44,52.44 v2(44.29,52.59)
OCP_CHG#: length 1.3
  BOTTOM w0.102: PR8520.1 133.05,25.2 132.98,25.13 132.52,25.13 132.39,25.25 PR8221.1
OCP_ID_ADC2: length 68.9
  TOP w0.102: PR8504.1 PR8508.1 160.55,12.61 160.61,12.68 v2(160.61,13.82) ; v2(193.52,37.55) 193.52,39.95 193.73,40.16 194.24,40.16 194.45,40.36 194.98,40.89 194.98,41.71 195.37,42.1 196.73,42.1 R4710.2
  IN2 w0.114: v2(193.52,37.55) 193.52,37.19 193.53,37.18 193.53,35.22 193.33,35.01 193.19,34.88 189.6,34.88 189.51,34.98 188.5,34.98 188.09,35.39 188.09,35.88 187.61,36.35 184.48,36.35 183.92,35.79 183.92,26.37 185.43,24.86 185.43,24.52 185.02,24.11 182.16,24.11 181.49,23.44 181.49,21.7 181.76,21.42 181.76,19.47 181.2,18.91 177.15,18.91 176.95,19.11 168.57,19.11 v2(168.42,18.97)
  BOTTOM w0.102: v2(160.61,13.82) 161.22,13.2 162.33,13.2 168.1,18.97 v2(168.42,18.97)
OCP_ID_SEL: length 103.9
  TOP w0.102: v3(206.53,53.93) 206.86,54.26 U4701.K9 207.17,54.57 207.17,56.39 207.47,56.69 209.1,56.69 209.18,56.62 210.36,56.62 211.03,57.28 212.7,57.28 R4750.1 ; PQ8502.2 154.2,12.26 PR8509.2 154.85,11.85 v2(154.59,11.6)
  IN1 w0.076: 208.26,51.62 208.26,53.35 207.35,54.25 206.85,54.25 v3(206.53,53.93)
  IN1 w0.114: 208.26,51.62 208.26,47.81 207.88,47.43 206.28,47.43 205.84,46.99 205.84,46.97 204.17,45.3 204.17,44.79 204.45,44.51 204.45,35.97 202.5,34.01 202.5,21.87 195.64,15.01 195.64,14.48 194.61,13.45 193.89,13.45 192.67,12.23 191.32,12.23 190.5,11.41 188.82,11.41 186.54,13.69 164.09,13.69 162.8,12.41 155.4,12.41 v2(154.59,11.6)
  BOTTOM w0.102: v2(154.59,11.6) 154.59,11.93 v2(154.95,12.29)
OCP_IN_ADC_R: length 16.3
  TOP w0.102: U4701.K10 v3(206.53,54.58) ; v2(204.61,45.14) 204.61,45.43 205.22,46.04 R4707.2
  IN1 w0.114: v3(206.53,54.58) 206.65,54.47 207.57,54.47 209.91,52.13 209.91,51.34 209.28,50.7 209.28,49.43 208.64,48.79 208.64,47.55 208.26,47.17 206.39,47.17 204.61,45.39 v2(204.61,45.14)
OCP_PWM_OUT: length 114.6
  TOP w0.076: v3(205.23,51.33) 205.23,51.98 U4701.G6
  IN1 w0.114: v2(189.58,12.92) 188.61,12.92 186.89,14.64 163.71,14.64 162.4,13.33 155.02,13.33 153.47,14.88 143.64,14.88 142.61,15.91 139.13,15.91 v2(137.35,17.7)
  IN2 w0.076: v3(205.23,51.33) 205.23,51.32 205.56,50.99 205.56,50.49 205.44,50.36 205.11,50.36 204.91,50.17 204.91,49.85 205.05,49.71 205.4,49.71 205.62,49.49 205.62,49.19 205.37,48.95 205.19,48.95 204.91,48.66 204.91,47.57 205.49,46.99 205.49,46.79 205.85,46.44
  IN2 w0.114: 205.85,46.44 206.53,45.76 206.53,41.06 205.09,39.63 205.09,38.73 205.09,38.72 205.09,33.91 203.3,32.12 203.3,19.35 202.23,18.28 202.23,15.12 201.14,14.03 200.69,14.03 198.86,12.2 193.29,12.2 192.86,11.78 191.25,11.78 190.54,12.49 190,12.49 v2(189.58,12.92)
  BOTTOM w0.102: PQ8503.2 137.04,20.07 137.04,18 v2(137.35,17.7)
ON_OFF#: length 71.1
  TOP w0.102: Q7502.1 44.15,60.3 40.34,60.3 39.3,61.34 39.3,61.79 38.28,62.81 v2(38.28,64.2) ; CN7600.18 8.25,105.84 8.7,106.28 10.25,106.28 C7601.1 11.08,106.71 11.31,106.48 11.31,105.93 11.9,105.34 12.28,105.34 12.87,104.75 14.06,104.75 14.48,104.33 v2(14.48,103.93)
  IN2 w0.114: v2(38.28,64.2) 38.47,64.2 38.85,64.57 38.85,65.01 38.21,65.64 38.21,72.13 36.04,74.3 34.29,74.3 31.38,77.21 31.38,78.96 30,80.33 30,82.33 19.56,92.77 19.56,99.99 15.61,103.93 v2(14.48,103.93)
ON_OFF#1: length 14.3
  TOP w0.102: R7507.1 53.33,61.62 52.92,62.03 51.9,62.03 51.34,62.59 49.06,62.59 48.85,62.39 48.85,61.19 48.69,61.03 Q7501.3 48.28,61.75 R7506.1 47.87,63.02 v2(47.73,63.16) 47.56,63.33 46.64,63.33 46.09,62.78 R7505.2 45.33,61.4 44.08,61.4
ON_OFF#1_Q: length 521.8
  TOP w0.102: v2(38.77,62.9) 39.62,62.04 39.62,61.47 40.58,60.51 44.74,60.51 45.26,61.03 Q7501.4 47.09,61.44 R7506.2 47.09,62.84 v2(47.1,62.84) ; v2(50.73,128.37) 51.07,128.71 64.61,128.71 69.69,123.63 73.01,123.63 73.61,123.02 78.91,123.02 80.18,124.3 85.61,124.3 89.72,128.41 89.72,129.76 90.3,130.33 91.58,130.33 v2(92,130.75) ; R4754.1 195.53,51.9 191.34,51.9 191.19,52.05 190.87,52.05 190.61,52.31 190.22,52.31 189.73,51.82 189.1,51.82 189.04,51.88 187.19,51.88 186.38,52.69 180.87,52.69 175.98,47.8 144.79,47.8 144.04,47.05 117.55,47.05 116.9,47.7 113.69,47.7 113.14,47.15 105.17,47.15 102.37,49.95 58.88,49.95 57.95,50.88 56.71,50.88 56.51,50.68 54.26,50.68 54.03,50.91 52.89,50.91 52.69,51.11 52.05,51.11 51.59,51.57 51.59,51.92 v2(51.16,52.35) ; v2(170.39,77.35) 170.39,79.11 172.25,80.97 173,80.97 173.87,81.84 175.42,81.84 176.01,82.43 182.23,82.43 182.99,83.19 v2(183.24,83.19) ; v2(47.53,75.67) 46.65,75.67 45.38,76.94 42.2,76.94 41.89,76.64 37.45,76.64 36.43,77.65 33.13,77.65 31.1,79.69 31.1,81.75 20.56,92.29 20.56,103.56 19.01,105.11 19.01,111.54 20.58,113.11 20.58,115.6 25.71,120.73 25.71,121.95 26.45,122.69 v2(26.75,122.69) 26.9,122.83 29.48,122.83 29.57,122.93 30.19,122.93 31.15,121.97 R7717.2
  IN1 w0.114: v2(26.75,122.69) 26.49,122.69 24.91,124.27 24.91,126.79 25.38,127.27 26.48,127.27 26.66,127.08 28.79,127.08 29.45,127.74 31.09,127.74 31.68,127.15 35.09,127.15 35.59,126.66 37.92,126.66 39.12,127.85 39.99,127.85 40.51,128.36 48.87,128.36 49.29,127.94 50.31,127.94 v2(50.73,128.37) ; v2(154.37,75.04) 154.37,74.39 154.8,73.97 155.81,73.97 155.94,74.1 157.59,74.1 159.56,76.07 164.77,76.07 165.96,74.88 166.92,74.88 168.84,76.79 169.96,76.79 170.39,77.22 v2(170.39,77.35) ; v2(47.1,62.84) 46.36,63.58 46.36,74.5 v2(47.53,75.67) ; v2(92,130.75) 92.24,130.75 93.15,129.84 121.05,129.84 122.58,128.31 128.82,128.31 129.87,129.36 141.43,129.36 142.23,128.55 146.54,128.55 147.34,129.35 156.13,129.35 156.27,129.49 v2(156.98,129.49)
  BOTTOM w0.102: R7705.2 154.86,73.96 154.37,74.44 v2(154.37,75.04) ; v2(156.98,129.49) 156.98,126.13 158.2,124.91 158.2,122.79 157.56,122.15 157.56,120.96 162.52,116 162.52,115.25 167.45,110.32 174.46,110.32 178.6,106.18 178.6,100.49 183.24,95.84 183.24,93.63 183.73,93.14 183.73,90.66 182.32,89.25 182.32,86.77 182.48,86.61 182.48,83.62 182.91,83.19 v2(183.24,83.19) ; v2(38.77,62.9) 38.77,60.54 40.08,59.22 41.97,59.22 44.64,56.55 44.64,53.05 44.72,52.97 44.72,52.11 44.64,52.03 44.64,51.54 45.63,50.55 50.4,50.55 50.68,50.83 50.68,51.87 v2(51.16,52.35)
OUT_DPST_PWM: length 3.2
  TOP w0.102: R3405.2 39.22,126.07 v2(38.83,126.46) 38.31,125.94 R3414.2 R3416.1
OVP_DET: length 52.3
  TOP w0.102: v2(156.41,8.62) 157.28,7.75 160.98,7.75 162.06,8.83 162.06,10.31 162.37,10.62 163.03,10.62 163.38,10.98 163.38,12.43 163.53,12.58 165.92,12.58 166.15,12.35 166.15,11.73 PR8518.2 165.74,10.8 165.62,10.67 PQ8506.3
  BOTTOM w0.102: v2(156.41,8.62) 153.95,6.17 146.31,6.17 144.78,7.7 144.78,9.38 143.27,10.9 141.03,10.9 140.67,11.25 138.19,11.25 135.6,13.84 135.6,15.14 136.89,16.43 136.89,17.71 136.1,18.5 PQ8206.2 135.93,19.31 132.92,19.31 PR8242.2
PCH_DISP_ON: length 173.8
  TOP w0.102: U3400.3 32.61,122.65 32.14,122.18 R3410.2 31.54,122.18 31.45,122.28 31.13,122.28 30.24,123.18 29.54,123.18 29.39,123.03 27.34,123.03 27.16,123.21 26.65,123.21 25.51,122.07 25.51,120.82 20.36,115.67 20.36,113.52 v2(19.76,112.92)
  IN2 w0.114: v2(19.76,112.92) 19.76,110.08 22.39,107.46 22.39,106.82 28.28,100.93 28.28,96.26 27.42,95.4 27.42,89.81 35.26,81.97 40.88,81.97 42.63,80.22 56.42,80.22 57.54,81.34 59.6,81.34 63.75,85.49 68.59,85.49 71.46,88.35 73.21,88.35 81.34,96.48 90.94,96.48 92.1,95.33 99.82,95.33 100.53,94.61 105.43,94.61 105.77,94.27 116.17,94.27 116.44,94.54 116.95,95.05 118.35,96.45 118.35,96.65 119.16,97.47 119.16,98.63 119.85,99.32 120.33,99.32 121.83,100.82 125.4,100.82 125.92,100.3 126.58,100.3 126.94,100.67 127.63,100.67 128.2,100.1 129.04,100.1 129.16,100.21 130.86,100.21 131.17,99.9 131.17,97.69 131.36,97.5 132.05,97.5 132.17,97.62 132.72,97.62 132.95,97.4 132.95,96.59 v1(133.74,95.8)
  BOTTOM w0.079: U400.CG11 133.76,95.8 v1(133.74,95.8)
PCH_DPST_PWM: length 185.1
  TOP w0.102: R3416.2 36.89,126.93 v2(35.91,127.91)
  IN2 w0.127: 130.41,96.89 130.26,97.04 130.26,97.47 129.35,98.38 129.35,99.42 129.09,99.67 128.29,99.67 127.53,100.44 127.03,100.44 126.67,100.07 125.82,100.07 125.31,100.59 121.92,100.59 120.18,98.84 120.18,98.28 120.1,98.2 120.1,97.62 120.18,97.54 120.18,95.69 118.4,93.91 105.62,93.91 105.15,94.39 100.36,94.39 99.65,95.1 92.01,95.1 90.95,96.16 81.47,96.16 73.34,88.03 71.59,88.03 68.73,85.17 63.88,85.17 59.72,81.01 57.67,81.01 56.56,79.89 42.45,79.89 40.75,81.59 35.17,81.59 26.56,90.2 26.56,92.39 27.1,92.92 27.1,95.53 27.95,96.39 27.95,100.79 22.03,106.72 22.03,107.35 19.16,110.22 19.16,114.53 19.39,114.76 24.44,114.76 26.09,116.41 28.05,116.41 v2(28.71,117.07)
  IN2 w0.14: 130.41,96.89 130.68,96.63 132.31,96.63 133.55,95.39 133.92,95.39 134.27,95.74 v1(134.97,95.74)
  BOTTOM w0.079: v1(134.97,95.74) 134.86,95.85 U400.CH11
  BOTTOM w0.102: v2(28.71,117.07) 28.71,119.53 29.3,120.12 29.3,120.76 29.82,121.28 29.82,122.08 30.58,122.85 30.58,123.26 30.82,123.5 32.19,123.5 33.78,125.09 35,125.09 35.91,126 v2(35.91,127.91)
PCH_KBC_CLK: length 443.9
  TOP w0.076: U4701.K8 v3(207.18,53.93)
  TOP w0.102: Q5402.6 65.98,27 66.12,26.85 66.65,26.85 v2(67.25,27.46) ; R4727.2 215.37,54.26 215.37,55.07 v2(215.25,55.2) 215.3,55.25 215.55,55.25 215.73,55.07 216.96,55.07 v2(218.53,56.64) ; v2(190.18,57.7) 190.02,57.7 189.35,58.37 188.78,58.37 188.08,57.68 Q4700.6 ; v2(72.45,128.3) 72.64,128.49 R7633.1 72.72,128.93 U5301.1
  IN1 w0.076: 205.6,48.77 206.94,48.77 207.93,49.76 207.93,53.22 207.22,53.93 v3(207.18,53.93) 206.86,53.61 206.86,53.11 207.03,52.95 207.03,50.63 206.75,50.35 204.23,50.35 204.07,50.2
  IN1 w0.127: 204.07,50.2 201.88,50.2 201.59,50.49 201.59,52.14 201.19,52.54 201.19,52.9 200.64,53.45 197.32,53.45 196.69,52.82 193.5,52.82 193.21,53.12 192.18,53.12 191.56,53.74 190.88,53.74 190.18,54.43 190.13,54.43 189.47,55.09 189.47,57 v2(190.18,57.7) ; v2(48.54,92.31) 48.01,91.78 48.01,91.07 43.1,86.15 43.1,82.43 42.47,81.8 42.47,77.21 41.89,76.63 41.89,66.09 42.64,65.34 42.64,60.7 41.7,59.75 41.7,56.38 41.27,55.95 41.27,50.54 41.13,50.4 41.13,44.99 40.63,44.49 40.63,44.04 40.15,43.57 40.15,41.32 40.63,40.84 40.63,37.52 40.8,37.34 40.8,36.4 41.72,35.49 42.6,35.49 44.01,34.07 44.01,33.42 45.97,31.46 45.97,29.45 48.28,27.14 48.28,26.56 48.75,26.09 49.44,26.09 50.96,27.62 51.74,27.62 52.72,28.59 55.13,28.59 56.12,27.61 64.52,27.61 65.21,26.92 66.71,26.92 v2(67.25,27.46) 67.71,27.92 68.54,27.92 69.34,28.72 77.69,28.72 78.63,29.66 81.02,29.66 81.42,29.27 92.15,29.27 92.37,29.04 95.29,29.04 95.41,29.16 95.89,29.16 96,29.27 97.21,29.27 97.77,28.71 102.18,28.71 103.81,27.07 110.54,27.07 111.96,25.65 115.31,25.65 117.75,23.21 121.25,23.21 121.93,22.53 121.93,22.31 124.74,19.5 124.74,14.62 128.37,10.99 131.27,10.99 131.9,10.36 134.39,10.36 134.97,10.94 143.12,10.94 147.79,6.27 156.44,6.27 v2(158.73,8.57) ; 205.6,48.77 204.91,48.77 204.58,48.44 204.58,47.3 203.57,46.29 203.57,36 201.86,34.3 201.86,22.1 195.31,15.55 194.29,15.55 192.9,14.15 188.96,14.15 187.18,15.93 185.29,15.93 184.68,16.54 184.46,16.76 177.4,16.76 176.12,15.47 159.42,15.47 v2(159.37,15.42)
  BOTTOM w0.076: 208.85,55.68 208.39,55.68 207.18,54.47 v3(207.18,53.93)
  BOTTOM w0.102: v2(67.25,27.46) 68.69,28.9 68.69,34.09 70.04,35.44 82.64,35.44 83.2,36 85.08,36 85.45,36.38 86.5,36.38 86.88,36 93.24,36 94.24,35 94.24,33.25 94.91,32.58 PU8201.1 ; v2(72.45,128.3) 71.91,128.84 58.01,128.84 57.22,128.04 57.22,126.17 54.98,123.93 50.4,123.93 48.4,121.94 48.4,107.19 46.95,105.74 46.95,100.82 49.31,98.47 49.31,93.08 v2(48.54,92.31) ; 208.85,55.68 211.44,55.68 211.72,55.4 212.27,55.4 212.29,55.43 212.47,55.61 213.55,55.61 214.13,55.02 215.07,55.02 v2(215.25,55.2) ; v2(159.37,15.42) 159.11,15.17 159.11,10.47 158.61,9.96 158.61,8.69 v2(158.73,8.57)
PCH_KBC_CLK_C: length 5.5
  TOP w0.102: v2(74.16,128.21) 74.16,127.9 74.15,127.89 74.15,126.66 C7622.2 73.72,126.71 73.72,127.44 73.45,127.71 R7633.2
  BOTTOM w0.102: v2(74.16,128.21) 75.14,129.19 CN7602.1
PCH_KBC_DATA: length 444
  TOP w0.076: U4701.K7 v3(207.18,53.28)
  TOP w0.102: v2(212.56,53.44) 212.77,53.65 R4726.2 ; v2(66.62,27.45) 66.53,27.54 64.4,27.54 64.12,27.26 64.12,26.17 63.65,25.7 Q5402.3 ; Q4700.3 189.38,54.65 v2(189.08,54.35) ; U5301.4 74.58,129.9 74.68,130 v2(74.81,130)
  IN1 w0.076: 205.64,49.03 206.82,49.03 207.65,49.87 207.65,53.12 207.49,53.28 v3(207.18,53.28) 207.25,53.22 207.25,50.22 206.74,49.71 204.33,49.71 204.07,49.97
  IN1 w0.127: 205.64,49.03 204.66,49.03 204.2,48.57 204.2,47.46 203.08,46.34 203.08,36.28 201.48,34.68 201.48,22.26 195.15,15.93 194.04,15.93 192.69,14.58 189.07,14.58 187.34,16.31 185.44,16.31 184.62,17.14 177.24,17.14 175.96,15.85 159.04,15.85 v2(158.61,15.42) ; 204.07,49.97 201.79,49.97 201.36,50.39 201.36,52.08 200.98,52.45 200.98,52.69 200.43,53.25 198.34,53.25 198.19,53.1 198.19,53.01 197.18,52 193.79,52 193.05,52.74 192.02,52.74 191.41,53.35 190.64,53.35 189.93,54.06 189.72,54.28 189.15,54.28 v2(189.08,54.35) ; v2(48.89,91.78) 48.89,91.41 43.48,86 43.48,82.27 42.91,81.7 42.91,77.02 42.27,76.38 42.27,66.25 43.02,65.49 43.02,60.54 42.08,59.6 42.08,55.89 41.66,55.47 41.66,49.59 41.56,49.49 41.56,47.35 41.61,47.3 41.61,44.94 41.01,44.33 41.01,43.88 40.62,43.5 40.62,41.41 41.01,41.02 41.01,37.77 41.18,37.6 41.18,36.58 41.77,36 42.63,36 44.53,34.09 45.3,34.09 45.88,33.51 45.88,32.14 46.35,31.67 46.35,29.61 48.67,27.28 48.67,26.75 48.95,26.47 49.28,26.47 50.8,28 51.58,28 52.56,28.97 55.29,28.97 56.28,27.99 65.13,27.99 65.67,27.45 v2(66.62,27.45) 67.47,28.3 68.38,28.3 69.18,29.1 77.35,29.1 78.3,30.04 81.18,30.04 81.58,29.65 92.3,29.65 92.53,29.42 95.14,29.42 95.25,29.54 95.73,29.54 95.84,29.65 97.37,29.65 97.93,29.09 102.34,29.09 103.97,27.46 110.7,27.46 112.03,26.13 115.51,26.13 118.04,23.6 121.41,23.6 122.31,22.69 122.31,22.47 125.12,19.66 125.12,14.97 128.35,11.74 128.85,11.74 129.14,11.45 131.35,11.45 132,10.8 134.29,10.8 134.82,11.33 143.28,11.33 147.95,6.65 156.06,6.65 v2(157.97,8.57)
  BOTTOM w0.076: 208.85,53.78 207.91,53.78 207.41,53.28 v3(207.18,53.28)
  BOTTOM w0.102: v2(48.89,91.78) 48.5,91.78 48.14,92.15 48.14,93.47 48.95,94.29 48.95,98.32 46.6,100.68 46.6,105.89 48.05,107.34 48.05,122.09 50.25,124.29 54.83,124.29 56.86,126.32 56.86,128.19 57.87,129.2 72.14,129.2 73.03,128.3 73.03,128.04 74.34,126.74 75.5,126.74 75.62,126.86 75.62,127.64 76.35,128.36 76.35,129.53 76.19,129.69 CN7602.2 75.13,129.69 v2(74.81,130) ; PU8201.5 100.33,32.58 99.8,32.06 94.93,32.06 93.89,33.1 93.89,34.85 92.97,35.77 86.82,35.77 86.42,36.18 85.58,36.18 85.18,35.77 83.48,35.77 82.79,35.08 70.19,35.08 69.05,33.94 69.05,28.38 67.5,26.83 67.24,26.83 v2(66.62,27.45) ; v2(158.61,15.42) 158.73,15.3 158.73,10.63 158.22,10.12 158.22,8.82 v2(157.97,8.57) ; v2(212.56,53.44) 211.82,53.44 211.48,53.78 208.85,53.78
PCH_LAN_RST#: length 22
  TOP w0.079: 136.6,95.67 136.38,95.46 136.07,95.46 135.97,95.36 135.42,95.36 135.19,95.13 134.91,95.13 v1(134.55,94.77)
  TOP w0.102: R477.1 152.75,98.02 152.35,98.43 151.53,98.43 151.4,98.29 149.86,98.29 149.49,98.66 146.95,98.66 146.62,98.33 146.62,98.23 v2(146.49,98.09) 146.35,98.23 142.02,98.23 141.52,98.74 138.72,98.74 138.11,98.13 138.11,98.09 138.08,98.06 138.08,97.16 136.6,95.67
  BOTTOM w0.079: U400.CG12 134.21,95.2 134.55,94.86 v1(134.55,94.77)
PCH_LVDS_BLON: length 167.9
  TOP w0.102: v2(19.73,114.24) 19.92,114.43 19.92,115.8 22.76,118.64 R3415.2 22.76,121 23.54,121.78 R3423.2 23.79,122.23 v2(24.34,122.23) 24.6,121.98 R3404.2
  IN2 w0.114: v2(19.73,114.24) 20.03,113.94 20.59,113.39 20.59,109.58 22.79,107.37 22.79,106.74 28.51,101.02 28.51,96.16 27.65,95.3 27.65,89.9 35.33,82.23 41.13,82.23 42.91,80.45 56.32,80.45 57.44,81.56 59.5,81.56 63.76,85.82 68.6,85.82 71.36,88.58 73.11,88.58 81.24,96.71 91.09,96.71 91.7,96.1 99.35,96.1 100.59,94.87 105.5,94.87 105.87,94.5 115.48,94.5 117.44,96.46 117.44,96.73 118.24,97.53 118.24,99.21 120.24,101.22 122.87,101.22 123.02,101.08 126.65,101.08 126.81,100.92 127.68,100.92 128.28,100.31 128.89,100.31 129.03,100.45 132.71,100.45 133.06,100.1 133.8,100.1 133.99,99.9 133.99,96.56 134.36,96.19 135.07,96.19 135.48,95.78 v1(135.77,95.78)
  BOTTOM w0.079: U400.CK11 136.16,96.17 v1(135.77,95.78)
PCH_OPI_RCOMP: length 1.2
  TOP w0.254: v1(129.14,87.15) 128.93,87.36 R412.2
  BOTTOM w0.254: v1(129.14,87.15) 129.49,86.81 U400.BW25
PCH_PWROK: length 22.4
  TOP w0.102: v1(126.86,82.88) 126.22,82.24 126.22,79.95 125.88,79.61 125.88,77.55 126.86,76.57 126.86,75.53 126.74,75.41 126.74,74.44 127.59,73.59 127.59,72.8 127.24,72.45 127.24,71.46 R466.1 126.7,71.25 126.29,71.66 125.42,71.66 R451.1 124.95,71.66 125.35,71.26 R452.1 126.29,71.26 126.58,70.97 126.58,69.87 v2(127.41,69.04) 128.45,68 U401.4
  BOTTOM w0.079: U400.BP31 126.53,83.22 v1(126.86,82.88)
PCH_SLP_S0IX#: length 7.6
  TOP w0.102: R4756.2 208.69,44.76 TP4706.1 208.14,45.12 v2(208.01,45.12) ; U4701.J3 v3(206.53,50.03)
  IN2 w0.076: 207.75,46.44 207.75,48.81 v3(206.53,50.03)
  IN2 w0.114: 207.75,46.44 207.75,45.37 v2(208.01,45.12)
PCH_SLP_SUS#: length 108.6
  TOP w0.076: U4701.J6 v3(206.53,52.63)
  TOP w0.079: v1(129.65,84.06) 130.01,83.7 130.01,83.39 130.24,83.16 130.24,82.74 130.49,82.49 130.49,81.86 130.77,81.58 130.77,81.26
  TOP w0.102: v2(176.84,52.41) 179.59,52.41 180.48,53.3 188.71,53.3 190.47,55.06 190.47,55.18 191.3,56.01 v2(191.3,56.22) ; 130.77,81.26 130.77,80.28 129.76,79.27 129.76,78.87 133.23,75.4 133.23,71.66 132.75,71.18 132.75,70.03 132.48,69.77 132.48,68.81 134.55,66.74 135.03,66.74 135.97,65.81 145.73,65.81 146.58,66.65 148.24,66.65 149.16,67.58 152.93,67.58 154.23,66.27 159.52,66.27 160.1,66.86 v2(161.06,66.86)
  IN1 w0.076: 201.1,53.66 201.79,52.96 202.17,52.96 202.31,52.82 202.31,52.5 202.51,52.3 203.42,52.3 203.61,52.5 203.61,52.87 203.7,52.96 205.05,52.96 205.71,52.3 206.2,52.3 v3(206.53,52.63)
  IN1 w0.114: v2(191.3,56.22) 191.43,56.09 191.43,55.94 192.58,54.79 195.69,54.79 195.99,54.48 197.69,54.48 197.77,54.56 199.82,54.56 199.98,54.4 200.87,54.4 201.1,54.17 201.1,53.66
  BOTTOM w0.102: v2(161.06,66.86) 161.08,66.84 161.08,65.68 162.57,64.19 163.66,64.19 169.51,58.34 169.51,57.82 174.09,53.24 176.01,53.24 v2(176.84,52.41) ; U400.BU29 128.61,84.21 129.5,84.21 v1(129.65,84.06)
PCH_SMB_CLK: length 31.2
  TOP w0.102: v1(136.38,93.71) 136.38,93.71 138.09,93.71 138.26,93.88 140.08,93.88 140.51,94.31 141.9,94.31 143.33,95.73 144.8,95.73 145.33,95.2 147.09,95.2 147.3,95.41 148.19,95.41 148.9,94.7 150.01,94.7 150.32,95.01 151.36,95.01 151.75,94.62 v2(152.38,94.62) 152.52,94.48 153.69,94.48 154.17,94 157.6,94 157.96,94.37 159.65,94.37 159.9,94.62 R421.2 159.9,95.26 160.05,95.41 161.73,95.41 162.89,94.25 Q401.3
  BOTTOM w0.079: v1(136.38,93.71) 136.38,94 U400.CK14
PCH_SMB_DATA: length 35
  TOP w0.102: v1(135.06,92.71) 135.63,93.27 137.9,93.27 137.93,93.24 138.43,93.24 138.7,92.97 140.33,92.97 140.74,93.38 141.99,93.38 142.48,93.87 v2(142.84,93.87) 143.15,93.56 144.2,93.56 144.43,93.79 144.78,93.79 145.72,94.72 147.29,94.72 147.5,94.93 147.99,94.93 148.7,94.22 150.21,94.22 150.52,94.52 151.16,94.52 151.56,94.13 152.17,94.13 152.32,93.98 153.51,93.98 153.98,93.51 160.57,93.51 161.48,94.42 R422.2 161.93,94.42 162.67,93.68 164.02,93.68 164.47,94.14 164.47,95.28 164.74,95.55 Q401.6
  BOTTOM w0.079: U400.CH15 135.06,92.98 v1(135.06,92.71)
PCH_SMBCLK: length 454.7
  TOP w0.102: v2(166.26,92.99) 166.41,93.13 166.41,93.81 166.18,94.04 R447.2 165.67,94.25 Q401.4 ; v2(179.13,68.35) 178.87,68.35 178.57,68.05 178.57,67.06 177.51,66 177.51,65.5 176.92,64.92 176.92,63.73 175.01,61.82 175.01,60.84 173.85,59.68 173.85,58.32 172.02,56.5 170.54,56.5 167.24,53.19 161.41,53.19 160.75,53.85 156.32,53.85 154.07,51.61 142.33,51.61 141.6,50.88 126.83,50.88 125.85,51.86 105.4,51.86 103.95,53.31 61.84,53.31 57.14,58.01 v2(57.14,58.34) ; CN7700.53 27.76,117.01 24.77,114.02 23.02,114.02 22.51,113.52 22.51,92.47 25.99,88.99 39.69,88.99 42.69,86 42.69,83.51 44.34,81.86 44.34,79.24 47.19,76.38 48.95,76.38 53.01,72.32 54.69,72.32 v2(55.25,72.88)
  IN1 w0.127: v2(189.04,42.58) 189.03,42.59 187.62,42.59 187.13,42.09 185.28,42.09 184.36,41.18 184.36,39.38 182.55,37.56 180.96,37.56 180.09,38.43 180.09,40.09 179.06,41.13 177.35,41.13 177.27,41.2 171.07,41.2 170.55,40.68 169.31,40.68 169.07,40.44 169.07,38.26 168.66,37.85 150.5,37.85 150.21,37.56 125.75,37.56 123.99,39.32 119.97,39.32 119.44,39.86 115.3,39.86 114.87,40.29 114.87,41.94 v2(114.36,42.45) 114.28,42.45 112.61,40.77 112.61,40.17 111.95,39.51 111.95,38.84 110.99,37.89 92.02,37.89 91.83,37.7 86.04,37.7 86.04,37.7 83.82,37.7 82.57,36.45 71.24,36.45 70,37.7 50.63,37.7 48.78,39.55 48.78,39.98 49.34,40.54 49.34,42.02 48.69,42.66 48.69,45.08 51.29,47.68 51.77,47.68 52.43,48.34 52.43,49 54.67,51.24 55.51,51.24 57.97,53.7 57.97,57.51 57.14,58.35 v2(57.14,58.34) ; v2(179.13,68.35) 179.98,69.2 180.46,69.2 181.53,70.28 181.53,73.07 181.72,73.25 182.24,73.77 182.24,78.71 180.68,80.27 180.68,83.13 179.89,83.92 177.59,83.92 176.79,84.72 176.79,88.99 173.59,92.19 171.88,92.19 171.18,91.5 167.62,91.5 166.26,92.85 v2(166.26,92.99)
  BOTTOM w0.102: JDIM2800.253 114.1,44.33 114.32,44.11 114.32,42.83 114.36,42.8 v2(114.36,42.45) ; JDIM2801.253 191.07,43.28 190.1,42.32 189.3,42.32 v2(189.04,42.58) ; v2(57.14,58.34) 57.14,62.28 56.32,63.1 56.32,69.83 55.13,71.02 55.13,72.75 v2(55.25,72.88)
PCH_SMBDATA: length 459.4
  TOP w0.102: v2(54.54,72.88) 53.32,72.88 49.31,76.89 47.37,76.89 44.82,79.44 44.82,82.06 43.17,83.71 43.17,86.2 39.89,89.48 26.19,89.48 23,92.67 23,110.56 23.38,110.95 23.38,111.28 25.78,113.67 25.78,114.35 28.26,116.82 CN7700.51 ; v2(179.19,67.72) 179.19,67.72 179.19,67 177.99,65.8 177.99,65.3 177.4,64.72 177.4,63.53 175.49,61.62 175.49,60.64 174.33,59.48 174.33,58.12 172.07,55.86 170.59,55.86 167.44,52.71 161.21,52.71 160.55,53.37 156.52,53.37 154.27,51.13 142.53,51.13 141.8,50.4 118.76,50.4 117.78,51.38 105.2,51.38 103.75,52.82 61.64,52.82 v2(57.13,57.33) ; v2(166.89,92.97) 166.89,93.76 167.37,94.24 167.37,96.02 167.14,96.24 166.2,96.24 R450.2 166,96.04 164.55,96.04 164.06,95.55 Q401.1
  IN1 w0.127: v2(57.13,57.33) 57.47,57 57.47,53.91 55.3,51.74 54.46,51.74 52.43,49.71 51.82,49.71 51.57,49.46 51.57,48.52 51.29,48.24 51.04,48.24 48.18,45.38 48.18,43.6 46.84,42.26 46.84,40.07 49.72,37.19 69.79,37.19 71.03,35.95 82.78,35.95 84.03,37.19 92.06,37.19 92.25,37.38 111.2,37.38 112.45,38.63 112.45,39.3 113.12,39.97 113.12,40.52 113.68,41.08 114.21,41.08 114.36,40.92 114.36,39.2 v2(114.64,38.92) 115.07,39.35 119.23,39.35 119.76,38.82 123.63,38.82 125.4,37.05 150.42,37.05 150.71,37.34 168.88,37.34 169.31,37.78 170.24,37.78 170.65,38.18 170.65,40.06 171.28,40.7 176.21,40.7 176.28,40.62 178.85,40.62 179.59,39.88 179.59,38.22 180.75,37.05 182.76,37.05 184.87,39.16 184.87,40.97 185.49,41.59 187.34,41.59 187.82,42.07 189.82,42.07 190.06,41.83 190.06,41.24 189.57,40.75 v2(189.57,40.24) ; v2(166.89,92.97) 167.86,92 170.92,92 171.62,92.7 173.8,92.7 177.3,89.2 177.3,84.93 177.8,84.43 180.1,84.43 181.19,83.34 181.19,80.48 182.75,78.92 182.75,73.56 182.23,73.04 182.06,72.88 182.06,70.07 180.43,68.44 179.95,68.44 179.23,67.72 v2(179.19,67.72)
  BOTTOM w0.102: JDIM2800.254 114.35,38.08 114.64,38.37 v2(114.64,38.92) ; v2(54.54,72.88) 54.59,72.83 54.59,70.8 55.69,69.7 55.69,58.78 v2(57.13,57.33) ; v2(189.57,40.24) 191.32,38.49 JDIM2801.254
PCH_SPI1_CLK: length 26.1
  TOP w0.102: v2(175.56,77.82) 175.38,77.64 175.38,76.31 175.92,75.77 176.38,75.77 176.46,75.85 177.61,75.85 178.03,75.42 178.03,71.05 176.93,69.94 R5110.2 R5102.1 R5606.1 174.35,70.07 173.69,70.73 U5100.19
  BOTTOM w0.102: TP5601.1 180.84,80.72 178.22,78.1 178.22,77.66 177.87,77.31 177.12,77.31 176.42,78.02 175.75,78.02 v2(175.56,77.82) 175.56,77.9 174.84,78.62 174.84,79.43 174.56,79.71 U5600.6
PCH_SPI1_CLK_E1: length 38.9
  TOP w0.102: v2(198.16,61.3) 198.52,60.94 200.07,60.94 200.33,60.68 200.42,60.68 200.53,60.57 201.34,60.57 201.93,59.98 R4709.2 ; R5110.1 175.21,68.09 v2(175.21,67.91)
  BOTTOM w0.102: v2(175.21,67.91) 175.14,67.85 175.14,67.12 174.72,66.7 174.72,65.89 174.49,65.66 174.49,64.14 174.4,64.05 174.4,63.48 176.03,61.85 179.05,61.85 180.09,60.81 182.58,60.81 184.53,62.75 185.23,62.75 186.87,64.39 187.57,64.39 188.23,63.73 189.32,63.73 192.02,61.03 194.12,61.03 194.39,60.76 195.82,60.76 195.87,60.71 197.56,60.71 198.15,61.3 v2(198.16,61.3)
PCH_SPI1_CLK_E2: length 4.1
  TOP w0.102: U4701.F12 204.13,56.33 204.13,57.15 203.92,57.36 203.92,57.59 v2(203.31,58.2) 203.13,58.37 202.8,58.37 R4709.1
PCH_SPI1_CLK_R1: length 32.3
  TOP w0.102: v2(173.72,68.84) 174.04,69.16 R5606.2
  IN1 w0.127: v2(173.72,68.84) 172.69,68.84 172.56,68.97 172.56,69.8 172.44,69.93 172.18,69.93 172.06,69.8 172.06,68.97 171.93,68.84 168.41,68.84 165.18,72.07 161.4,72.07 161.15,71.81 157.46,71.81 156.85,71.2 152.31,71.2 151.47,70.36 151.47,69.6 v2(151.46,69.59)
  BOTTOM w0.102: v2(151.46,69.59) 151.51,69.64 151.51,70.17 149.8,71.88 C401.1 R425.2
PCH_SPI1_CLK_R2: length 16.9
  BOTTOM w0.079: 143.09,75.46 142.63,75.46 141.99,76.1 141.74,76.1 141.54,76.3 141.22,76.3 139.43,78.09 135.66,78.09 134.72,79.04 U400.CH37
  BOTTOM w0.102: R425.1 148.27,73.01 v2(147.79,73.49) 147.68,73.6 145.28,73.6 143.42,75.46 143.09,75.46
PCH_SPI1_SI: length 24.3
  TOP w0.102: v2(174.9,77.87) 174.9,76.1 175.74,75.26 176.43,75.26 176.68,75.01 177.4,75.01 177.55,74.86 177.55,74.37 177.15,73.97 R5608.1 177.15,73.46 177.53,73.08 R5112.2 176.62,72.84 R7727.1 176.61,72.58 R5602.1 173,71.74 172.99,71.73 U5100.21
  BOTTOM w0.102: U5600.5 173.29,79.92 174.22,78.99 174.22,78.28 174.63,77.87 v2(174.9,77.87) 174.9,77.5 175.24,77.16 176.59,77.16 176.92,76.83 178.16,76.83 178.7,77.37 178.7,77.89 180.2,79.39 180.59,79.39 TP5602.1
PCH_SPI1_SI_E1: length 43.6
  TOP w0.102: v2(176.84,70.84) 177.14,70.84 177.53,71.22 R5112.1 ; v2(196.9,61.83) 196.98,61.75 198.1,61.75 198.45,62.11 200.87,62.11 201.34,61.63 201.78,61.63 202.22,61.2 204.04,61.2 204.98,60.26 R4711.2
  BOTTOM w0.102: v2(176.84,70.84) 176.71,70.84 176.33,70.45 176.33,66.8 175.85,66.32 175.85,65.51 175.67,65.33 175.67,63.73 176.48,62.92 183.18,62.92 186.08,65.82 188.35,65.82 189.25,64.91 189.65,64.91 192.47,62.1 194.04,62.1 194.58,62.64 196.15,62.64 196.83,61.96 196.83,61.91 v2(196.9,61.83)
PCH_SPI1_SI_E2: length 4.2
  TOP w0.112: R4711.1 204.98,58.54 v2(204.81,58.37) 204.55,58.11 204.55,57.5 204.95,57.1 204.95,56.6 205.23,56.32 205.23,55.88 U4701.H11
PCH_SPI1_SI_R1: length 42.4
  TOP w0.102: R5608.2 176.56,74.61 176.31,74.87 v2(174.99,74.87)
  IN1 w0.127: v2(174.99,74.87) 174.99,75.28 173.69,76.59 172.67,76.59 172.14,76.05 171.61,76.05 171.21,75.66 169.31,75.66 167.39,73.74 164.81,73.74 164.42,74.12 164.12,74.12 163.5,74.74 162.01,74.74 160.22,72.95 156.7,72.95 156.09,72.34 151.8,72.34 150.17,70.71 v2(150.17,70.49)
  BOTTOM w0.102: R428.2 142.35,73.08 142.35,72.57 143.62,71.31 143.62,70.87 144.73,69.76 147.86,69.76 147.96,69.65 149.33,69.65 v2(150.17,70.49)
PCH_SPI1_SI_R2: length 11.9
  BOTTOM w0.079: 133.49,78.46 133.38,78.57 133.38,79.15 133.27,79.31 133.21,79.38 133.16,79.46 133.16,79.63 133.18,79.71 133.21,79.76 133.31,79.86 U400.CF36
  BOTTOM w0.102: R428.1 141.03,74 v2(140.6,74.44) 140.41,74.44 140.15,74.71 140.15,74.93 139.76,75.32 139.61,75.32 138.21,76.72 135.23,76.72 133.49,78.46
PCH_SPI1_SO: length 15.9
  TOP w0.102: v2(173.09,75.65) 173.33,75.41 174.2,75.41 R5607.1 174.4,74.65 174.5,74.55 R5111.2 174.25,74.22 173.99,73.96 173.97,73.92 173.92,73.83 173.88,73.77 173.75,73.65 173.69,73.61 173.52,73.44 172.96,73.44 172.75,73.23 U5100.24
  BOTTOM w0.102: TP5603.1 168.81,77.57 169.5,76.87 169.5,76.57 169.91,76.15 171.14,76.15 171.51,75.79 172.95,75.79 v2(173.09,75.65) 173.44,75.65 173.64,75.44 173.75,75.44 174.37,74.83 175.17,74.02 175.54,74.02 175.78,73.78 175.78,73.39 175.83,73.34 U5600.2
PCH_SPI1_SO_E1: length 46.9
  TOP w0.102: v2(199.27,61.7) 199.32,61.75 200.72,61.75 201.2,61.28 201.64,61.28 202.1,60.82 202.76,60.82 203.6,59.98 R4713.2 ; v2(176.18,74.43) 175.98,74.22 R5111.1
  BOTTOM w0.102: v2(176.18,74.43) 176.46,74.43 177.61,73.28 177.61,71.76 177.11,71.27 176.51,71.27 175.97,70.73 175.97,66.95 175.46,66.43 175.46,65.62 175.32,65.48 175.32,63.58 176.33,62.57 183.33,62.57 184.23,63.47 184.94,63.47 186.58,65.11 188.55,65.11 189.1,64.56 189.5,64.56 192.32,61.74 194.42,61.74 194.68,61.47 196.11,61.47 196.16,61.42 197.21,61.42 197.87,62.08 198.26,62.08 198.38,62.21 198.76,62.21 v2(199.27,61.7)
PCH_SPI1_SO_E2: length 5.4
  TOP w0.076: R4713.1 204.43,59.63 204.43,60.22 v2(203.85,60.8)
  TOP w0.112: U4701.G12 204.76,56.35 204.76,57.02 204.33,57.45 204.33,58.87 R4713.1
PCH_SPI1_SO_R1: length 36.3
  TOP w0.102: v2(173.78,75.88) 173.88,75.99 R5607.2
  IN1 w0.127: v2(173.78,75.88) 173.46,76.21 172.83,76.21 172.19,75.56 171.66,75.56 171.37,75.27 169.76,75.27 169.48,75 169.48,74.45 169.05,74.02 168.41,74.02 167.21,72.83 160.64,72.83 160.38,72.57 156.96,72.57 156.35,71.96 152,71.96 150.6,70.57 150.6,70.31 150.35,70.06 149.96,70.06 v2(149.52,70.5)
  BOTTOM w0.102: v2(149.52,70.5) 149.52,70.34 149.18,70.01 148.11,70.01 148,70.11 144.88,70.11 144.51,70.48 144.51,70.91 144.98,71.38 v2(144.98,71.78) 144.9,71.85 R427.2
PCH_SPI1_SO_R2: length 14.1
  BOTTOM w0.079: 140.39,74.95 139.79,75.54 139.68,75.54 138.33,76.9 135.4,76.9 133.55,78.75 133.55,79.38 U400.CF37
  BOTTOM w0.102: 140.39,74.95 140.41,74.93 140.67,74.93 141.32,74.28 141.89,74.28 142.73,73.44 142.73,72.93 v2(142.96,72.7) 143.55,72.7 143.62,72.63 R427.1
PCH_SPI_CS0#: length 18.9
  TOP w0.102: R5614.2 178.07,76.43 R5601.2 R5611.1 176.41,76.53 v2(176.18,76.29)
  BOTTOM w0.102: TP5600.1 167.65,79.08 170.26,79.08 172.94,76.4 173.95,76.4 174.86,75.49 175.18,75.49 175.98,76.29 v2(176.18,76.29) 176.18,75.99 176.04,75.85 176.04,75.52 175.48,74.96 175.48,74.51 175.99,74 176.38,74 176.65,73.73 176.65,73.34 177.1,72.89 U5600.1
PCH_SPI_CS0#_E1: length 47.9
  TOP w0.102: v2(199.91,61.35) 199.93,61.33 200.43,61.33 v2(200.66,61.1) 200.84,60.92 201.49,60.92 202,60.41 202.52,60.41 202.94,59.98 R4757.2 ; v2(178.75,74.96) 178.96,75.17 R5614.1
  IN1 w0.114: v2(174.81,63.71) 175.16,64.05 175.16,65.66 176.58,67.09 176.58,70.08 176.29,70.38 176.29,71.08 176.58,71.37 177.47,71.37 178.75,72.65 v2(178.75,74.96)
  BOTTOM w0.102: v2(199.91,61.35) 199.68,61.12 198.93,61.12 198.34,61.7 197.99,61.7 197.36,61.07 196.02,61.07 195.96,61.12 194.54,61.12 194.27,61.38 192.17,61.38 189.47,64.09 188.38,64.09 187.72,64.75 186.72,64.75 185.08,63.11 184.38,63.11 182.44,61.17 180.24,61.17 179.2,62.21 176.18,62.21 174.81,63.58 v2(174.81,63.71)
