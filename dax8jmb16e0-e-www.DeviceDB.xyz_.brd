# Allegro board dax8jmb16e0-e-www.DeviceDB.xyz_.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM (solid shape): 185.99,35.64 185.99,34.35 185.94,34.17 185.99,33.98 185.99,33.34 185.94,33.15 185.99,32.97 185.99,32.67 185.91,32.59 184.31,32.59 183.27,31.55 182.41,31.55 182.28,31.68 182.28,32.66 182.32,32.74 182.41,32.76 182.85,32.93 182.73,33.39 182.13,33.99 181.49,33.99 181.29,34.19 181.29,34.91 181.52,35.14 181.8,35.14 181.86,35.13 181.91,35.14 182.01,35.17 182.1,35.24 182.74,35.24 183.29,35.79 185.83,35.79
GND on BOTTOM (solid shape): 61.81,125.64 62.16,125.28 63.71,125.28 63.84,125.15 63.84,124.75 63.98,124.6 64.59,124.6 64.92,124.27 64.92,123.45 65.01,123.37 66.28,123.37 66.28,123.37 66.89,123.37 67.32,122.94 67.6,122.94 68.44,122.1 68.44,117.58 68.33,117.48 67.73,117.48 67.57,117.33 67.57,116.34 67.88,116.03 68.89,116.03 69.17,115.75 69.17,115.45 68.77,115.04 68.39,115.04 67.98,114.64 67.98,114.33 68.28,114.03 68.61,114.03 68.74,113.9 68.74,113.37 68.31,112.93 68.31,108.72 68.13,108.54 67.45,108.54 67.32,108.41 67.32,107.27 67.55,107.04 67.93,107.04 68.08,106.89 68.08,106.65 67.93,106.49 66.14,106.49 65.79,106.84 65.79,111.69 64.96,112.53 64.22,112.53 64.04,112.71 64.04,115.65 64.58,116.18 65.41,116.18 65.74,116.51 65.74,122.08 65.71,122.11 65.71,122.12 65.64,122.19 65.6,122.25 65.54,122.29 65.5,122.33 65.49,122.33 65.44,122.38 62.24,122.38 62.23,122.4 58.8,122.4 58.5,122.69 58.5,127.44 58.84,127.77 61.81,127.77
GND on BOTTOM (solid shape): 229.98,44.84 230.28,44.13 230.99,43.83 235.6,43.83 235.6,44.23 238.9,44.23 239.25,44.09 239.39,43.74 239.39,40.28 239.25,39.93 238.9,39.79 235.6,39.79 235.6,40.19 230.99,40.19 230.28,39.89 229.98,39.18 229.98,38.31 229.8,38.13 227.87,38.13 227.36,38.64 227.36,45.85 227.55,46.04 229.98,46.04
GND on BOTTOM (solid shape): 106.41,75.44 106.41,75.14 106.28,75.02 106.26,75.01 106.24,75.01 105.84,74.69 106.27,74.41 106.37,74.4 106.41,74.31 106.41,74.08 106.18,73.86 105.85,73.45 106.35,73.29 107.02,72.62 107.88,72.62 108.14,72.37 108.14,71.43 107.76,71.05 102.17,71.05 101.58,71.63 101.58,72.32 102.01,72.75 104.05,72.75 104.94,73.64 104.94,74.88 105.6,75.54 106.31,75.54
GND on BOTTOM (solid shape): 97.08,88.44 97.08,87.73 97.02,87.67 96.78,87.49 96.8,87.19 96.8,87.09 96.72,87.04 96.62,87.01 96.55,86.95 96.48,86.91 96.41,86.93 96.24,87.01 96.06,87.04 95.97,86.94 95.12,86.94 95.05,87.01 95.05,87.2 95.1,87.25 95.76,87.25 95.82,87.32 95.88,87.38 95.92,87.46 95.95,87.48 95.99,87.48 96.29,87.58 96.23,87.89 96.22,87.91 96.21,87.93 96.21,88.38 96.41,88.58 96.95,88.58
GND on BOTTOM (solid shape): 61.67,111 61.67,107.97 61.45,107.75 60.72,107.75 60.72,107.74 60.5,107.74 60.23,107.47 59.94,107.47 59.8,107.47 59.65,107.41 59.59,107.27 59.58,107.12 59.59,106.97 59.65,106.82 59.8,106.77 59.92,106.75 59.94,106.71 59.94,105.81 59.5,105.38 56.77,105.38 56.7,105.31 56.69,105.31 56.69,105.29 56.6,105.2 56.6,104.24 56.58,104.21 56.58,104.1 56.57,104.09 56.57,103.82 56.14,103.39 55.43,103.39 54.9,103.92 54.9,104.73 55.05,104.88 55.28,104.88 55.41,105.01 55.41,106.48 55.3,106.58 54.11,106.58 53.93,106.77 53.92,106.82 53.91,106.86 53.91,107.07 54.22,107.38 55.17,107.38 55.47,107.69 57.26,107.69 57.64,108.07 57.64,111 57.94,111.3 61.37,111.3
GND on BOTTOM (solid shape): 99.13,99.62 99.42,99.62 99.58,99.47 99.59,99.45 99.84,99.26 100.06,99.48 100.06,99.5 100.16,99.6 100.39,99.6 100.5,99.48 100.51,99.47 100.57,99.33 100.71,99.27 100.72,99.26 100.92,99.07 100.92,98.79 100.85,98.71 100.67,98.71 100.62,98.76 100.59,98.83 100.59,98.89 100.41,99.07 100.24,99.07 100.1,98.93 100.06,98.89 99.88,98.71 99.7,98.71 99.68,98.74 99.67,98.78 99.65,98.84 99.65,98.89 99.45,99.09 99.3,99.09 99.19,98.98 99.13,98.94 99.09,98.88 99.04,98.84 99.04,98.79 98.94,98.68 98.84,98.68 98.75,98.78 98.74,98.81 98.74,99.27 98.74,99.27 98.75,99.37 98.74,99.46 98.74,99.46 98.74,99.6 98.8,99.66 99.09,99.66
GND on BOTTOM (solid shape): 236.79,81.06 239.39,81.06 239.39,80.52 239.39,80.37 239.25,80.02 238.9,79.88 232.55,79.88 231.58,79.13 232.04,78 232.04,77.3 231.26,77.3 231.03,77.54 230.57,79.29 231.71,80.71 231.71,82.4 232.96,83.66 236.79,83.66
GND on BOTTOM (solid shape): 224.85,49.43 224.85,48.42 224.65,48.21 219.77,48.21 219.64,48.09 219.64,47.12 220.56,46.21 220.79,46.21 221.01,45.98 221.01,42.17 220.91,42.07 219.41,42.07 219.15,42.33 219.15,43.39 219.13,43.4 219.13,43.53 218.95,43.72 218.82,43.72 218.47,44.07 218.46,44.08 218.37,44.25 218.2,44.34 218.19,44.35 217.37,45.16 217.37,46.3 217.68,46.61 217.68,47.27 217.75,47.34 217.75,47.9 217.76,47.92 217.78,47.94 217.95,48.2 217.85,48.5 217.82,48.57 217.85,48.64 218.91,49.7 220.9,49.7 221,49.69 221.11,49.7 221.68,49.7 221.78,49.69 221.89,49.7 222.5,49.7 222.53,49.67 222.92,49.51 223.31,49.67 223.43,49.79 224.49,49.79
GND on BOTTOM (solid shape): 144.46,129.3 144.46,128.68 144.29,128.5 136.56,128.5 136.08,128.02 135.21,128.02 135.07,127.88 135.07,127.73 135.06,127.72 135.06,126.8 134.6,126.34 134.6,125.15 134.48,125.03 133.28,125.03 133.18,125.11 133.18,125.23 133.2,125.27 133.23,125.28 133.74,125.28 133.74,125.53 133.23,125.53 133.2,125.54 133.18,125.58 133.18,125.73 133.2,125.77 133.23,125.78 133.74,125.78 133.74,126.03 133.23,126.03 133.2,126.04 133.18,126.08 133.18,126.23 133.2,126.27 133.23,126.28 133.74,126.28 133.74,126.53 133.23,126.53 133.2,126.54 133.18,126.58 133.18,127.62 133.03,127.77 132.6,127.77 132.47,127.89 132.47,128.72 132.32,128.87 131.85,128.87 131.78,128.81 131.77,128.81 131.67,128.73 131.63,128.67 131.54,128.58 131.33,128.58 131.12,128.78 130.65,128.78 130.4,128.53 130.02,128.53 129.77,128.78 129.75,128.78 129.73,128.81 129.42,128.81 129.22,129.01 129.22,129.6 129.35,129.72 144.04,129.72
GND on BOTTOM (solid shape): 241,11.53 241.35,11.39 241.49,11.04 241.49,1.99 240.61,1 239.42,0.42 238.25,0.31 237.1,0.59 236.67,0.95 236.51,1.5 236.51,2.43 236.4,3.08 236.09,3.66 235.8,4.03 235.27,4.45 234.62,4.6 214.29,4.6 214.29,4.1 209.8,4.1 209.73,4.16 209.73,4.85 209.79,4.92 214.67,4.92 215.37,5.61 216.88,5.61 217.22,5.27 224.29,5.27 224.63,5.61 229.32,5.61 229.64,5.93 229.64,8.38 230.15,8.9 235.72,8.9 237.35,10.52 237.35,11.33 237.55,11.53
GND on BOTTOM (solid shape): 133.2,96.63 133.23,96.62 133.25,96.6 133.37,96.46 133.55,96.41 133.58,96.41 133.59,96.4 133.72,96.27 133.72,96.22 133.59,96.09 133.2,95.92 133.32,95.52 133.37,95.45 133.36,95.38 133.36,95.12 133.59,95.02 133.75,95.02 133.94,94.82 133.94,93.63 133.84,93.53 133.41,93.53 133.26,93.68 133,93.68 132.75,93.93 132.75,94.06 132.6,94.21 132.19,94.21 132.12,94.14 132.01,94.14 131.99,94.15 131.98,94.16 131.93,94.2 131.93,94.46 132.37,94.89 132.37,95.25 132.21,95.41 131.96,95.41 131.91,95.36 131.63,95.36 131.58,95.41 128.79,95.41 128.76,95.37 128.68,95.32 128.52,95.32 128.12,95.73 127.98,95.87 127.98,95.87 127.95,95.9 127.95,96.38 128.19,96.63
GND on BOTTOM (solid shape): outline of 108 points within 178.04,19.56 185.05,24.36
GND on BOTTOM (solid shape): 133.78,87.94 133.78,87.83 133.76,87.81 133.74,87.79 133.71,87.79 133.36,87.65 133.4,87.27 133.43,87.2 133.4,87.13 133.34,87.04 133.32,86.91 133.31,86.89 133.27,86.85 133.27,86.64 132.9,86.28 130.04,86.28 129.84,86.48 129.84,86.75 129.87,86.82 129.94,86.85 130.17,86.97 130.23,87.24 130.23,87.25 130.23,87.27 130.41,87.45 130.56,87.45 130.59,87.44 130.61,87.42 130.83,87.35 131.01,87.5 131.02,87.51 131.19,87.68 131.2,87.68 131.28,87.71 131.34,87.75 131.36,87.76 131.45,87.76 131.47,87.75 131.49,87.74 131.73,87.63 131.98,87.74 132,87.75 132.02,87.76 132.1,87.76 132.11,87.75 132.33,87.67 132.53,87.76 132.97,87.76 133.35,88.13 133.59,88.13
GND on BOTTOM (solid shape): 235.52,112.76 235.71,112.41 236.09,112.28 236.16,112.25 236.19,112.18 236.19,111.96 235.73,110.82 236.7,110.08 241.5,110.08 241.85,109.94 241.99,109.59 241.99,109.01 241.85,108.66 241.5,108.52 239.85,108.52 239.85,103.69 239.72,103.56 234.93,103.56 234.74,103.75 234.74,104.26 234.76,104.27 235.57,105.79 234.74,107.3 234.74,110.57 234.68,111.06 234.73,111.55 234.77,111.65 234.79,111.75 234.81,111.81 234.83,111.87 234.83,112.71 234.93,112.81 235.51,112.81
GND on BOTTOM (solid shape): 166.79,120.99 167.23,119.92 168.3,119.48 171.54,119.48 171.72,119.44 171.88,119.34 173.3,117.92 173.4,117.76 173.44,117.58 173.44,115.95 183.21,115.95 183.21,116.89 183.35,117.24 183.7,117.38 193.71,117.38 193.71,118.38 193.75,118.56 193.85,118.72 195.27,120.14 195.43,120.24 195.61,120.28 199.79,120.28 199.97,120.24 200.13,120.14 201.55,118.72 201.65,118.56 201.69,118.37 201.69,117.38 205.93,117.38 213,117.38 213.35,117.24 213.49,116.89 213.49,115.96 212.48,115.96 212.48,116.36 200.68,116.36 199.63,115.32 195.77,115.32 194.72,116.36 184.22,116.36 184.22,114.93 172.43,114.93 172.43,114.94 171.41,113.92 168.89,113.92 167.22,115.6 167.22,118.5 166.59,119.13 165.99,119.98 165.78,120.99 165.78,121.98 166.79,121.98
GND on BOTTOM (solid shape): 232.04,65.24 231.58,64.1 232.55,63.36 240,63.36 240.35,63.22 240.49,62.87 240.49,62.17 240.35,61.82 240,61.68 238.49,61.68 238.49,59.34 238.35,58.99 238,58.85 235.6,58.85 235.6,59.25 230.99,59.25 230.28,58.95 229.98,58.24 229.98,57.13 227.77,57.13 227.44,57.46 227.44,58.37 227.87,58.81 228.9,58.81 229.13,59.04 229.47,59.57 229.95,59.97 231.3,61.33 231.3,62.76 231.25,62.82 230.53,64.21 231.03,65.7 231.03,65.97 232.04,65.97
GND on BOTTOM (solid shape): outline of 162 points within 120.23,118.78 127.21,126.55
GND on BOTTOM (solid shape): outline of 119 points within 35.59,24.49 42.07,27.39
GND on BOTTOM (solid shape): 234.22,124.78 234.31,124.73 234.24,123.16 235.51,122.4 236.5,122.4 237.46,122.78 237.93,123.71 238,123.79 238.1,123.76 238.35,123.47 238.36,123.46 239.2,122.48 239.71,122.09 240.35,121.95 240.39,121.95 240.74,121.81 240.88,121.46 240.88,121.09 240.74,120.74 240.39,120.6 236.7,120.6 235.73,119.85 236.19,118.72 236.19,118.5 236.16,118.43 236.09,118.4 235.73,118.28 235.53,117.96 234.59,117.96 234.54,118.01 234.54,118.19 234.56,118.2 233.99,119.57 233.59,118.15 233.63,118.03 233.53,117.96 227.82,117.96 227.82,117.39 227.82,117.31 227.82,117.23 227.77,117.09 227.79,116.94 227.66,116.49 227.46,116.08 226.69,116.08 226.4,116.36 226.7,116.84 226.81,117.39 226.81,120.3 226.81,122.27 226.85,122.46 226.95,122.62 228.24,123.91 228.24,123.91 228.97,124.64 229.13,124.74 229.31,124.78
GND on BOTTOM (solid shape): outline of 270 points within 113.84,98.68 122.18,101.41
GND on BOTTOM (solid shape): outline of 138 points within 108.87,82.96 113.94,86.01
GND on BOTTOM (solid shape): outline of 162 points within 114.45,82.81 121.3,85.32
GND on BOTTOM (solid shape): outline of 1457 points within 0.51,4.1 207.73,137.18
GND on BOTTOM (solid shape): outline of 1400 points within 98.29,86.07 111.11,88.22
GND on BOTTOM (solid shape): outline of 1299 points within 94.4,80.66 109.31,86.58
GND on BOTTOM (solid shape): outline of 1402 points within 101.18,79.78 125.72,85.41
GND on SVCC (solid shape): 12.51,110.58 12.55,110.35 12.71,110.18 12.71,108.66 12.21,108.16 11.96,108.16 11.66,108.46 11.63,108.48 11.59,108.49 9.51,108.49 9.47,108.48 9.43,108.46 8.34,107.36 7.93,107.34 7.78,106.96 6.63,106.96 6.43,107.16 6.43,108.47 6.76,108.79 7.47,108.79 7.51,108.8 7.55,108.82 9.55,110.83 12.26,110.83
GND on SVCC (solid shape): 40.93,33.13 40.97,33.11 41.01,33.1 42.02,33.1 42.16,33.08 42.29,33.1 45.03,33.1 46.01,32.11 46.07,32.04 46.14,31.99 46.27,31.86 46.3,31.84 46.34,31.83 49.85,31.83 50.63,31.05 50.67,31.03 50.71,31.02 51.12,31.02 51.39,30.75 51.39,30.34 51.4,30.3 51.42,30.26 53.28,28.41 53.31,28.38 53.35,28.38 53.64,28.38 53.94,28.07 53.93,27.95 53.96,27.82 53.96,27.77 53.96,27.73 53.99,27.7 54.75,26.93 54.86,26.74 55.05,26.63 57.88,23.81 56.58,22.39 57.04,20.53 56.99,20.38 56.9,20.25 56.49,19.85 56.48,19.84 56.32,19.73 56.14,19.7 25.7,19.7 24.99,19.4 24.69,18.69 24.69,18.02 21.9,18.02 21.55,18.16 21.41,18.51 21.41,23.02 21.45,23.22 21.56,23.38 21.61,23.42 25.48,27.56 28.68,32.25 28.7,32.29 28.88,32.47 29.12,32.53 34.14,32.53 35.97,32.06 37.39,33.3 37.88,33.79 37.91,33.82 37.93,33.86 40.2,33.86
GND on SVCC (solid shape): outline of 3587 points within 15.58,0.3 241.99,137.18
GND on IN1 (solid shape): 44.74,31.22 44.74,29.22 44.33,28.81 42.8,28.81 42.64,28.97 42.64,31.34 42.75,31.45 44.51,31.45
GND on IN1 (solid shape): 153.28,82.64 155.83,82.64 155.94,82.53 155.94,81.47 155.4,80.93 152.51,80.93 152.23,81.21 152.23,82.58 152.29,82.64 153.27,82.64
GND on IN1 (solid shape): 190.97,62.26 190.97,60.74 190.74,60.51 187.73,60.51 187.53,60.71 187.53,63.06 187.77,63.3 189.92,63.3
GND on IN1 (solid shape): 150.51,102.59 150.51,102.48 150.78,102.21 151.83,102.21 152.04,102 152.04,100.17 151.74,99.87 151.27,99.87 151.06,100.08 150.15,100.08 149.91,99.84 149.61,99.84 149.29,100.16 149.29,101.64 150.36,102.71 150.38,102.71
GND on IN1 (solid shape): 229.98,25.78 230.28,25.07 230.99,24.77 235.6,24.77 235.6,25.17 238.4,25.17 238.75,25.03 238.89,24.68 238.89,22.82 237.88,22.82 237.88,24.15 236.61,24.15 236.61,23.75 235.9,23.75 235.59,24.06 229.4,24.06 228.99,23.65 228.43,23.65 227.29,24.8 227.29,26.8 227.62,27.13 229.98,27.13
GND on IN1 (solid shape): 229.98,44.84 230.28,44.13 230.99,43.83 235.6,43.83 235.6,44.23 238.9,44.23 239.25,44.09 239.39,43.74 239.39,40.28 239.25,39.93 238.9,39.79 235.6,39.79 235.6,40.19 230.99,40.19 230.28,39.89 229.98,39.18 229.98,38.05 227.82,38.05 227.29,38.59 227.29,45.8 227.57,46.08 229.98,46.08
GND on IN1 (solid shape): 236.79,81.06 239.39,81.06 239.39,80.65 239.39,80.37 239.25,80.02 238.9,79.88 232.55,79.88 231.58,79.13 232.04,78 232.04,77.25 232.04,77.25 231.03,77.25 231.03,77.54 230.54,79.12 231.4,80.54 231.4,83.06 232.72,84.38 236.79,84.38
GND on IN1 (solid shape): 241,11.53 241.35,11.39 241.49,11.04 241.49,1.99 240.5,0.92 239.16,0.36 238.11,0.32 237.1,0.59 236.67,0.95 236.51,1.5 236.51,2.43 236.4,3.08 236.09,3.66 235.8,4.03 235.27,4.45 234.62,4.6 214.29,4.6 214.29,4.1 209.39,4.1 209.52,4.61 209.37,5.11 213.28,5.11 213.28,5.61 216.85,5.61 217.12,5.34 224.02,5.34 224.82,6.15 224.82,7.45 224.98,7.6 225.97,7.6 226.48,8.11 229.09,8.11 229.26,8.32 229.45,8.51 229.86,8.92 235.68,8.92 237.22,10.46 237.22,11.28 237.47,11.53
GND on IN1 (solid shape): 235.52,112.76 235.71,112.41 236.09,112.28 236.16,112.25 236.19,112.18 236.19,111.96 235.73,110.82 236.7,110.08 241.5,110.08 241.85,109.94 241.99,109.59 241.99,109.01 241.85,108.66 241.5,108.52 239.85,108.52 239.85,103.43 239.61,103.18 235.25,103.18 234.74,103.69 234.74,104.26 234.76,104.27 235.57,105.79 234.74,107.3 234.74,110.57 234.68,111.06 234.73,111.55 234.77,111.65 234.79,111.75 234.81,111.81 234.83,111.87 234.83,112.71 234.93,112.81 235.51,112.81
GND on IN1 (solid shape): 232.04,65.24 231.58,64.1 232.55,63.36 240,63.36 240.35,63.22 240.49,62.87 240.49,62.17 240.35,61.82 240,61.68 238.49,61.68 238.49,59.34 238.35,58.99 238,58.85 235.6,58.85 235.6,59.25 230.99,59.25 230.28,58.95 229.98,58.24 229.98,56.48 229.94,56.4 229.85,56.39 228.83,56.1 228.78,55.05 228.78,54.69 228.51,54.41 227.95,54.41 227.57,54.79 227.57,58.58 227.92,58.93 229.09,58.93 229.1,58.95 229.64,59.75 230.5,60.2 231.38,61.08 231.38,62.69 231.22,62.84 230.53,64.23 231.03,65.7 231.03,66.02 232.04,66.02
GND on IN1 (solid shape): 234.22,124.78 234.31,124.73 234.24,123.16 235.51,122.4 236.5,122.4 237.46,122.78 237.93,123.71 238,123.79 238.1,123.76 238.35,123.47 238.36,123.46 239.2,122.48 239.71,122.09 240.35,121.95 240.39,121.95 240.74,121.81 240.88,121.46 240.88,121.09 240.74,120.74 240.39,120.6 236.7,120.6 235.73,119.85 236.19,118.72 236.19,118.5 236.16,118.43 236.09,118.4 235.84,118.35 235.65,118.2 235.64,118.19 234.77,118.19 234.68,118.25 234.69,118.35 234.04,119.57 233.39,118.35 233.4,118.25 233.31,118.19 232.84,118.19 232.69,118.04 231.5,118.04 231.45,117.99 227.82,117.99 227.82,117.67 227.63,117.48 226.81,117.48 226.81,120.3 226.81,122.27 226.85,122.46 226.95,122.62 228.36,124.03 228.97,124.64 229.13,124.74 229.31,124.78
GND on IN1 (solid shape): outline of 752 points within 175.37,19.55 195.47,29.67
GND on IN1 (solid shape): outline of 386 points within 0.51,4.1 222.58,137.18
GND on IN1 (solid shape): outline of 2539 points within 51.29,96.88 78.04,121.8
GND on IN2 (solid shape): 44.84,31.07 44.84,29.16 44.51,28.83 42.91,28.83 42.78,28.96 42.78,31.35 42.91,31.48 44.43,31.48
GND on IN2 (solid shape): 150.56,102.71 150.56,102.31 150.66,102.21 151.81,102.21 151.97,102.05 151.97,100.21 151.85,100.09 150.11,100.09 149.88,99.86 149.57,99.86 149.31,100.12 149.31,101.74 150.33,102.76 150.51,102.76
GND on IN2 (solid shape): 190.97,61.99 190.97,60.76 190.95,60.72 190.91,60.71 188.62,60.71 188.26,61.07 188.26,61.58 187.65,62.19 187.65,63.09 187.76,63.19 189.76,63.19
GND on IN2 (solid shape): 154.11,82.09 154.68,82.09 155.32,81.45 155.34,81.34 155.24,81.28 152.33,81.28 152.3,81.29 152.28,81.33 152.28,82.63 152.41,82.76 153.45,82.76
GND on IN2 (solid shape): 229.98,25.78 230.28,25.07 230.99,24.77 235.6,24.77 235.6,25.17 238.4,25.17 238.75,25.03 238.89,24.68 238.89,23.07 238.73,22.91 237.88,22.91 237.88,24.15 236.61,24.15 236.61,23.75 235.92,23.75 235.62,24.06 229.92,24.06 229.57,23.7 228.43,23.7 227.41,24.72 227.41,25.94 228.3,26.83 229.98,26.83
GND on IN2 (solid shape): 229.98,44.84 230.28,44.13 230.99,43.83 235.6,43.83 235.6,44.23 238.9,44.23 239.25,44.09 239.39,43.74 239.39,40.28 239.25,39.93 238.9,39.79 235.6,39.79 235.6,40.19 230.99,40.19 230.28,39.89 229.98,39.18 229.98,37.98 227.97,37.98 227.26,38.69 227.26,45.67 227.75,46.16 229.98,46.16
GND on IN2 (solid shape): 236.79,84.51 236.79,81.06 239.39,81.06 239.39,80.66 239.39,80.37 239.25,80.02 238.9,79.88 232.55,79.88 231.58,79.13 232.04,78 232.04,77.09 231.03,77.09 231.03,77.54 230.53,78.97 231.17,80.35 231.66,80.84 231.66,83.93 232.07,84.34 232.07,84.35 232.43,84.7 236.59,84.7
GND on IN2 (solid shape): 241,11.53 241.35,11.39 241.49,11.04 241.49,1.99 240.41,0.87 238.95,0.33 238.01,0.33 237.1,0.59 236.67,0.95 236.51,1.5 236.51,2.43 236.4,3.08 236.09,3.66 235.8,4.03 235.27,4.45 234.62,4.6 214.29,4.6 214.29,4.1 209.39,4.1 209.52,4.61 209.37,5.11 213.28,5.11 213.28,5.61 216.8,5.61 217.07,5.34 223.94,5.34 224.65,6.05 224.65,7.5 225.05,7.9 226.32,7.9 226.64,8.23 229.18,8.23 229.31,8.37 229.45,8.51 229.91,8.97 235.75,8.97 237.22,10.44 237.22,11.41 237.35,11.53
GND on IN2 (solid shape): 235.52,112.76 235.71,112.41 236.09,112.28 236.16,112.25 236.19,112.18 236.19,111.96 235.73,110.82 236.7,110.08 241.5,110.08 241.85,109.94 241.99,109.59 241.99,109.01 241.85,108.66 241.5,108.52 239.85,108.52 239.85,103.43 239.63,103.21 235.2,103.21 234.74,103.66 234.74,104.26 234.76,104.27 235.57,105.79 234.74,107.3 234.74,110.57 234.68,111.06 234.73,111.55 234.77,111.65 234.79,111.75 234.81,111.81 234.83,111.87 234.83,112.71 234.93,112.81 235.51,112.81
GND on IN2 (solid shape): 232.04,65.24 231.58,64.1 232.55,63.36 240,63.36 240.35,63.22 240.49,62.87 240.49,62.17 240.35,61.82 240,61.68 238.49,61.68 238.49,59.34 238.35,58.99 238,58.85 235.6,58.85 235.6,59.25 230.99,59.25 230.28,58.95 229.98,58.24 229.98,57.13 228,57.13 227.75,57.38 227.75,58.07 228.28,58.6 228.88,58.6 229.04,58.76 229.71,59.81 230.87,60.26 231.35,60.74 231.35,62.72 231.26,62.81 230.53,64.21 231.03,65.7 231.03,66.36 232.04,66.36
GND on IN2 (solid shape): 234.22,124.78 234.31,124.73 234.24,123.16 235.51,122.4 236.5,122.4 237.46,122.78 237.92,123.7 238,123.79 238.1,123.76 238.24,123.6 238.36,123.46 239.2,122.48 239.71,122.09 240.35,121.95 240.39,121.95 240.74,121.81 240.88,121.46 240.88,121.09 240.74,120.74 240.39,120.6 236.7,120.6 235.73,119.85 236.19,118.72 236.19,118.5 236.16,118.43 236.09,118.4 235.75,118.29 235.54,118 235.53,117.96 234.5,117.96 234.47,117.99 234.44,118.07 234.48,118.14 234.78,119.05 233.98,119.57 233.32,119.1 233.43,118.31 233.44,118.2 233.35,118.14 232.92,118.14 232.77,117.99 231.41,117.99 231.31,117.96 227.82,117.96 227.82,117.83 226.94,116.94 226.82,116.92 226.77,117.03 226.8,117.21 226.81,117.39 226.81,120.3 226.81,122.27 226.85,122.46 226.95,122.62 228.02,123.69 228.97,124.64 229.13,124.74 229.31,124.78
GND on IN2 (solid shape): outline of 784 points within 182.63,19.47 195.06,33.47
GND on IN2 (solid shape): outline of 1615 points within 0.51,4.1 213.49,137.18
GND on SGND (solid shape): outline of 3269 points within 0.51,0.3 241.99,137.18
VDDD_SUPPLY_R on BOTTOM (solid shape): 161.07,78.67 161.07,78.34 160.79,78.06 160.75,78.06 160.31,77.62 160.31,77.57 160.18,77.45 160.18,76.03 160.1,75.95 159.98,75.95 159.88,76.05 159.88,77.78 159.29,78.36 159.29,78.67 159.42,78.8 160.94,78.8
681_BST_1.8V on BOTTOM (solid shape): 163.41,26.14 163.41,25.48 163.25,25.33 161.08,25.33 160.55,24.8 160.45,24.8 160.42,24.81 160.4,24.85 160.4,25.64 160.78,26.01 162.29,26.01 162.72,26.45 163.1,26.45
681_SW_1.8V on TOP (solid shape): 160.64,25.86 160.64,24.29 160.49,24.14 159.93,24.14 159.8,24.26 159.8,25.15 159.76,25.19 159.76,26.1 159.88,26.22 160.28,26.22
681_SW_1.8V on BOTTOM (solid shape): 163.53,27.87 163.53,26.78 163.36,26.61 162.58,26.61 162.14,26.17 160.71,26.17 160.13,25.58 160.13,24.11 160.1,24.08 159.93,24.08 159.9,24.11 159.9,24.88 159.9,25.59 159.9,25.63 159.53,26 159.15,26 158.81,26.35 157.41,26.35 157.21,26.55 157.21,28.3 157.44,28.53 162.87,28.53
2260_BST_1.0V on BOTTOM (solid shape): 132.06,123.86 132.06,123.81 132.06,123.81 132.06,123.35 132.06,123.35 132.06,122.92 132.27,122.71 132.27,121.77 132.24,121.75 131.55,121.75 131.48,121.82 131.48,122.76 131.81,123.08 131.81,123.86 131.82,123.89 131.86,123.91 132.01,123.91
2260_LX_1.0V on BOTTOM (solid shape): 138.13,127.23 138.13,123.7 137.73,123.3 132.86,123.3 132.83,123.31 132.81,123.32 132.81,123.35 132.81,123.81 132.8,123.88 132.7,123.98 132.11,123.98 131.96,124.14 131.96,124.28 133.74,124.28 133.74,124.53 133.28,124.53 133.28,124.28 131.96,124.28 131.96,127.54 132.09,127.67 132.95,127.67 133.08,127.54 133.08,124.98 133.28,124.78 134.46,124.78 134.7,125.03 134.7,126.12 135.24,126.65 135.24,127.54 135.47,127.77 137.6,127.77
8097_EN_2.5V on TOP (solid shape): 166.84,58.17 166.84,57.74 167.17,57.41 167.17,56.11 167.04,55.99 164.63,55.99 164.57,56.04 164.57,56.47 164.63,56.52 166.02,56.52 166.18,56.67 166.18,57.75 166.28,57.85 166.28,58.1 166.4,58.22 166.78,58.22
8097_LX_2.5V on TOP (solid shape): 168.99,59.54 168.99,58.6 168.82,58.43 166.35,58.43 166.18,58.25 166.18,57.89 166.02,57.74 164.6,57.74 164.52,57.82 164.52,58.37 165,58.86 166.15,58.86 166.99,59.7 168.84,59.7
8097_VFB_2.5V on TOP (solid shape): 161.12,58.15 161.12,58.02 161.21,57.93 161.21,57.25 161.3,57.16 161.3,57.03 161.83,56.49 163.25,56.49 163.3,56.44 163.3,56.04 163.25,55.99 161.45,55.99 161.32,56.12 161.3,56.12 161.29,56.13 161.23,56.17 161.17,56.19 161.15,56.19 161.14,56.21 160.1,56.21 160.09,56.22 159.96,56.21 159.79,56.21 159.67,56.33 159.67,57.16 159.8,57.28 159.9,57.28 159.91,57.24 160.47,57.05 160.45,57.64 160.4,57.69 160.4,57.75 160.41,57.81 160.43,57.82 160.43,58.14 160.56,58.27 160.99,58.27
8097_VFB_2.5V_S on TOP (solid shape): 161.84,61.68 161.84,60.72 161.7,60.58 161.29,60.58 161.19,60.69 161.19,60.93 161.18,60.93 161.17,60.96 161.18,60.98 160.85,61.48 160.53,60.97 160.54,60.96 160.54,60.91 160.26,60.64 159.52,60.64 159.39,60.76 159.39,61.14 160.34,62.09 161.43,62.09
8231_LG on BOTTOM (solid shape): 143.18,22.51 143.18,21.65 143.17,21.65 143.17,21.27 142.95,21.05 142.54,21.05 142.4,21.19 142.4,21.67 142.39,21.68 142.39,22.59 142.53,22.73 142.96,22.73
8231_PH on BOTTOM (solid shape): 150.78,31.37 150.78,27.34 149.65,26.2 148.92,26.2 148.73,26 147.51,26 147.25,25.74 147.25,25.08 147.7,24.62 148.62,24.62 148.7,24.54 148.7,22.99 148.61,22.9 147.7,22.9 146.93,23.67 146.88,23.67 146.87,23.68 146.01,23.68 145.52,23.2 142.43,23.2 142.3,23.32 142.3,24.08 142.31,24.1 142.31,25.06 142.78,25.53 144.66,25.53 144.92,25.79 144.92,31.09 145.47,31.65 150.5,31.65
8231_UG on BOTTOM (solid shape): 148.26,25.82 148.48,25.82 148.78,25.53 148.78,25 148.67,24.9 147.73,24.9 147.4,25.23 147.4,25.74 147.51,25.84 148.24,25.84
8231_VLDOIN on BOTTOM (solid shape): 147.73,19.74 147.73,19.18 147.66,19.11 145.96,19.11 145.63,18.78 145.63,17.86 145.55,17.79 145.5,17.79 145.45,17.84 145.45,19.08 145.73,19.36 145.73,19.79 145.88,19.94 147.53,19.94
8693_VCCGT_BST1 on BOTTOM (solid shape): 54.08,101.1 54.08,100.77 54.42,100.44 54.42,99.29 54.21,99.09 53.45,99.09 53.25,99.29 53.25,99.63 53.8,100.18 53.8,101.1 53.81,101.13 53.85,101.15 54.03,101.15
8693_VCCGT_HG1 on BOTTOM (solid shape): 55.71,100.95 55.71,99.55 55.56,99.4 54.87,99.4 54.73,99.54 54.73,100.45 54.31,100.87 54.31,101.63 54.32,101.64 55.02,101.64
8693_VCCGT_HG1_R on BOTTOM (solid shape): 62.11,100.39 62.11,98.63 61.98,98.51 61.2,98.51 61.07,98.63 61.07,99.07 60.21,99.93 60.21,100.56 60.28,100.64 61.86,100.64
8693_VCCGT_HG1_R on BOTTOM (solid shape): 56.37,99.45 56.37,98.63 56.27,98.53 55.84,98.53 55.69,98.38 55.69,98.13 55.53,97.97 54.92,97.97 54.77,98.13 54.77,98.99 54.94,99.15 55.65,99.15 56.07,99.57 56.24,99.57
8693_VCCGT_LG1 on BOTTOM (solid shape): 62.97,106.33 62.97,105.39 62.92,105.34 60.54,105.34 60.18,105.69 60.18,106.18 60.41,106.41 62.9,106.41
8693_VCCGT_LG1 on BOTTOM (solid shape): 55.38,103.26 56.14,103.26 56.29,103.1 56.29,102.77 56.14,102.62 55.56,102.62 55.29,102.89 54.33,102.89 54.32,102.9 54.31,102.92 54.31,103.52 54.43,103.64 54.99,103.64
8693_VCCGT_SW1 on BOTTOM (solid shape): 54.53,98.7 54.53,97.83 54.29,97.59 53.5,97.59 53.2,97.9 53.2,98.94 53.25,98.99 54.24,98.99
8693_VCCGT_SW1 on BOTTOM (solid shape): 64.07,105.57 64.07,104.88 63.64,104.45 63.64,101.12 63.33,100.82 61.45,100.82 61.12,101.15 61.12,101.99 60.84,102.27 56.77,102.27 56.05,101.55 55.6,101.55 55.26,101.89 54.34,101.89 54.32,101.91 54.32,102.12 54.34,102.14 55.87,102.14 56.68,102.95 56.68,104.17 56.7,104.19 56.7,105.16 56.82,105.28 60.09,105.28 60.23,105.14 63.1,105.14 63.23,105.26 63.23,105.64 63.46,105.87 63.76,105.87
8693_VCCSA_BST1 on TOP (solid shape): 108.31,121.34 109.24,121.34 109.33,121.25 109.33,120.85 109.32,120.82 109.28,120.8 107.53,120.8 107.45,120.88 107.45,121.42 107.53,121.49 108.16,121.49
8693_VCCSA_HG1 on TOP (solid shape): 109.61,123.65 109.61,122.48 109.81,122.28 109.81,121.32 109.77,121.28 109.44,121.28 108.44,122.28 108.44,123.81 108.49,123.86 109.41,123.86
8693_VCCSA_HG1_R on TOP (solid shape): 112.05,125.23 112.05,124.41 111.9,124.26 110.46,124.26 110.04,124.26 109.94,124.16 108.7,124.16 108.59,124.26 108.59,125.08 108.95,125.43 111.84,125.43
8693_VCCSA_HG1_R on BOTTOM (solid shape): 112,124.77 112,124.01 111.84,123.86 110.93,123.86 110.83,123.96 110.83,124.85 110.98,125 111.77,125
8693_VCCSA_SW1 on TOP (solid shape): 113.17,123.42 113.17,122.92 112.99,122.74 112.58,122.74 112.02,123.3 110.88,123.3 110.45,122.87 110.45,122.41 110.32,122.29 110.32,121.31 110.31,121.3 110.08,121.3 110.07,121.31 110.07,122.29 110.04,122.32 110.04,122.33 109.74,122.64 109.74,123.4 110.5,124.16 112.43,124.16
8693_VCCSA_SW1 on BOTTOM (solid shape): 114.92,129.9 114.92,126.56 114.88,126.56 114.88,125.98 114.92,125.98 114.92,123.37 114.11,122.56 112.86,122.56 112.43,122.99 112.43,124.69 112.01,125.11 110.8,125.11 110.63,124.93 110.63,124.14 110.5,124.01 107.83,124.01 107.68,124.16 107.68,124.54 108.26,125.13 108.69,125.13 109.48,125.91 109.48,128.46 109.84,128.82 110.43,128.82 110.75,129.14 110.75,130.05 110.78,130.08 114.74,130.08
8693_VCORE_BST1 on BOTTOM (solid shape): 54.24,109.33 54.24,107.65 54.16,107.57 53.7,107.57 53.65,107.63 53.65,108.59 53.75,108.69 53.75,109.48 53.77,109.52 53.8,109.53 54.03,109.53
8693_VCORE_BST2 on BOTTOM (solid shape): 54.49,117.28 54.49,115.45 54.36,115.32 53.91,115.32 53.78,115.45 53.78,117.38 53.79,117.41 53.83,117.43 54.34,117.43
8693_VCORE_HG1 on BOTTOM (solid shape): 56.6,109.96 56.6,109.17 56.57,109.15 54.69,109.15 54.29,109.56 54.29,109.99 54.3,110 54.98,110 55.01,110.03 56.54,110.03
8693_VCORE_HG1_R on BOTTOM (solid shape): 57.23,108.67 57.23,108 57.14,107.9 55.64,107.9 55.58,107.96 55.58,108.69 55.63,108.74 57.16,108.74
8693_VCORE_HG1_R on BOTTOM (solid shape): 63.99,108.03 63.99,107.42 64.07,107.35 65.13,107.35 65.34,107.14 65.34,106.48 65.21,106.36 64.12,106.36 63.15,107.32 63.15,108.01 63.28,108.13 63.89,108.13
8693_VCORE_HG2 on BOTTOM (solid shape): 55.16,117.76 55.18,117.76 55.28,117.66 56.65,117.66 56.78,117.53 56.78,117.02 56.7,116.95 55.3,116.95 54.67,117.58 54.34,117.58 54.26,117.66 54.26,117.82 54.28,117.86 54.31,117.87 55.05,117.87
8693_VCORE_HG2_R on BOTTOM (solid shape): 57.74,116.58 57.74,115.72 57.64,115.62 55.82,115.62 55.77,115.67 55.77,116.58 55.82,116.63 57.69,116.63
8693_VCORE_HG2_R on BOTTOM (solid shape): 64.12,116.92 64.12,116.03 63.99,115.91 63.13,115.91 62.92,115.7 62.29,115.7 62.16,115.83 62.16,116.62 62.31,116.77 62.95,116.77 63.31,117.12 63.91,117.12
8693_VCORE_LG1 on BOTTOM (solid shape): 55.96,112.07 55.96,111.38 55.84,111.26 54.34,111.26 54.24,111.36 54.24,111.87 54.54,112.17 55.86,112.17
8693_VCORE_LG1 on BOTTOM (solid shape): 69.63,108.11 69.63,106.79 69.35,106.51 68.82,106.51 68.16,107.17 67.95,107.17 67.62,107.5 67.62,108.01 67.83,108.21 69.53,108.21
8693_VCORE_LG2 on BOTTOM (solid shape): 70.72,116.82 70.72,115.73 70.57,115.58 70.11,115.58 69.45,116.24 68.03,116.24 67.78,116.49 67.78,117.07 67.85,117.15 70.39,117.15
8693_VCORE_LG2 on BOTTOM (solid shape): 58.28,118.9 58.28,117.18 58.05,116.95 57.16,116.95 56.93,117.18 56.93,118.11 56.21,118.83 55.46,118.83 55.15,119.13 54.42,119.13 54.31,119.23 54.31,119.97 54.42,120.07 57.11,120.07
8693_VCORE_SW1 on BOTTOM (solid shape): 55.25,108.79 55.25,107.75 55.1,107.6 54.49,107.6 54.39,107.7 54.39,108.84 54.44,108.9 55.15,108.9
8693_VCORE_SW1 on BOTTOM (solid shape): 72.93,113.31 72.93,107.45 72.83,107.35 69.86,107.35 69.76,107.45 69.76,108.21 69.6,108.36 69.07,108.36 68.79,108.64 68.79,113.16 69.38,113.75 72.5,113.75
8693_VCORE_SW1 on BOTTOM (solid shape): 56.35,110.88 56.35,110.32 56.27,110.25 54.24,110.25 54.2,110.26 54.19,110.3 54.19,110.45 54.2,110.48 54.24,110.5 55.16,110.5 55.28,110.62 55.28,110.9 55.38,111 56.22,111
8693_VCORE_SW2 on TOP (solid shape): 72.25,117.51 72.25,115.75 72.02,115.52 71.13,115.52 70.95,115.7 70.95,117.53 71.18,117.76 71.99,117.76
8693_VCORE_SW2 on BOTTOM (solid shape): 73.05,122.04 73.05,120.59 73.14,120.49 73.14,116.6 72.17,115.63 71.41,115.63 71.2,115.83 71.2,117.15 70.85,117.51 69.99,117.51 69.83,117.66 68.84,117.66 68.66,117.84 68.66,122.03 69.07,122.43 72.65,122.43
8693_VCSA_LG1 on TOP (solid shape): 112.07,123.02 112.07,122.38 111.69,122 111.69,121.57 111.43,121.31 111.09,121.31 111.07,121.32 111.07,122.29 111.02,122.29 110.99,122.3 110.97,122.34 110.97,122.98 111.11,123.12 111.97,123.12
8693_VCSA_LG1 on BOTTOM (solid shape): 109.28,128.99 109.28,127.97 109.17,127.86 108.66,127.86 108.64,127.84 107.42,127.84 107.35,127.92 107.02,127.92 106.84,128.1 106.84,128.91 107.2,129.27 109,129.27
+BAT_DIS on TOP (solid shape): 112.28,35.21 112.28,30.84 112.1,30.66 108.21,30.66 107.83,30.28 107.83,29.16 107.68,29.01 104.96,29.01 104.76,29.22 104.76,30.74 104.87,30.85 104.87,31.81 105.18,32.11 105.18,34 106.55,35.37 112.11,35.37
+BAT_DIS on BOTTOM (solid shape): 107.81,31.22 107.81,28.3 107.48,27.97 102.97,27.97 102.87,28.07 102.87,28.58 102.73,28.72 102.73,29.32 102.17,29.88 101.57,29.88 101.53,29.92 100.2,29.92 100.14,29.98 100.14,30.37 100.16,30.42 100.18,30.42 100.18,31.01 100.14,31.01 100.14,31.27 100.47,31.6 107.42,31.6
+BATCHG on BOTTOM (solid shape): outline of 115 points within 74.96,27.03 98.41,34.22
+G_SEN_PW on TOP (solid shape): outline of 93 points within 64.47,24.34 69.73,30.31
+G_SEN_PW_S on TOP (solid shape): 73.36,132.54 73.36,131.25 73.31,131.2 73.11,131.2 73.08,131.21 73.06,131.25 73.06,131.63 72.87,131.63 72.87,131.25 72.85,131.21 72.82,131.2 72.55,131.2 72.22,131.53 72.22,132.52 72.37,132.67 73.24,132.67
+SMDDR_VREF_DIMM on TOP (solid shape): 120.07,40.95 120.07,39.93 120.61,39.4 120.61,37.92 120.97,37.55 120.97,37.06 120.72,36.81 119.52,36.81 119.46,36.86 119.46,39.93 119.03,40.37 119.03,41.1 119.06,41.13 119.9,41.13
+SPI_VCC on TOP (solid shape): 178.54,79.43 178.54,77.08 178.38,76.92 177.87,76.92 177.32,77.47 177.32,77.49 177.26,77.59 177.15,77.65 177.14,77.65 176.64,78.15 176.64,79.28 176.88,79.52 177.15,79.52 177.2,79.58 177.22,79.58 177.28,79.6 177.35,79.64 177.37,79.65 178.32,79.65
+SPI_VCC on TOP (solid shape): 172.37,67.52 172.6,67.52 172.66,67.5 172.71,67.49 172.91,67.49 173.11,67.29 173.11,66.88 172.93,66.71 172.93,66.67 172.92,66.66 172.87,66.47 172.92,66.28 172.93,66.27 172.93,66.17 173.39,65.72 173.39,65.31 173.26,65.18 172.96,65.18 172.32,65.82 172.32,66.86 172.07,67.11 171.66,67.11 171.46,67.32 171.46,67.77 171.53,67.85 172.04,67.85
+SPI_VCC on TOP (solid shape): 167.83,69.86 167.86,69.84 167.88,69.81 167.88,67.95 167.84,67.91 167.65,67.91 167.62,67.93 167.6,67.97 167.33,68.31 166.93,68.13 166.43,68.13 166.14,67.84 166.14,67.2 166,67.06 165.39,67.06 165.26,67.19 165.26,67.85 165.08,68.03 164.19,68.03 164.17,68.06 164.17,68.07 163.62,68.07 163.56,68.13 163.56,68.46 164.42,69.32 165.91,69.32 166.26,68.98 166.26,68.97 166.82,68.75 166.79,69.35 166.74,69.42 166.77,69.51 167.12,69.86
+SPI_VCC on IN2 (solid shape): outline of 101 points within 174.23,75.11 176.77,77.15
+VAC on BOTTOM (solid shape): 218.61,108.96 218.61,105.26 218.42,105.07 216.95,105.07 216.95,105.06 216.91,105.02 214.63,105.02 214.51,105.14 214.51,106.09 215.15,106.74 215.63,106.74 215.76,106.86 215.76,107.5 216.26,108 216.26,109 216.34,109.07 217.35,109.07 217.48,109.2 218.37,109.2
+VAC_IN on TOP (solid shape): 218.07,107.5 218.07,105.84 218.37,105.54 219.16,105.54 219.41,105.29 219.77,105.29 219.93,105.12 219.93,105.02 219.95,105.01 219.95,102.95 219.82,102.82 219.52,102.82 219.38,102.96 219.38,103.48 214.57,103.48 214.57,103.45 214.31,103.18 214.05,103.18 213.8,103.43 213.8,104.12 214,104.32 214.21,104.32 214.46,104.07 215.43,104.07 215.53,104.17 215.53,105.06 215.02,105.57 215.02,106.28 214.83,106.47 214.82,106.5 214.83,106.52 214.83,106.8 214.62,107 214.6,107.02 214.59,107.05 214.59,108.04 214.77,108.22 217.35,108.22
+VAC_IN on BOTTOM (solid shape): 219.39,105.29 219.95,105.29 220.02,105.22 220.03,105.19 220.03,105.16 220.04,104.91 220.21,104.73 220.22,104.72 220.39,104.55 220.42,104.55 220.45,104.54 220.47,104.5 220.47,104.34 220.48,104.32 220.48,103.33 219.97,102.82 214.1,102.82 213.75,103.18 213.75,103.97 214.1,104.32 214.23,104.32 214.36,104.2 216.52,104.2 216.93,104.61 218.71,104.61 218.83,104.73 218.83,105.44 218.93,105.54 219.13,105.54
BATT+ on TOP (solid shape): 84.87,28.55 84.87,28.07 86.06,26.88 86.06,26.07 86.05,26.04 86.01,26.02 82.56,26.02 82.52,26.04 82.51,26.07 82.51,26.98 83.19,27.67 83.19,28.81 83.37,28.99 84.44,28.99
BATT+ on BOTTOM (solid shape): 85.72,30.3 85.72,27.94 86.27,27.4 86.27,26.07 86.25,26.04 86.22,26.02 81.42,26.02 81.38,26.04 81.36,26.07 81.36,27.82 81.2,27.98 81.2,30.47 81.37,30.64 85.37,30.64
BQBTST on BOTTOM (solid shape): 123.5,24.57 124.7,24.57 124.77,24.64 125.79,24.64 125.84,24.59 125.84,24.52 125.81,24.49 125.08,24.49 124.94,24.35 123.53,24.35 123.11,23.93 122.51,23.93 122.42,24.02 122.42,24.64 122.64,24.86 123.21,24.86
BQHIDRV on BOTTOM (solid shape): 112.84,30.38 112.84,29.8 112.58,29.55 111.67,29.55 111.54,29.67 111.54,30.03 112,30.49 112.73,30.49
BQHIDRV on BOTTOM (solid shape): 124.32,25.05 125.81,25.05 125.84,25.02 125.84,24.92 125.79,24.87 124.8,24.87 124.61,24.68 123.74,24.68 123.58,24.85 123.58,25.1 123.76,25.28 124.09,25.28
BQLODRV on BOTTOM (solid shape): 116.85,26.83 116.85,26.19 116.67,26.01 114.71,26.01 114.56,26.17 114.56,26.88 114.59,26.9 116.77,26.9
BQLODRV on BOTTOM (solid shape): 125.84,23.81 125.84,23.73 125.79,23.68 125.08,23.68 124.93,23.53 124.93,22.94 124.82,22.84 124.44,22.84 124.27,23.02 124.27,23.35 124.47,23.55 124.72,23.55 125.03,23.86 125.79,23.86
BQPHASE on BOTTOM (solid shape): 125.08,25.46 125.79,25.46 125.87,25.38 125.87,25.33 125.81,25.28 124.42,25.28 124.28,25.42 123.52,25.42 123.43,25.33 122.97,25.33 122.89,25.41 122.89,25.49 122.92,25.52 122.92,25.79 123.15,26.01 124.52,26.01
BQPHASE on BOTTOM (solid shape): 111.37,31.58 111.37,29.53 111.57,29.34 112.58,29.34 113.01,29.77 113.01,30.35 113.11,30.45 114.96,30.45 115.25,30.16 115.25,29.57 114.41,28.73 114.41,26.27 114.13,25.99 112.4,25.99 110.4,28 108.34,28 108.11,28.22 108.11,31.5 108.36,31.76 111.2,31.76
BQVCC on TOP (solid shape): 125.23,26.52 125.23,26.22 125.01,26 124.18,26 123.5,25.33 122.21,25.33 121.9,25.63 121.9,26.24 122.03,26.37 123.07,26.37 123.48,26.78 124.98,26.78
BQVCC on BOTTOM (solid shape): 125.87,26.48 125.87,25.76 125.81,25.71 125.08,25.71 124.57,26.22 124.21,26.22 124.04,26.4 124.04,27.49 124.16,27.62 124.73,27.62
DDR_VTT on TOP (solid shape): 116.21,39.07 117.99,39.07 118.11,38.96 118.11,38.28 117.89,38.07 117.89,37.75 117.69,37.55 112.21,37.55 112.12,37.64 112.12,37.9 112.2,37.98 114.59,37.98 115.25,38.64 115.25,39.17 115.43,39.35 115.93,39.35
DDR_VTT on TOP (solid shape): 176.34,39.05 176.34,38.28 176.69,37.93 183.22,37.93 183.35,37.8 190.99,37.8 191.32,38.13 191.32,38.99 191.5,39.17 192.21,39.17 192.41,38.97 192.41,38.27 192.29,38.15 191.38,37.24 183.11,37.24 182.98,37.12 180.87,37.12 180.87,37.12 175.75,37.12 175.34,37.52 175.34,39.05 175.55,39.25 176.13,39.25
DDR_VTT on BOTTOM (solid shape): 151.39,21.27 151.39,18.75 149.89,18.75 149.61,18.48 149.61,17.84 149.56,17.79 148.78,17.79 148.57,17.58 148.57,17.18 148.42,17.02 147.89,17.02 147.86,17 146.29,17 146.26,17.02 146.26,17.12 146.29,17.15 147.25,17.15 147.4,17.3 147.4,17.56 147.15,17.81 145.98,17.81 145.91,17.89 145.91,18.65 146.01,18.75 148.22,18.75 148.92,19.45 149.32,19.45 149.61,19.74 149.61,20.33 150,20.71 150,21.37 150.15,21.52 151.14,21.52
DDR_VTT on IN1 (solid shape): 159.2,36.41 159.2,35.82 158.88,35.51 157.5,35.51 157.04,35.97 157.04,36.37 157.15,36.48 159.13,36.48
DDR_VTT on IN2 (solid shape): outline of 425 points within 149.72,20 159.22,35.86
HPOUT_L on TOP (solid shape): 225.64,12.58 225.64,12.04 225.6,12.01 224.18,12.01 224.11,12.07 224.11,12.6 224.19,12.68 225.53,12.68
HPOUT_L_C on TOP (solid shape): 227.54,13.49 227.54,12.93 227.49,12.88 227.49,12.68 227.41,12.6 227.41,12.1 227.16,11.84 225.97,11.84 225.89,11.92 225.89,12.65 226.14,12.91 226.27,12.91 226.4,13.04 226.4,13.47 226.58,13.65 227.39,13.65
HPOUT_L_C on TOP (solid shape): 231.03,20.88 231.03,20.28 230.94,20.19 228.73,20.19 228.52,19.98 227.57,19.98 226.98,19.39 227.03,18.61 227.31,17.89 227.31,16.53 226.92,16.13 226.45,16.13 226.39,16.16 226.35,16.16 226.05,16.16 226,16.16 225.94,16.13 225.89,16.13 225.79,16.23 225.79,16.75 225.47,17.07 225.06,17.07 224.97,17.16 224.97,17.71 225.6,18.35 225.6,19.43 225.85,19.68 225.85,19.68 227.23,21.05 230.86,21.05
HPOUT_L_L on TOP (solid shape): 223.91,12.43 223.91,11.97 223.78,11.84 223.35,11.84 222.92,12.27 222.49,12.27 222.46,12.25 221.34,12.25 221.29,12.3 221.29,12.4 221.32,12.43 222.31,12.43 222.41,12.53 223.81,12.53
HPOUT_R on TOP (solid shape): 225.59,13.59 225.59,12.96 225.53,12.91 224.04,12.91 223.99,12.96 223.99,13.42 224.04,13.47 224.16,13.47 224.47,13.77 225.41,13.77
HPOUT_R_C on TOP (solid shape): 226.37,14.48 226.37,14.08 226.27,13.98 226.27,13.26 226.14,13.14 225.76,13.14 225.69,13.21 225.69,13.9 225.67,13.92 225.67,14.35 225.88,14.56 226.3,14.56
HPOUT_R_C on TOP (solid shape): 227.24,10.75 227.24,9.34 227.13,9.08 227.14,8.79 227.12,8.71 227.04,8.67 226.5,8.67 226.35,8.82 226.35,9.2 225.94,9.61 225.94,10.65 226.22,10.93 227.06,10.93
HPOUT_R_R on TOP (solid shape): 223.88,13.34 223.88,12.78 223.73,12.63 221.32,12.63 221.29,12.65 221.29,12.78 221.32,12.81 222.31,12.81 222.33,12.78 222.51,12.78 223.22,13.49 223.73,13.49
L_SPK+ on TOP (solid shape): 220.18,18.7 220.18,16.72 219.47,16.02 219.47,14.64 219.45,14.62 219.32,14.62 219.29,14.65 219.29,16.19 219.72,16.62 219.72,17.91 219.06,18.57 218.83,18.57 218.6,18.81 218.6,19.69 218.68,19.77 219.11,19.77
L_SPK+ on IN1 (solid shape): 219.28,21.17 219.28,18.9 218.98,18.6 218.7,18.6 218.56,18.74 218.56,21.02 218.91,21.37 219.08,21.37
L_SPK- on TOP (solid shape): 218.32,19.54 218.32,18.88 218.74,18.46 219.02,18.46 219.6,17.88 219.6,16.65 219.08,16.13 219.08,14.65 219.06,14.63 218.9,14.63 218.89,14.64 218.89,16.39 219.24,16.75 219.24,17.72 218.99,17.96 218.59,17.96 218.15,18.39 217.84,18.39 217.74,18.5 217.74,19.51 217.86,19.64 218.22,19.64
L_SPK- on IN1 (solid shape): 218.27,20.71 218.27,18.62 218.07,18.42 217.69,18.42 217.41,18.7 217.41,20.5 217.76,20.86 218.12,20.86
MP2949A_VDD18 on TOP (solid shape): 46.76,109.45 47.1,109.45 47.48,109.07 47.48,108.01 47.35,107.88 46.85,107.88 46.69,108.03 46.69,108.54 46.32,108.91 46.32,108.92 46.26,108.99 46.18,109.05 46.18,109.06 46.11,109.12 45.18,109.12 45.17,109.13 45.04,109.15 44.92,109.13 44.89,109.12 44.87,109.1 44.79,109.05 44.73,108.97 44.73,108.96 44.66,108.9 44.66,108.26 44.26,107.85 43.82,107.85 43.76,107.92 43.75,107.93 43.69,108 43.62,108.06 43.59,108.08 43.57,108.09 43.44,108.11 43.32,108.09 43.31,108.08 43.14,108.08 43.01,107.96 42.63,107.96 42.53,108.06 42.53,108.62 42.85,108.94 42.92,108.97 42.99,108.95 43.05,108.91 43.11,108.9 43.41,108.9 43.48,108.91 43.53,108.94 43.55,108.95 43.61,108.95 43.99,109.33 44,109.33 44.24,109.52 44.25,109.82 44.26,109.92 44.35,109.96 46.25,109.96
PVADPTR on TOP (solid shape): 216.67,98.4 216.67,96.22 216.54,96.09 216.01,96.09 215.9,95.98 215.81,95.98 215.81,95.89 215.53,95.61 214.18,95.61 214.02,95.78 214.02,97.35 214.16,97.49 214.49,97.49 214.6,97.6 214.61,97.6 214.61,97.62 214.93,97.93 215.1,97.93 215.21,98.05 215.29,98.17 215.32,98.3 215.32,98.32 215.58,98.58 216.49,98.58
PVADPTR on TOP (solid shape): outline of 2935 points within 134.7,13.82 229.57,91.39
PVADPTR on BOTTOM (solid shape): outline of 592 points within 214.31,88.3 226.8,99.29
R_SPK+ on TOP (solid shape): 218.42,16.85 218.42,15.88 218.27,15.73 218.27,14.64 218.09,14.64 218.09,15.65 217.93,15.82 217.93,16.91 217.99,16.97 218.3,16.97
R_SPK+ on IN1 (solid shape): 218.4,17.05 218.4,16.54 218.68,16.26 219.59,16.26 219.77,16.08 219.77,15.19 219.57,14.99 218.17,14.99 217.48,15.68 217.48,16.79 217.79,17.1 218.35,17.1
R_SPK- on TOP (solid shape): 219.11,17.66 219.11,16.78 218.77,16.44 218.77,15.82 218.68,15.73 218.68,14.69 218.65,14.66 218.52,14.66 218.5,14.69 218.5,15.73 218.58,15.8 218.58,17.68 218.7,17.81 218.96,17.81
R_SPK- on IN1 (solid shape): 220.28,18.39 220.28,17.85 219.53,17.1 219.53,17.07 219,16.54 218.76,16.54 218.65,16.65 218.65,17.15 218.65,17.84 219.46,18.65 220.02,18.65
REGN6V on TOP (solid shape): 124.29,24.21 124.65,24.21 125.38,23.47 125.38,22.33 124.96,21.91 123.52,21.91 122.97,22.46 122.97,23.02 123.55,23.6 123.57,23.6 123.66,23.69 123.71,23.69 123.71,23.74 123.76,23.79 123.76,24.19 123.81,24.24 124.27,24.24
REGN6V on BOTTOM (solid shape): 125.84,24.21 125.84,24.11 125.81,24.08 125.08,24.08 124.7,23.7 124.11,23.7 123.93,23.88 123.93,24.11 124.04,24.21 125.03,24.21 125.08,24.26 125.79,24.26
SLEEVE_C on TOP (solid shape): 227.21,23.5 227.21,22.76 227.36,22.61 227.36,21.62 226.86,21.11 226.2,21.11 226.19,21.11 226.03,21.11 225.8,21.35 225.8,21.94 225.95,22.1 225.98,22.1 226.29,22.09 226.48,22.33 226.49,22.35 226.55,22.41 226.55,23.47 226.65,23.58 227.14,23.58
SLEEVE_C on IN1 (solid shape): 228.48,22.43 228.48,21.67 228.37,21.56 228.27,21.52 228.11,21.45 227.94,21.37 226.81,21.37 226.29,21.88 226.29,22.05 226.3,22.08 226.32,22.09 226.48,22.27 226.5,22.5 226.5,22.52 226.51,22.55 226.68,22.71 228.2,22.71
SLEEVE_L on TOP (solid shape): 225.54,21.86 225.54,21.29 226.17,20.66 226.17,20.53 226.06,20.41 225.42,20.41 225.26,20.58 225.26,20.59 225.13,20.72 225.13,21.02 225.03,21.12 225.03,21.83 225.12,21.92 225.47,21.92
SLEEVE_L on IN1 (solid shape): 220.56,9.91 220.56,9.51 219.26,8.21 218.87,8.21 218.37,8.71 218.34,8.77 218.3,8.82 218.29,8.83 218.28,8.85 218.28,9.34 219.08,10.14 220.33,10.14
SMDDR_VREF_DQ1_M1 on TOP (solid shape): 123.13,39.51 123.13,38.84 122.98,38.69 122.98,37.14 122.83,36.99 122.33,36.99 122.26,37.06 122.26,38.37 121.94,38.69 121.94,39.77 121.39,40.32 120.66,40.32 120.61,40.37 120.61,41.08 120.66,41.13 121.52,41.13
SN3V on TOP (solid shape): 177.78,24.24 177.78,23.98 177.88,23.88 177.88,22.56 177.73,22.41 177,22.41 176.84,22.56 176.84,24.06 177.12,24.34 177.68,24.34
SY8270C_LX on BOTTOM (solid shape): 190.71,28.48 190.84,28.45 190.96,28.48 190.97,28.48 191.49,28.48 191.5,28.48 191.63,28.45 191.75,28.48 191.76,28.48 192.06,28.48 192.28,28.26 192.28,26.74 191.89,26.36 191.21,26.36 190.87,26.02 190.87,19.52 190.86,19.51 190.86,18.8 190.86,18.78 190.61,18.52 190.08,18.52 190,18.6 190,19.77 190.43,20.19 190.43,24.18 189.66,24.95 189.66,25.99 189.53,26.12 188.8,26.12 188.5,26.42 188.5,28.25 188.73,28.48 190.7,28.48
SY8270CBST on BOTTOM (solid shape): 190.15,21.39 190.15,20.38 189.8,20.03 189.8,19.18 189.78,19.17 189.78,18.57 189.71,18.5 188.96,18.5 188.78,18.67 188.78,19.92 188.9,20.04 188.92,20.04 189.14,20.14 189.25,20.37 189.25,20.39 189.44,20.58 189.44,21.04 189.65,21.26 189.65,21.26 189.8,21.4 190.13,21.4
SY8286BBST on BOTTOM (solid shape): 181.87,25 181.87,24.26 180.98,23.37 180.02,23.37 179.97,23.42 179.97,23.67 179.98,23.68 179.98,24.04 181.03,25.1 181.77,25.1
SY8286BBSW on TOP (solid shape): 179.15,24.87 179.15,23.53 179.08,23.45 178.34,23.45 178.27,23.53 178.27,24.45 178.34,24.57 178.36,24.73 178.37,24.75 178.65,25.02 179,25.02
SY8286BBSW on BOTTOM (solid shape): 180.23,28.29 180.77,28.29 181.08,27.97 181.08,26.75 180.2,25.86 180.09,25.86 179.79,25.56 179.79,25.1 179.87,25.02 179.87,23.75 179.76,23.65 179.71,23.65 179.66,23.7 179.66,24.29 179.61,24.34 179.46,24.34 179.41,24.29 179.41,23.68 179.36,23.63 179.26,23.63 179.18,23.7 179.18,24.31 179.08,24.41 178.82,24.41 178.6,24.64 178.6,25.12 178.57,25.14 178.57,25.2 178.06,25.71 177.1,25.71 176.69,26.12 176.69,28.17 176.82,28.3 180.22,28.3
TRA_V_DAC on TOP (solid shape): 211.54,74.17 211.54,66.05 211.36,65.87 211.33,65.87 210.95,65.49 210.42,65.49 210.3,65.61 210.3,67.54 209.64,68.2 209.64,71.5 209.67,71.58 209.89,71.59 210.04,71.6 210.18,71.66 210.24,71.81 210.24,71.95 210.24,72.75 209.62,73.37 209.61,73.39 209.61,73.41 209.61,74.33 209.99,74.71 211.01,74.71
TYPEC1_USB0 on TOP (solid shape): 224.49,101.28 224.49,99.5 223.6,98.61 222.18,98.61 221.53,97.95 221.51,97.94 221.49,97.94 221.33,97.87 221.25,97.71 221.25,97.69 219.74,96.18 219.74,96.17 219.72,96.14 219.72,95.38 218.98,94.64 218.88,94.64 218.81,94.63 218.73,94.57 218.71,94.57 218.42,94.57 217.81,95.18 216.9,95.18 216.82,95.26 216.82,98.35 217,98.53 219.13,98.53 219.21,98.61 219.23,98.61 219.24,98.63 219.24,98.99 219.39,99.14 219.39,100.72 219.59,100.92 219.87,100.92 219.91,100.9 219.92,100.87 219.92,100.74 220.28,100.39 220.63,100.74 220.63,100.87 220.65,100.9 220.68,100.92 220.84,100.92 221.09,101.17 221.09,101.4 221.22,101.53 224.24,101.53
TYPEC_VBUS on TOP (solid shape): 225,96.73 225,95.71 224.72,95.43 223.17,95.43 222.79,95.81 222.79,96.42 222.72,96.5 222.36,96.5 222.28,96.58 222.28,96.8 222.36,96.88 224.85,96.88
TYPEC_VBUS on TOP (solid shape): 225.79,105.94 225.79,103.83 225.69,103.73 224.7,103.73 224.53,103.56 224.53,102.3 224.39,102.16 222.23,102.16 222.21,102.19 222.21,102.95 222.11,103.05 221.09,103.05 220.96,103.18 220.96,104.2 221.09,104.32 221.72,104.32 222,104.6 222,105.65 222.1,105.74 222.11,105.78 222.18,105.85 224.47,105.85 224.68,106.06 225.66,106.06
TYPEC_VBUS on IN2 (solid shape): outline of 366 points within 220.47,95.26 228.76,105.59
TYPEC_VBUS_C on TOP (solid shape): outline of 184 points within 224.9,102.16 233.08,110.28
TYPEC_VBUS_C on IN1 (solid shape): outline of 1179 points within 224.67,103 234.67,117.87
VADPBL on TOP (solid shape): 218.67,103.38 219.14,103.38 219.26,103.26 219.26,99.27 219.11,99.12 219.11,98.74 219.03,98.66 216.56,98.66 216.53,98.68 215.15,98.68 215.1,98.74 213.95,98.74 213.62,98.4 213.62,95.76 213.44,95.59 211.18,95.59 210.96,95.81 210.96,98.66 209.19,100.42 209.19,100.93 211.31,103.05 214.33,103.05 214.66,103.38 218.66,103.38
N25319276 on TOP (solid shape): 215.4,104.91 215.4,104.3 215.27,104.17 214.56,104.17 214.28,104.45 213.52,104.45 213.32,104.65 213.32,105.52 213.43,105.64 214.67,105.64
N25580644 on BOTTOM (solid shape): 179.28,16.1 179.28,15.25 179.17,15.14 178.28,15.14 178.13,15.3 178.13,16.1 178.27,16.24 179.14,16.24
N25580644 on BOTTOM (solid shape): 184.16,15.65 184.16,14.66 183.21,13.71 181.43,13.71 181.39,13.73 181.38,13.76 181.38,14.04 181.36,14.18 181.29,14.3 181.29,15.02 181.47,15.19 181.86,15.19 182.63,15.19 183.37,15.93 183.88,15.93
N25580644 on IN1 (solid shape): 184.12,15.68 184.12,15.3 183.87,15.05 180.14,15.05 180.13,15.05 178.34,15.05 178.15,15.25 178.15,16.03 178.33,16.21 183.59,16.21
N27239997 on BOTTOM (solid shape): 146.95,23.45 146.95,22.84 146.66,22.55 146.66,22.18 146.6,22.13 146.16,22.13 145.91,22.38 145.91,23.4 146.03,23.53 146.87,23.53
N27265621 on TOP (solid shape): 173.24,35.16 173.24,34.32 172.78,33.86 172.78,33.18 172.65,33.05 171.33,33.05 171.1,33.28 170.29,33.28 170.06,33.05 170.06,32.8 169.86,32.59 169.64,32.59 169.6,32.61 169.59,32.64 169.59,33.41 169.39,33.41 169.39,32.64 169.37,32.61 169.34,32.59 169.27,32.59 169.2,32.67 169.2,33.76 169.63,34.19 172.18,34.19 172.31,34.32 172.31,35.15 172.47,35.31 173.08,35.31
N27265632 on TOP (solid shape): 167.08,36.07 167.17,36.03 167.18,35.94 167.19,35.7 167.34,35.52 167.36,35.5 167.37,35.48 167.37,34.63 167.64,34.36 167.64,34.07 167.67,33.96 167.77,33.86 167.78,33.84 167.78,32.72 167.67,32.62 167.64,32.62 167.6,32.63 167.59,32.67 167.59,33.41 167.39,33.41 167.39,32.67 167.37,32.63 167.34,32.62 165.9,32.62 165.67,32.39 165.67,32.25 165.47,32.05 165.01,32.05 164.97,32.01 164.93,32.01 164.8,32.14 164.8,32.54 164.81,32.55 164.81,33.04 165.13,33.37 165.13,33.7 165.59,34.15 165.59,35.92 165.74,36.07
N27265672 on TOP (solid shape): 183.83,30.46 185.07,30.46 185.2,30.59 185.2,30.71 185.25,30.76 185.78,30.76 185.92,30.62 186.51,30.62 186.52,30.61 186.56,30.61 186.6,30.6 186.61,30.56 186.61,29.8 186.81,29.8 186.81,30.56 186.83,30.6 186.87,30.61 186.96,30.61 187,30.6 187.01,30.56 187.01,29.8 187.05,29.8 187.09,29.78 187.1,29.75 187.1,29.61 186.49,29 186.49,28.83 186.47,28.8 186.45,28.8 186.34,28.73 186.3,28.6 186.3,28.56 185.81,28.07 183.27,28.07 182.26,29.08 182.26,30.9 182.56,31.2 183.09,31.2
