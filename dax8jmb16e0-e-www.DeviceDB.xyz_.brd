# Allegro board dax8jmb16e0-e-www.DeviceDB.xyz_.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQ7: length 78.4
  IN1 w0.127: v1(89.34,84.05) 88.93,84.46 88.54,84.46 87.17,83.09 86.37,83.09 82.48,79.2 82.48,68.29 76.68,62.49 76.68,62.34 77.22,61.79 77.22,61.58 77.07,61.43 76.86,61.43 76.4,61.89 76.19,61.89 76.05,61.74 76.05,61.53 76.5,61.07 76.5,60.86 76.36,60.71 76.14,60.71 75.67,61.19 75.46,61.19 75.31,61.04 75.31,60.83 75.79,60.35 75.79,60.14 75.64,59.99 75.43,59.99 74.94,60.48 74.73,60.48 74.58,60.33 74.58,60.12 75.07,59.63 75.07,59.42 74.92,59.27 74.71,59.27 74.21,59.77 74,59.77 73.85,59.62 73.85,59.41 74.36,58.91 74.36,58.69 74.2,58.53 73.98,58.53 73.46,59.06 73.25,59.06 73.1,58.91 73.1,58.7 73.54,58.26 73.54,57.87 59.84,44.18 54.82,44.18 53.88,43.24 53.88,42.74 v2(53.34,42.2)
  BOTTOM w0.079: v1(89.34,84.05) 89.82,84.54 90.53,84.54 90.71,84.72 92.72,84.72 92.78,84.78 93.54,84.78 93.94,85.19 U400.A28
  BOTTOM w0.102: v2(53.34,42.2) 54.1,42.96 JDIM2800.21
M_A_DQ8: length 63
  IN1 w0.127: v2(60.4,41.99) 60.94,42.54 60.94,43.3 83.88,66.23 83.88,77.64 87.55,81.31 88.43,81.31 88.85,81.73 v1(88.85,81.93)
  BOTTOM w0.079: 90.48,83.11 90.71,83.11 91.07,83.47 92.5,83.47 93.14,84.11 93.86,84.11 93.98,84.23 94.22,84.23 94.44,84.16 94.6,84.16 U400.B30
  BOTTOM w0.102: v1(88.85,81.93) 88.85,82.21 89.75,83.11 90.48,83.11 ; JDIM2800.49 61.1,44.09 61.15,44.04 61.15,42.75 v2(60.4,41.99)
M_A_DQ9: length 63.9
  IN1 w0.127: v1(87.67,81.97) 87.38,81.68 83.5,77.8 83.5,67.87 82.88,67.25 82.88,67.04 83.41,66.52 83.41,66.3 83.26,66.16 83.05,66.16 82.52,66.68 82.31,66.68 82.16,66.54 82.16,66.33 82.71,65.78 82.71,65.6 60.38,43.28 v2(60.38,43.26)
  BOTTOM w0.079: 90.1,83.5 90.36,83.5 90.51,83.65 92.42,83.65 93.05,84.28 93.79,84.28 93.91,84.39 94.24,84.39 94.47,84.32 94.67,84.32 94.75,84.24 95.57,84.24 95.84,83.97 U400.D30
  BOTTOM w0.102: v2(60.38,43.26) 60.31,43.26 60.1,43.46 JDIM2800.45 ; v1(87.67,81.97) 89.2,83.5 90.1,83.5
M_A_DQ10: length 63.5
  IN1 w0.127: v2(63.35,39.2) 65.28,41.13 66.37,41.13 67.39,42.15 67.39,45.49 76.25,54.34 76.43,54.34 76.72,54.04 76.93,54.04 77.08,54.19 77.08,54.4 76.81,54.68 76.81,54.89 76.96,55.04 77.17,55.04 77.44,54.76 77.65,54.76 77.8,54.91 77.8,55.12 77.53,55.4 77.53,55.61 77.68,55.75 77.89,55.75 78.16,55.48 78.39,55.48 78.55,55.64 78.55,55.87 78.26,56.16 78.26,56.34 78.44,56.52 78.62,56.52 78.89,56.25 79.19,56.25 91.91,68.97 91.91,76.07 91.96,76.12 v1(91.96,76.97)
  BOTTOM w0.097: 91.58,80.29 92.34,81.06 93.35,81.06 93.57,81.27 93.57,81.42 94.13,81.99 U400.B33
  BOTTOM w0.102: v1(91.96,76.97) 91.96,79.23 91.58,79.61 91.58,80.29 ; v2(63.35,39.2) JDIM2800.58
M_A_DQ11: length 63
  IN1 w0.127: v2(90.9,75.53) 90.9,75.1 91.1,74.9 91.1,69.24 84.27,62.41 83.98,62.41 83.77,62.62 83.56,62.62 83.41,62.47 83.41,62.26 83.62,62.05 83.62,61.87 83.44,61.69 83.26,61.69 83,61.96 82.79,61.96 82.64,61.81 82.64,61.6 82.9,61.33 82.9,61.15 82.72,60.97 82.54,60.97 82.32,61.2 82.11,61.2 81.96,61.05 81.96,60.84 82.19,60.61 82.19,60.43 82.01,60.25 81.83,60.25 81.59,60.48 81.31,60.48 64.09,43.27 64.09,43.27 v2(64.09,42.89)
  BOTTOM w0.079: U400.D32 96.05,83.34 96.02,83.44 95.98,83.5 95.89,83.58 95.4,83.72 95.29,83.72 94.99,83.58 94.86,83.53 94.71,83.53 94.54,83.59 94.35,83.58 94.16,83.51 93.85,83.52 93.74,83.53 93.73,83.53 93.66,83.5 93.05,83.25 92.84,83.1 92.7,82.97 92.44,82.97 92.24,82.91 91.93,82.74 91.48,82.43 91.27,82.25 91.19,82.14 91.16,82.05 91.08,81.74
  BOTTOM w0.102: JDIM2800.59 63.6,43.37 v2(64.09,42.89) ; 91.08,81.74 91,80.99 90.89,79.98 90.88,79.82 90.82,78.89 90.8,78.6 90.76,76.58 90.51,76.33 90.51,75.92 v2(90.9,75.53)
M_A_DQ12: length 62.5
  IN1 w0.127: v1(90.01,81.95) 90.01,81.25 89.03,80.26 89.03,70.85 61.37,43.19 61.37,40.92 60.87,40.42 60.87,38.9 v2(60.35,38.38)
  BOTTOM w0.079: U400.A30 93.95,83.97 93.93,83.95 93.21,83.95 92.56,83.3 91.36,83.3 90.9,82.84
  BOTTOM w0.102: 90.9,82.84 90.73,82.67 v2(90.21,82.67) 90.01,82.47 v1(90.01,81.95) ; v2(60.35,38.38) JDIM2800.46
M_A_DQ13: length 62.8
  IN1 w0.127: v2(61.35,39.2) 61.81,39.66 61.81,43.08 89.41,70.69 89.41,79.63 90.64,80.85 v1(90.64,81.9)
  BOTTOM w0.079: U400.C30 94.93,83.73 94.84,83.7 94.74,83.7 94.56,83.76 94.31,83.75 94.23,83.72 94.14,83.68 94.02,83.69 93.81,83.69 93.68,83.7 93.67,83.69 93.19,83.69 92.63,83.13 91.6,83.13 90.64,82.17 v1(90.64,81.9)
  BOTTOM w0.102: v2(61.35,39.2) JDIM2800.50
M_A_DQ14: length 62.2
  IN1 w0.127: v1(91.19,76.1) 91.48,75.82 91.48,69.09 81.49,59.09 81.31,59.09 81.15,59.25 80.94,59.25 80.79,59.1 80.79,58.89 80.95,58.73 80.95,58.55 80.77,58.37 80.59,58.37 80.4,58.57 80.19,58.57 80.04,58.42 80.04,58.21 80.23,58.02 80.23,57.84 80.05,57.66 79.87,57.66 79.59,57.94 79.31,57.94 78.27,56.91 66.33,44.96 66.33,42.14 65.8,41.62 v2(64.12,41.62)
  BOTTOM w0.079: U400.B32 94.44,82.32 94.19,82.32 93.39,81.53
  BOTTOM w0.097: 91.25,80.47 92.16,81.39 93.25,81.39 93.39,81.53
  BOTTOM w0.102: v1(91.19,76.1) 91.12,76.18 91.12,76.79 91.25,76.92 91.25,80.47 ; v2(64.12,41.62) 64.22,41.62 64.86,42.25 64.86,43.94 64.6,44.19 JDIM2800.63
M_A_DQ15: length 61.9
  IN1 w0.127: v1(92.41,77.32) 92.41,76.03 92.29,75.9 92.29,68.81 76.61,53.13 76.43,53.13 76.25,53.3 76.04,53.3 75.89,53.16 75.89,52.95 76.07,52.77 76.07,52.59 75.89,52.41 75.71,52.41 75.52,52.6 75.31,52.6 75.16,52.45 75.16,52.25 75.35,52.06 75.35,51.87 68.08,44.61 68.08,42.3 66.53,40.75 65.44,40.75 64.83,40.14 64.83,38.87 v2(64.35,38.39)
  BOTTOM w0.079: U400.C32 95.28,82.67 94.81,82.2 94.81,81.95 94.47,81.61 94.02,81.61 93.85,81.45 93.85,81.23 93.35,80.73 93.18,80.73
  BOTTOM w0.097: 93.18,80.73 92.46,80.73 91.93,80.19
  BOTTOM w0.102: v1(92.41,77.32) 92.41,79.3 91.93,79.79 91.93,80.19 ; v2(64.35,38.39) JDIM2800.62
M_A_DQ16: length 75
  IN2 w0.127: v1(99.24,88.36) 97.87,89.72 95.56,89.72 93.31,87.46 89.9,87.46 89.04,86.59 83.9,86.59 77.55,80.25 77.55,59.16 70.24,51.84 70.24,51.51 70.99,50.76 70.99,50.55 70.84,50.4 70.63,50.4 69.88,51.15 69.7,51.15 69.52,50.97 69.52,50.79 70.27,50.04 70.27,49.83 65.41,44.98 65.41,43.36 v2(65.84,42.93)
  BOTTOM w0.079: v1(99.24,88.36) 99.05,88.54 98.97,88.54 U400.J22
  BOTTOM w0.102: JDIM2800.67 65.6,44.1 65.43,43.92 65.43,43.34 v2(65.84,42.93)
M_A_DQ17: length 77.9
  IN2 w0.127: v1(98.35,86.4) 97.83,85.87 97.12,85.87 96.82,85.57 95.83,85.57 95.11,84.84 95.11,84.43 93.56,82.89 90.79,82.89 90.71,82.81 87.38,82.81 87.07,82.5 84.61,82.5 80.96,78.86 80.96,54.44 80.69,54.17 80.51,54.17 80.11,54.58 79.9,54.58 79.75,54.43 79.75,54.22 80.31,53.66 80.31,53.45 80.16,53.31 79.95,53.31 79.37,53.88 79.16,53.88 79.01,53.73 79.01,53.52 79.61,52.92 79.61,52.71 79.46,52.56 79.25,52.56 78.68,53.14 78.46,53.14 78.32,52.99 78.32,52.78 78.87,52.23 78.87,52.02 78.72,51.87 78.51,51.87 77.94,52.43 77.73,52.43 77.58,52.28 77.58,52.07 78.14,51.52 78.14,51.31 77.99,51.16 77.78,51.16 77.19,51.75 76.98,51.75 76.83,51.6 76.83,51.39 77.45,50.77 77.45,50.07 72.16,44.79 71.58,44.79 71.04,44.25 70.37,44.25 69.83,43.72 69.83,40.77 69.32,40.26 69.32,38.99 v2(68.87,38.54)
  BOTTOM w0.079: v1(98.35,86.4) 98.18,86.57 98.18,86.65 U400.H25
  BOTTOM w0.102: JDIM2800.80 68.85,38.52 v2(68.87,38.54)
M_A_DQ18: length 74.4
  IN2 w0.127: v2(66.81,43.79) 66.81,45.3 72.22,50.71 72.22,50.71 72.37,50.86 72.37,51.07 71.77,51.67 71.77,51.88 71.92,52.03 72.13,52.03 72.73,51.43 72.94,51.43 73.09,51.58 73.09,51.79 72.33,52.55 72.33,52.76 72.48,52.91 72.69,52.91 73.45,52.15 73.66,52.15 73.81,52.3 73.81,52.51 73.05,53.27 73.05,53.48 73.2,53.63 73.41,53.63 74.17,52.87 74.38,52.87 74.53,53.02 74.53,53.23 73.85,53.91 73.85,54.09 78.32,58.55 78.32,79.93 84.21,85.83 89.31,85.83 89.57,86.09 92.16,86.09 92.34,86.27 93.16,86.27 95.94,89.05 97.32,89.05 v1(98.04,88.33)
  BOTTOM w0.079: U400.G22 97.56,88.66 97.71,88.66 v1(98.04,88.33)
  BOTTOM w0.102: JDIM2800.71 66.6,44.28 66.81,44.08 v2(66.81,43.79)
M_A_DQ19: length 74
  IN2 w0.127: v1(98.62,88.36) 97.58,89.39 95.76,89.39 93.47,87.11 90.06,87.11 89.16,86.21 84.06,86.21 77.93,80.09 77.93,58.91 71.39,52.37 71.39,50.42 66.33,45.35 66.33,41.92 65.82,41.41 65.82,39.69 v2(65.35,39.23)
  BOTTOM w0.079: v1(98.62,88.36) 98.3,88.68 98.19,88.68 U400.H22
  BOTTOM w0.102: v2(65.35,39.23) JDIM2800.66
M_A_DQ20: length 77.9
  IN2 w0.127: v2(68.71,42.3) 68.81,42.21 68.81,41.01 69,40.82 69.26,40.82 69.45,41.01 69.45,43.88 70.28,44.71 70.96,44.71 71.46,45.21 72.05,45.21 73.95,47.11 73.95,47.73 73.27,48.4 73.27,48.58 73.45,48.76 73.63,48.76 74.28,48.12 74.49,48.12 74.64,48.27 74.64,48.48 73.99,49.12 73.99,49.3 74.17,49.48 74.35,49.48 74.98,48.85 75.19,48.85 75.34,49 75.34,49.21 74.71,49.84 74.71,50.02 74.89,50.2 75.07,50.2 75.69,49.58 75.9,49.58 76.05,49.73 76.05,49.94 75.43,50.56 75.43,50.74 75.61,50.92 75.79,50.92 76.47,50.24 76.68,50.24 76.83,50.39 76.83,50.6 76.15,51.28 76.15,51.46 80.58,55.88 80.58,79.01 84.45,82.89 86.83,82.89 87.13,83.19 90.49,83.19 90.56,83.26 93.37,83.26 94.72,84.61 94.72,84.94 95.69,85.91 96.03,85.91 96.69,85.91 v1(97.14,86.36)
  BOTTOM w0.079: v1(97.14,86.36) 96.92,86.59 96.92,86.61 U400.F25
  BOTTOM w0.102: v2(68.71,42.3) 69.6,43.19 JDIM2800.83
M_A_DQ21: length 76.2
  IN2 w0.127: v1(98.99,86.39) 98.91,86.39 98.05,85.53 97.26,85.53 96.96,85.22 95.92,85.22 95.46,84.77 95.46,84.26 93.79,82.58 91.12,82.58 90.97,82.43 87.54,82.43 87.23,82.12 84.76,82.12 81.34,78.7 81.34,53.42 80.54,52.63 80.54,52.45 81.16,51.83 81.16,51.62 81.01,51.47 80.8,51.47 80.19,52.09 80.01,52.09 79.83,51.91 79.83,51.73 80.43,51.12 80.43,50.91 80.28,50.76 80.07,50.76 79.47,51.37 79.29,51.37 79.11,51.19 79.11,51.01 79.74,50.38 79.74,50.17 79.59,50.02 79.38,50.02 78.75,50.65 78.57,50.65 78.39,50.47 78.39,50.29 78.97,49.71 78.97,49.5 78.82,49.35 78.61,49.35 78.03,49.93 77.85,49.93 72.12,44.2 71.53,44.2 70.95,43.62 70.95,40.45 v2(69.85,39.36)
  BOTTOM w0.079: U400.J25 98.83,86.65 98.83,86.55 v1(98.99,86.39)
  BOTTOM w0.102: v2(69.85,39.36) JDIM2800.84
M_A_DQ22: length 74.8
  IN2 w0.127: v1(97.74,86.39) 97.74,86.55 97.48,86.81 96.01,86.81 94.34,85.15 94.34,84.81 93.16,83.63 90.48,83.63 90.43,83.57 86.7,83.57 86.39,83.27 84.29,83.27 80.19,79.17 80.19,56.04 72.69,48.54 72.69,48.36 73.57,47.48 73.57,47.27 73.42,47.12 73.21,47.12 72.33,48 72.15,48 71.97,47.82 71.97,47.64 72.85,46.76 72.85,46.55 72.7,46.4 72.49,46.4 71.63,47.26 71.42,47.26 71.27,47.11 71.27,46.9 72.07,46.1 72.07,45.89 71.92,45.74 71.71,45.74 70.91,46.54 70.7,46.54 70.55,46.39 70.55,46.18 71.12,45.61 71.12,45.4 70.97,45.26 70.76,45.26 70.19,45.83 69.98,45.83 69.83,45.68 69.83,45.46 70.06,45.23 70.06,45.03 69.93,44.89 69.73,44.89 69.48,45.14 69.29,45.14 69.16,45.01 69.16,44.82 69.4,44.58 69.4,44.46 69.2,44.25 68.91,44.25 68.7,44.04 v2(68.7,43.62)
  BOTTOM w0.079: v1(97.74,86.39) 97.54,86.59 97.54,86.64 U400.G25
  BOTTOM w0.102: JDIM2800.79 68.6,44.29 68.7,44.2 v2(68.7,43.62)
M_A_DQ23: length 74.1
  IN2 w0.127: v1(97.45,88.31) 97.45,88.41 97.09,88.78 96.18,88.78 93.33,85.92 92.49,85.92 92.31,85.74 89.71,85.74 89.41,85.44 84.37,85.44 78.7,79.78 78.7,58.39 75.25,54.94 75.25,54.73 75.9,54.08 75.9,53.85 75.74,53.69 75.51,53.69 74.86,54.34 74.65,54.34 74.5,54.2 74.5,53.99 75.09,53.4 75.09,53.04 67.29,45.24 67.29,42.09 66.35,41.15 v2(66.35,38.42)
  BOTTOM w0.079: U400.F22 96.93,88.83 v1(97.45,88.31)
  BOTTOM w0.102: v2(66.35,38.42) JDIM2800.70
M_A_DQ24: length 81
  IN2 w0.127: v1(91.22,89.95) 90.88,90.29 88.86,90.29 88.76,90.4 82.75,90.4 74.28,81.92 74.28,62.26 67.72,55.7 67.72,55.54 68.16,55.1 68.16,54.89 68.01,54.74 67.8,54.74 67.36,55.19 67.18,55.19 67,55.01 67,54.83 67.44,54.38 67.44,54.17 67.3,54.02 67.08,54.02 66.64,54.47 66.46,54.47 66.28,54.29 66.28,54.11 66.73,53.66 66.73,53.45 66.58,53.3 66.37,53.3 65.92,53.75 65.74,53.75 65.56,53.57 65.56,53.39 66.01,52.95 66.01,52.71 65.5,52.2 65.48,52.2 59.45,46.16 58.03,46.16 56.02,44.14 56.02,42.83 v2(56.1,42.74)
  BOTTOM w0.079: v1(91.22,89.95) 92.36,88.81 93.77,88.81 93.83,88.75 94.24,88.75 94.37,88.78 94.62,88.78 94.69,88.75 94.9,88.75 94.96,88.78 95.19,88.78 95.35,88.75 95.52,88.75 95.67,88.8 95.88,88.8 U400.D22
  BOTTOM w0.102: JDIM2800.29 v2(56.1,42.74)
M_A_DQ25: length 80.4
  IN2 w0.127: v2(54.85,38.41) 54.39,38.87 54.39,44.14 72.91,62.65 72.91,82.17 82.28,91.54 88.94,91.54 89.37,91.12 91.83,91.12 92.39,90.56 93.05,90.56 v2(93.89,89.72)
  BOTTOM w0.079: v2(93.89,89.72) 94.12,89.49 94.19,89.49 94.47,89.33 95.11,89.33 U400.C22
  BOTTOM w0.102: v2(54.85,38.41) JDIM2800.24
M_A_DQ26: length 80.5
  IN2 w0.127: v2(88.71,88.55) 88.38,88.87 83.66,88.87 75.78,80.99 75.78,60.38 75.5,60.1 75.32,60.1 74.96,60.47 74.75,60.47 74.6,60.32 74.6,60.11 74.96,59.74 74.96,59.56 74.78,59.39 74.6,59.39 74.26,59.72 74.05,59.72 73.9,59.57 73.9,59.36 74.24,59.03 74.24,58.85 74.06,58.67 73.88,58.67 73.49,59.06 73.28,59.06 73.13,58.91 73.13,58.7 73.52,58.31 73.52,58.13 73.34,57.95 73.16,57.95 72.79,58.32 72.58,58.32 72.43,58.18 72.43,57.96 72.79,57.6 72.79,57.39 72.64,57.24 72.43,57.24 72.08,57.59 71.87,57.59 71.72,57.44 71.72,57.23 72,56.96 72,56.6 59.75,44.35 58.58,44.35 58,43.77 58,42.91 v2(57.34,42.25)
  BOTTOM w0.079: U400.C24 95.18,87.45 94.65,87.45 94.55,87.35 94.43,87.35 93.88,87.11
  BOTTOM w0.097: 89.94,87.32 90.15,87.11 93.88,87.11
  BOTTOM w0.102: v2(57.34,42.25) 58.15,43.06 58.15,44.02 58.1,44.07 JDIM2800.37 ; 89.94,87.32 v2(88.71,88.55)
M_A_DQ27: length 80.7
  IN2 w0.127: v2(59.29,39.2) 59.58,39.2 59.9,39.53 59.9,40.62 61.1,41.81 61.1,42.58 62.52,44 63.43,44 67.71,48.28 67.71,48.65 66.96,49.4 66.96,49.61 67.11,49.76 67.32,49.76 68.2,48.88 68.41,48.88 68.56,49.02 68.56,49.24 67.82,49.98 67.82,50.19 67.97,50.34 68.18,50.34 68.92,49.59 69.13,49.59 69.28,49.74 69.28,49.95 68.57,50.66 68.57,51.14 76.92,59.49 76.92,80.51 83.63,87.23 89.1,87.23 89.67,87.8 90.52,87.8 v1(91.22,88.5)
  BOTTOM w0.079: U400.D24 96.08,88.43 95.88,88.63 95.7,88.63 95.54,88.58 95.34,88.58 95.14,88.61 95,88.61 94.94,88.58 94.66,88.58 94.59,88.61 94.39,88.61 94.26,88.58 93.76,88.58 93.7,88.64 92.27,88.64 91.98,88.93 91.65,88.93 v1(91.22,88.5)
  BOTTOM w0.102: v2(59.29,39.2) 59.29,38.11 59.35,38.04 JDIM2800.42
M_A_DQ28: length 79.4
  IN2 w0.127: v2(55.85,39.2) 55.41,39.65 55.41,41.84 55.61,42.04 55.61,44.28 58.02,46.69 59.32,46.69 63.94,51.31 63.94,51.62 63.77,51.8 63.77,52.01 63.92,52.15 64.13,52.15 64.34,51.95 64.55,51.95 64.7,52.1 64.7,52.31 64.33,52.67 64.33,53 73.9,62.56 73.9,82.08 82.6,90.78 88.81,90.78 89.06,90.53 91.32,90.53 v1(91.88,89.97)
  BOTTOM w0.097: U400.A22 92.8,89 91.88,89.92 v1(91.88,89.97)
  BOTTOM w0.102: v2(55.85,39.2) JDIM2800.28
M_A_DQ29: length 79.7
  IN2 w0.127: v1(93.25,89.72) 92.64,90.33 92.13,90.33 91.65,90.81 89.24,90.81 88.89,91.16 82.44,91.16 73.51,82.24 73.51,62.72 62.54,51.75 62.54,51.31 62.83,51.02 62.83,50.81 62.68,50.66 62.47,50.66 62.2,50.94 61.99,50.94 61.84,50.79 61.84,50.58 62.11,50.3 62.11,50.09 61.96,49.94 61.75,49.94 61.4,50.29 61.19,50.29 61.04,50.14 61.04,49.93 61.38,49.6 61.38,49.39 61.23,49.24 61.02,49.24 60.7,49.56 60.49,49.56 60.34,49.41 60.34,49.2 60.69,48.85 60.69,48.64 60.54,48.49 60.33,48.49 59.94,48.88 59.73,48.88 59.58,48.73 59.58,48.52 59.92,48.19 59.92,47.98 59.77,47.83 59.56,47.83 59.18,48.21 59,48.21 55.09,44.29 v2(55.09,43.6)
  BOTTOM w0.079: U400.B22 94.62,89.17 94.43,89.17 94.26,89.26 93.71,89.26 v1(93.25,89.72)
  BOTTOM w0.102: v2(55.09,43.6) 55.09,43.96 55.1,43.98 JDIM2800.25
M_A_DQ30: length 79.6
  IN2 w0.127: v2(58.94,42.78) 59.48,43.32 59.83,43.32 60.59,44.07 62.05,44.07 62.36,44.38 62.87,44.38 64.68,46.19 64.68,46.44 63.98,47.13 63.98,47.34 64.13,47.49 64.34,47.49 65.26,46.58 65.47,46.58 65.62,46.73 65.62,46.94 64.69,47.87 64.69,48.08 64.84,48.23 65.05,48.23 65.98,47.3 66.19,47.3 66.34,47.44 66.34,47.65 65.46,48.53 65.46,48.74 65.61,48.89 65.82,48.89 66.7,48.01 66.91,48.01 67.06,48.16 67.06,48.37 66.06,49.37 66.06,49.55 76.54,60.03 76.54,80.67 83.48,87.61 88.96,87.61 89.52,88.17 90.28,88.17 v1(90.61,88.5)
  BOTTOM w0.097: v1(90.61,88.5) 91.6,87.51 93.81,87.51 94.01,87.7 U400.A24
  BOTTOM w0.102: v2(58.94,42.78) 59.29,43.13 59.29,44.06 59.1,44.25 JDIM2800.41
M_A_DQ31: length 80.9
  IN2 w0.127: v1(89.37,88.55) 88.81,87.99 83.32,87.99 76.16,80.83 76.16,60.2 63.19,47.24 63.19,47.06 63.98,46.28 63.98,46.07 63.83,45.92 63.62,45.92 62.95,46.58 62.74,46.58 62.59,46.44 62.59,46.22 63.25,45.57 63.25,45.36 63.1,45.21 62.89,45.21 62.2,45.9 61.98,45.9 61.84,45.75 61.84,45.54 62.31,45.07 62.31,44.87 62.05,44.61 60.56,44.61 59.9,43.95 58.71,43.95 58.38,43.61 58.38,41.43 v2(59.29,40.51)
  BOTTOM w0.079: 92.95,87.31 93.89,87.31 93.96,87.38 94.07,87.38 94.39,87.52 94.58,87.7 U400.B24
  BOTTOM w0.097: 92.95,87.31 90.61,87.31 90.45,87.47
  BOTTOM w0.102: JDIM2800.38 58.35,38.03 58.14,38.24 58.14,39.36 v2(59.29,40.51) ; 90.45,87.47 v1(89.37,88.55)
M_A_DQ32: length 54.2
  IN2 w0.127: v1(95.48,76.64) 94.85,76.64 94.45,76.23 93.45,76.23 92.44,75.21 92.44,74.83 89.48,71.87 89.48,71.24 89.35,71.11 88.97,71.11 88.84,70.99 88.84,70.73 88.97,70.61 89.35,70.61 89.48,70.48 89.48,70.22 89.35,70.1 88.97,70.1 88.84,69.97 88.84,69.72 88.97,69.59 89.35,69.59 89.48,69.46 89.48,69.21 89.35,69.08 88.97,69.08 88.84,68.95 88.84,68.7 88.97,68.57 89.35,68.57 89.48,68.45 89.48,68.19 89.35,68.07 88.97,68.07 88.84,67.94 88.84,67.68 88.97,67.56 89.35,67.56 89.48,67.43 89.48,67.18 89.35,67.05 88.97,67.05 88.84,66.92 88.84,66.67 88.97,66.54 89.35,66.54 89.48,66.41 89.48,50.74 95,45.21 97.53,45.21 99.7,43.03 v2(99.73,43.03)
  BOTTOM w0.079: v1(95.48,76.64) 96,76.64 98.09,78.73 98.09,79.49 U400.H37
  BOTTOM w0.102: JDIM2800.195 99.6,44.25 99.62,44.23 99.62,43.61 99.65,43.58 99.65,43.11 v2(99.73,43.03)
M_A_DQ33: length 56
  IN2 w0.127: v1(96.86,78.59) 96.29,78.46 95.82,78.28 95.65,78.17 95.14,77.98 94.56,77.79 93.99,77.22 92.89,77.22 91.42,75.75 91.42,75.44 87.7,71.71 87.7,66.19 88.34,65.56 88.34,50.26 94.53,44.07 97.05,44.07 98.48,42.63 98.48,41.89 98.44,41.85 v2(98.44,41.36)
  BOTTOM w0.079: v1(96.86,78.59) 96.86,79.02 97.14,79.3 97.21,79.3 97.37,79.46 97.37,79.74 97.28,79.84 97.28,80.79 97.67,81.18 97.84,81.18 U400.H34
  BOTTOM w0.102: v2(98.44,41.36) 98.6,41.52 JDIM2800.191
M_A_DQ34: length 58.2
  IN2 w0.127: v2(101.3,42.17) 101.3,43.56 96.49,48.37 94.15,48.37 90.97,51.55 90.97,69.83 91.09,69.96 91.42,69.96 91.59,70.12 91.59,70.3 91.45,70.44 90.86,70.44 90.74,70.57 90.74,70.75 90.86,70.87 91.52,70.87 91.65,71 91.65,71.23 91.52,71.35 91.15,71.35 91.02,71.48 91.02,71.66 91.17,71.81 91.88,71.81 92.01,71.94 92.01,72.09 91.83,72.27 91.83,72.41 v1(92.78,73.37)
  BOTTOM w0.079: U400.K34 99.48,81.32 99.11,80.94 99.11,79.86 99.06,79.73 99.06,79.36 99.15,79.27 99.15,78.82 98.94,78.61 98.69,78.61 96.96,76.88 96.96,76.66 96.76,76.46
  BOTTOM w0.102: JDIM2800.203 101.6,42.66 102.27,41.99 102.27,41.79 102.1,41.62 101.85,41.62 v2(101.3,42.17) ; v1(92.78,73.37) 92.48,73.37 92.34,73.51 92.34,73.74 92.52,73.92 93.89,73.92 94.63,74.66 94.95,74.66 96.76,76.46
M_A_DQ35: length 57.3
  IN2 w0.127: v1(92.82,71.05) 92.82,69.83 92.11,69.12 92.11,54.37 102.83,43.65 102.83,42.09 102.7,41.97 102.42,41.97 102.3,41.84 102.3,41.43 102.42,41.31 103.39,41.31 103.54,41.15 103.54,40.98 103.41,40.85 102.4,40.85 102.25,40.7 102.25,40.52 102.42,40.34 103.39,40.34 103.51,40.21 103.51,39.65 103.23,39.38 102.62,39.38 102.39,39.6 v2(102.39,39.81)
  BOTTOM w0.079: 97.4,75.77 97.56,75.95 97.88,76.48 98.13,77.13 98.21,77.3 98.54,77.75 98.9,78.11 99.15,78.11 99.65,78.61 99.65,79.05 99.74,79.43 99.74,80.37 U400.K35
  BOTTOM w0.102: v1(92.82,71.05) 94.62,72.85 95,73.22 95.44,73.67 95.46,73.67 95.57,73.78 97.15,75.48 97.4,75.77 ; v2(102.39,39.81) 102.7,39.81 102.98,39.53 102.98,38.41 102.85,38.28 JDIM2800.208
M_A_DQ36: length 55
  IN2 w0.127: v1(95.84,77.12) 94.98,77.12 94.42,76.56 93.23,76.56 92.08,75.42 92.08,75.02 88.46,71.4 88.46,66.51 89.1,65.88 89.1,50.58 94.85,44.83 97.37,44.83 99.26,42.94 99.26,39.54 v2(99.75,39.05)
  BOTTOM w0.079: U400.H36 98,80.04 98,79.88 97.92,79.67 97.92,78.8 96.24,77.12 v1(95.84,77.12)
  BOTTOM w0.102: v2(99.75,39.05) 99.35,38.65 JDIM2800.194
M_A_DQ37: length 55.8
  IN2 w0.127: v1(96.58,78.06) 96.05,78.06 95.64,77.65 95.06,77.65 94.27,76.87 93.03,76.87 91.75,75.58 91.75,75.23 88.08,71.56 88.08,66.35 88.72,65.72 88.72,50.42 94.69,44.45 97.21,44.45 98.88,42.78 98.88,39.7 v2(98.38,39.2)
  BOTTOM w0.079: v1(96.58,78.06) 96.95,78.06 97.76,78.87 97.76,79.7 97.83,79.91 97.83,80.52 U400.H35
  BOTTOM w0.102: JDIM2800.190 98.35,38.16 98.38,38.18 v2(98.38,39.2)
M_A_DQ38: length 56.6
  IN2 w0.127: v1(92.78,72.79) 92.32,72.33 92.32,71.72 92.06,71.46 92.06,70.06 91.35,69.35 91.35,53.78 91.48,53.65 91.75,53.65 91.88,53.52 91.88,53.22 91.41,52.75 91.41,52.57 91.55,52.43 91.78,52.43 92.28,52.94 92.46,52.94 92.66,52.73 92.66,52.55 91.89,51.78 91.89,51.6 94.74,48.75 96.65,48.75 101.84,43.56 101.84,39.12 101.96,38.99 102.6,38.99 102.78,38.82 102.78,38.59 102.65,38.46 v2(102.06,38.46)
  BOTTOM w0.079: 96.96,76.23 97.26,76.53 97.26,76.95 98.76,78.44 99.01,78.44 99.31,78.75 99.31,79.34 99.23,79.43 99.23,79.7 99.28,79.83 99.28,80.02 U400.K36
  BOTTOM w0.102: 96.96,76.23 93.53,72.79 v1(92.78,72.79) ; v2(102.06,38.46) 101.85,38.25 JDIM2800.204
M_A_DQ39: length 55.8
  IN2 w0.127: v2(102.38,43.17) 102.38,43.56 96.81,49.13 96.15,49.13 96.02,49.26 96.02,49.44 96.15,49.56 96.15,49.74 95.99,49.89 95.81,49.89 95.08,49.15 94.9,49.15 94.75,49.3 94.75,49.55 95.48,50.28 95.48,50.46 95.3,50.64 95.12,50.64 94.41,49.92 94.23,49.92 94.05,50.1 94.05,50.28 94.76,51 94.76,51.18 94.56,51.38 94.38,51.38 93.61,50.6 93.43,50.6 93.23,50.8 93.23,50.98 94,51.76 94,51.94 93.77,52.16 93.59,52.16 92.97,51.54 92.79,51.54 92.62,51.72 92.62,51.92 93.23,52.53 93.23,52.71 91.73,54.21 91.73,69.25 92.39,69.91 92.39,71.25 v1(92.77,71.63)
  BOTTOM w0.079: 97.18,75.93 97.47,76.21 97.47,76.92 98.83,78.28 99.08,78.28 99.48,78.68 U400.K37
  BOTTOM w0.102: v2(102.38,43.17) 102.38,43.96 102.6,44.18 JDIM2800.207 ; v1(92.77,71.63) 92.89,71.63 97.18,75.93
M_A_DQ40: length 52.3
  IN2 w0.127: v2(103.35,43.32) 103.35,44.02 92.74,54.63 92.74,69.17 93.45,69.88 93.45,73.51 94.32,74.38 94.32,74.76 94.56,75 94.94,75 95.33,75.39 95.33,75.7 95.58,75.94 95.88,75.94 96.23,76.29 96.23,76.47 96.14,76.55 96.14,76.73 96.32,76.91 96.5,76.91 96.59,76.83 96.77,76.83 97.04,77.09 97.04,78.08 97.24,78.29 97.42,78.29 97.52,78.18 97.52,77.68 97.65,77.54 97.88,77.54 98,77.67 98,78.62 98.16,78.77 98.38,78.77 98.51,78.64 98.51,77.67 98.78,77.41 98.96,77.41 v1(99.09,77.54)
  BOTTOM w0.079: U400.N36 100.51,80.04 100.51,79.88 100.44,79.67 100.44,79.4 100.52,79.32 100.52,79.23 100.53,79.22 100.53,78.78 99.29,77.54 v1(99.09,77.54)
  BOTTOM w0.102: JDIM2800.211 103.6,43.57 v2(103.35,43.32)
M_A_DQ41: length 52.6
  IN2 w0.127: v1(99.04,76.17) 98.56,75.95 97.59,75.75 96.72,75.25 94.29,72.83 94.29,69.22 93.89,68.82 93.89,55.1 104.56,44.43 104.56,41.91 v2(104.69,38.37)
  BOTTOM w0.079: U400.N34 100.9,81.11 100.95,80.98 100.95,80.77 100.92,80.69 100.92,80.41 100.95,80.32 100.95,80.15 100.93,80.07 100.91,80.01 100.91,79.82 100.95,79.7 100.95,79.35 100.87,79.27 100.87,78.64 99.68,77.46 99.68,76.81 99.6,76.68 99.39,76.44 v1(99.04,76.17)
  BOTTOM w0.102: v2(104.69,38.37) 104.85,38 JDIM2800.216
M_A_DQ42: length 53.1
  IN2 w0.127: v1(97.72,73.85) 97.72,73.16 97.6,73.03 97.32,73.03 97.06,73.29 96.61,73.29 95.77,72.45 95.77,55.87 106.89,44.74 106.89,40.62 107.02,40.49 107.6,40.49 107.76,40.34 107.76,39.93 107.63,39.81 v2(107.06,39.81)
  BOTTOM w0.079: 100.29,75.37 100.29,75.67 100.49,75.88 100.49,76.99 102.09,78.59 102.09,79.49 U400.R37
  BOTTOM w0.097: v1(97.72,73.85) 98.97,73.85 100.29,75.16 100.29,75.37
  BOTTOM w0.102: JDIM2800.228 107.85,39.01 v2(107.06,39.81)
M_A_DQ43: length 53.4
  IN2 w0.127: v2(107.05,38.47) 106.74,38.79 106.69,38.86 106.6,39.16 106.51,39.8 106.51,42.91 106.23,44.2 106.05,45.04 95.39,55.71 95.39,72.45 96.38,73.44 v1(96.93,73.84)
  BOTTOM w0.079: U400.R34 101.22,81.52 101.07,81.37 101.07,81.14 101.12,81.01 101.12,80.72 101.08,80.64 101.08,80.45 101.12,80.36 101.12,80.12 101.09,80.03 101.09,79.81 101.12,79.73 101.12,79.28 101.03,79.2 101.03,78.5 99.93,77.4 99.93,76.44 99.75,76.26
  BOTTOM w0.102: v2(107.05,38.47) 106.85,38.28 JDIM2800.224 ; 99.75,76.26 99.3,75.8 97.82,75.8 97.52,75.49 97.52,75.16 96.93,74.58 v1(96.93,73.84)
M_A_DQ44: length 52.3
  IN2 w0.127: v1(98.46,76.36) 97.29,76.36 94.06,73.13 94.06,69.53 93.51,68.97 93.51,54.94 104.18,44.27 104.18,38.75 104.05,38.61 103.84,38.61 v2(103.46,38.99)
  BOTTOM w0.079: v1(98.46,76.36) 98.64,76.54 99.2,76.54 99.45,76.79 99.45,77.46 100.7,78.71 100.7,79.29 100.69,79.3 100.69,79.56 U400.N37
  BOTTOM w0.102: v2(103.46,38.99) 103.85,38.6 JDIM2800.212
M_A_DQ45: length 52.2
  IN2 w0.127: v1(98.48,77.04) 97.46,77.04 93.68,73.26 93.68,69.68 93.12,69.12 93.12,54.79 103.8,44.11 103.8,42.27 v2(103.47,41.94)
  BOTTOM w0.079: U400.N35 100.7,80.63 100.34,80.28 100.34,79.91 100.27,79.7 100.27,79.33 100.35,79.25 100.35,79.16 100.36,79.15 100.36,78.85 99.45,77.94 98.97,77.94 98.71,77.69 98.71,77.27 v1(98.48,77.04)
  BOTTOM w0.102: v2(103.47,41.94) 104.5,41.94 104.6,42.04 104.6,42.25 104.33,42.52 104.33,42.93 104.6,43.21 JDIM2800.215
M_A_DQ46: length 54.4
  IN2 w0.127: v2(107.7,41.83) 107.27,42.26 107.27,44.9 96.15,56.02 96.15,72.27 96.73,72.85 96.91,72.85 96.99,72.78 v1(96.99,72.42)
  BOTTOM w0.079: U400.R36 102,80.06 102.18,79.87 102.25,79.65 102.25,78.45 100.72,76.92 100.72,75.67 100.54,75.49 100.54,75.37
  BOTTOM w0.097: 99.42,73.77 100.54,74.88 100.54,75.37
  BOTTOM w0.102: v2(107.7,41.83) 107.26,41.38 106.99,41.38 106.82,41.55 106.82,41.7 107.27,42.15 107.27,44.1 107.1,44.27 JDIM2800.225 ; 99.42,73.77 99.42,73.54 98.56,72.67 98.18,72.67 97.8,73.06 97.6,73.06 97.46,72.92 97.46,72.78 97.94,72.3 97.94,72.16 97.75,71.96 97.59,71.96 97.14,72.42 v1(96.99,72.42)
M_A_DQ47: length 53.3
  IN2 w0.127: v2(107.78,42.51) 108.09,42.51 108.21,42.64 108.21,43.46 108.09,43.59 107.79,43.59 107.66,43.72 107.66,44.05 107.79,44.18 108.09,44.18 108.21,44.3 108.21,44.5 96.53,56.18 96.53,71.51 96.64,71.62 96.82,71.62 96.97,71.47 v1(96.97,71.24)
  BOTTOM w0.079: U400.R35 102.23,80.64 102.23,80.51 102.34,80.39 102.34,80.11 102.35,80.11 102.35,79.9 102.42,79.68 102.42,78.31 100.92,76.81 100.92,75.34
  BOTTOM w0.102: 100.92,75.34 100.92,74.45 97.71,71.24 v1(96.97,71.24) ; JDIM2800.229 108.1,44.06 108.16,44 108.35,44 108.52,43.83 108.52,43.59 108.21,43.29 108.21,42.93 108.31,42.83 108.62,42.83 108.72,42.73 108.72,42.45 108.27,42 108.13,42 107.78,42.35 v2(107.78,42.51)
M_A_DQ48: length 65.5
  IN2 w0.127: v1(96.88,83.51) 95.58,82.77 93.68,80.88 91.55,80.88 91.32,80.65 85.27,80.65 82.73,78.12 82.73,68.28 83.63,67.39 83.63,49.82 89.06,44.38 89.29,43.57 89.4,42.96 89.56,42.03 89.61,41.78 89.65,41.6 89.85,40.99 90.19,40.61 90.41,40.41 90.56,40.34 92.95,40.34 v2(93.71,40.58)
  BOTTOM w0.079: U400.G31 v1(96.88,83.51)
  BOTTOM w0.102: JDIM2800.173 94.1,44.24 93.96,42.68 93.96,41.2 v2(93.71,40.58)
M_A_DQ49: length 67.2
  IN2 w0.127: v2(92.06,40.82) 91.5,40.72 90.66,40.72 90.23,41.15 90.23,42.43 89.88,42.78 89.88,44.1 84.44,49.54 84.44,68.01 84.31,68.13 83.59,68.13 83.45,68.28 83.45,68.52 83.58,68.64 84.31,68.64 84.44,68.77 84.44,69.02 84.31,69.15 83.45,69.15 83.32,69.28 83.32,69.53 83.45,69.66 84.31,69.66 84.44,69.79 84.44,70.17 84.31,70.29 83.47,70.29 83.12,70.64 83.12,77.96 85.37,80.22 91.5,80.22 91.78,80.5 93.81,80.5 95.89,82.58 v1(96.87,82.89)
  BOTTOM w0.079: v1(96.87,82.89) 97.04,82.73 97.15,82.73 U400.G32
  BOTTOM w0.102: v2(92.06,40.82) 92.53,41 92.9,41.34 93.25,41.92 93.25,44.13 93.1,44.27 JDIM2800.169
M_A_DQ50: length 66.2
  IN2 w0.079: v1(98.62,84.16) 98.51,84.04 98.51,81.01 98.28,80.78
  IN2 w0.127: 98.28,80.78 97.82,80.32 97.82,80.14 98.28,79.68 98.28,79.5 98.1,79.32 97.92,79.32 97.46,79.78 97.28,79.78 96.78,79.28 96.45,79.28 96.17,79.56 95.79,79.56 93.98,77.74 91.88,77.74 90.43,76.29 90.43,75.42 87.07,72.05 87.07,65.52 87.19,65.4 87.6,65.4 87.7,65.3 87.7,65.02 87.57,64.89 87.19,64.89 87.07,64.76 87.07,64.51 87.19,64.38 87.57,64.38 87.7,64.25 87.7,50 94.27,43.43 96.76,43.43 96.91,43.29 96.91,43.13 96.82,43.05 96.82,42.87 97,42.69 97.18,42.69 97.27,42.78 97.45,42.78 97.63,42.6 97.63,42.42 97.54,42.33 97.54,42.15 97.81,41.89 97.81,40.74 97.68,40.61 97.2,40.61 97.03,40.44 97.03,40.16 97.16,40.04 97.62,40.04 97.82,39.83 97.82,39.63 97.7,39.5 96.99,39.5 96.86,39.38 96.86,38.61 97.05,38.42 v2(97.34,38.42)
  BOTTOM w0.079: v1(98.62,84.16) 98.42,84.36 98.38,84.36 U400.H29
  BOTTOM w0.102: JDIM2800.186 97.35,38.41 v2(97.34,38.42)
M_A_DQ51: length 66.5
  IN2 w0.079: v1(98.71,84.85) 98.23,84.37 98.23,83.83 98.32,83.74 98.32,81.32 98.2,81.21
  IN2 w0.127: 98.2,81.21 96.93,79.94 95.61,79.94 93.77,78.09 91.7,78.09 89.9,76.3 89.9,75.43 86.69,72.21 86.69,64.29 87.32,63.66 87.32,63.28 87.19,63.15 86.81,63.15 86.69,63.02 86.69,62.77 86.81,62.64 87.19,62.64 87.32,62.51 87.32,62.26 87.19,62.13 86.81,62.13 86.69,62.01 86.69,61.75 86.81,61.63 87.19,61.63 87.32,61.5 87.32,61.24 87.19,61.12 86.81,61.12 86.69,60.99 86.69,60.74 86.81,60.61 87.19,60.61 87.32,60.48 87.32,60.23 87.19,60.1 86.81,60.1 86.69,59.97 86.69,59.72 86.81,59.59 87.19,59.59 87.32,59.47 87.32,49.84 94.11,43.05 96.1,43.05 97.24,41.91 97.24,41.24 v2(96.67,40.67)
  BOTTOM w0.079: U400.H28 98.36,85.17 98.68,84.85 v1(98.71,84.85)
  BOTTOM w0.102: JDIM2800.187 97.6,44.23 97.55,44.18 97.55,41.55 v2(96.67,40.67)
M_A_DQ52: length 65
  IN2 w0.127: v1(96.87,84.73) 96.61,84.55 96.3,84.33 93.73,81.77 93.1,81.49 85.03,81.49 81.97,78.43 81.97,53.5 82.58,49.38 86.74,44.18 87.54,41.89 88.7,40.87 88.82,40.77 88.91,40.7 89.42,40.24 90.08,39.58 90.64,39.58 91.92,39.51 92.3,39.46 92.47,39.41 92.66,39.32 92.8,39.23 v2(93.06,38.97)
  BOTTOM w0.079: U400.G28 v1(96.87,84.73)
  BOTTOM w0.102: JDIM2800.170 93.35,38.06 93.45,38.16 93.45,38.59 93.07,38.97 v2(93.06,38.97)
M_A_DQ53: length 66.4
  IN2 w0.127: v2(94.34,38.35) 94.04,38.35 93.91,38.47 93.91,39.32 94.12,39.53 94.12,39.76 93.91,39.96 90.23,39.96 88.53,41.67 88.53,42.63 88.25,42.91 88.25,44.65 82.94,49.96 82.94,67.26 82.35,67.85 82.35,78.28 85.16,81.08 91.11,81.08 91.19,81.17 93.54,81.17 96.48,84.1 v1(96.88,84.1)
  BOTTOM w0.079: U400.G29 97.31,84.28 97.14,84.1 v1(96.88,84.1)
  BOTTOM w0.102: v2(94.34,38.35) 94.35,38.33 JDIM2800.174
M_A_DQ54: length 66.4
  IN2 w0.127: v1(97.82,82.91) 97.97,82.91 98.1,82.78 98.1,81.71 96.61,80.22 95.49,80.22 93.71,78.44 91.51,78.44 89.52,76.46 89.52,75.59 86.3,72.37 86.3,59.21 86.43,59.09 86.81,59.09 86.94,58.96 86.94,58.7 86.81,58.58 86.43,58.58 86.3,58.45 86.3,58.2 86.43,58.07 86.81,58.07 86.94,57.94 86.94,57.69 86.81,57.56 86.43,57.56 86.3,57.43 86.3,57.18 86.43,57.05 86.81,57.05 86.94,56.93 86.94,56.67 86.81,56.55 86.43,56.55 86.3,56.42 86.3,56.16 86.43,56.04 86.81,56.04 86.94,55.91 86.94,55.66 86.81,55.53 86.43,55.53 86.3,55.4 86.3,55.15 86.43,55.02 86.81,55.02 86.94,54.89 86.94,54.64 86.81,54.51 86.43,54.51 86.3,54.39 86.3,54.13 86.43,54.01 86.81,54.01 86.94,53.88 86.94,53.62 86.81,53.5 86.43,53.5 86.3,53.37 86.3,53.12 86.43,52.99 86.81,52.99 86.94,52.86 86.94,52.61 86.81,52.48 86.43,52.48 86.3,52.35 86.3,52.1 86.43,51.97 86.81,51.97 86.94,51.85 86.94,51.59 86.81,51.47 86.43,51.47 86.3,51.34 86.3,51.11 86.43,50.98 86.81,50.98 86.94,50.86 86.94,50.67 86.77,50.5 86.47,50.5 86.37,50.4 86.37,50.26 86.6,50.02 86.83,50.02 86.94,49.91 86.94,49.68 93.95,42.67 95.87,42.67 v2(96.6,41.94)
  BOTTOM w0.079: U400.H31 98.11,83.33 97.91,83.33 97.72,83.14 97.72,83.01 v1(97.82,82.91)
  BOTTOM w0.102: v2(96.6,41.94) JDIM2800.183
M_A_DQ55: length 67.3
  IN2 w0.127: v1(97.71,82.31) 97.71,81.74 96.51,80.55 95.44,80.55 93.68,78.79 90.94,78.79 90.81,78.67 90.81,78.29 90.67,78.14 90.49,78.14 89.91,78.73 89.7,78.73 89.52,78.55 89.52,78.37 90.12,77.77 90.12,77.59 89.95,77.42 89.77,77.42 89.28,77.92 89.1,77.92 88.93,77.75 88.93,77.55 89.41,77.07 89.41,76.89 89.14,76.62 89.14,75.74 87.18,73.79 87,73.79 86.7,74.09 86.52,74.09 86.35,73.93 86.35,73.72 86.64,73.43 86.64,73.25 86.46,73.07 86.28,73.07 84.92,74.43 84.74,74.43 84.61,74.3 84.61,74.02 85.92,72.71 85.92,50.16 93.79,42.29 95.53,42.29 96.22,41.59 96.22,40.16 96.35,40.04 96.35,39.49 v2(95.85,38.99)
  BOTTOM w0.079: U400.H32 97.96,82.57 v1(97.71,82.31)
  BOTTOM w0.102: v2(95.85,38.99) 95.87,38.99 96.35,38.51 JDIM2800.182
M_A_DQ56: length 57.8
  IN2 w0.079: v1(99.59,83.74) 99.18,83.33 99.18,81.66 99.38,81.46 99.38,79.82 99.48,79.72 99.48,78.62 99.7,78.4
  IN2 w0.127: v2(109.69,41.92) 109.25,41.92 109.13,41.79 109.13,41.36 108.93,41.15 108.93,40.76 109.05,40.63 109.43,40.63 110.17,41.38 110.17,42.35 110.19,42.37 110.19,44.49 98.2,56.48 98.2,70.41 98.53,70.74 98.53,71.61 99.65,72.73 99.65,74.45 100.22,75.02 100.22,77.88 99.7,78.4
  BOTTOM w0.079: U400.L31 99.8,83.47 99.8,83.53 v1(99.59,83.74)
  BOTTOM w0.102: JDIM2800.233 109.1,43.97 109.33,43.74 109.33,42.14 108.88,41.7 108.88,41.55 109.01,41.43 109.2,41.43 v2(109.69,41.92)
M_A_DQ57: length 58.8
  IN2 w0.079: v1(99.6,83.07) 99.34,82.82 99.34,81.8 99.65,81.49 99.65,78.74 99.75,78.64 99.85,78.64 99.93,78.56
  IN2 w0.127: v2(109.85,38.4) 110.05,38.21 112.3,38.21 112.43,38.33 112.43,38.56 112.3,38.69 110.4,38.69 110.09,38.99 110.09,39.63 109.91,39.81 109.91,40.58 110.56,41.22 110.56,44.67 98.67,56.55 98.67,70.16 98.92,70.4 98.92,71.33 100.01,72.42 100.01,74.3 100.52,74.81 100.52,77.97 99.93,78.56
  BOTTOM w0.079: U400.L32 100.18,82.7 100.18,82.81 100.07,82.91 99.96,82.91 99.8,82.76 99.69,82.76 99.6,82.86 v1(99.6,83.07)
  BOTTOM w0.102: v2(109.85,38.4) JDIM2800.236
M_A_DQ58: length 56.8
  IN2 w0.127: v1(101.42,84.39) 101.1,84.39 100.97,84.26 100.97,82.77 101.43,82.31 101.43,81.11 101.76,80.78 101.76,79.75 102.07,79.44 102.07,77.91 102.65,77.32 102.65,73.97 102.4,73.72 102.4,72.45 101.09,71.14 101.09,61.62 101.8,60.9 101.8,60.23 102.04,59.99 102.04,59.14 102.55,58.64 102.55,58.18 102.9,57.83 102.9,57.17 103.33,56.74 103.33,55.07 112.84,45.57 112.84,42.64 113.13,42.35 113.8,42.35 114.31,41.84 114.31,40.8 114.92,40.19 114.92,39.65 114.73,39.46 114.37,39.46 113.9,38.99 v2(113.52,38.99)
  BOTTOM w0.079: v1(101.42,84.39) 101.29,84.52 U400.N29
  BOTTOM w0.102: v2(113.52,38.99) 113.35,38.83 JDIM2800.250
M_A_DQ59: length 56.5
  IN2 w0.127: v2(113.55,43.59) 113.82,43.59 113.95,43.72 113.95,44.04 113.76,44.23 113.39,44.23 113.26,44.36 113.26,45.68 104.64,54.31 104.64,54.69 104.3,55.03 103.93,55.03 103.71,55.25 103.71,56.9 103.28,57.33 103.28,57.99 102.98,58.29 102.98,58.74 102.42,59.3 102.42,60.15 102.19,60.39 102.19,61.06 101.47,61.78 101.47,62.02 101.73,62.28 101.73,62.83 101.47,63.09 101.47,71.09 102.69,72.31 102.69,73.68 102.88,73.87 102.88,77.55 102.41,78.02 102.41,79.57 102.14,79.84 102.14,80.02 102.27,80.14 102.7,80.14 102.83,80.27 102.83,80.52 102.7,80.65 102.27,80.65 102.14,80.78 102.14,80.92 101.81,81.25 101.81,81.43 101.94,81.56 102.36,81.56 102.52,81.73 102.52,81.93 102.4,82.05 102.01,82.05 101.89,82.18 101.89,84.92 101.76,85.05 v1(101.41,85.05)
  BOTTOM w0.079: U400.N28 100.96,84.87 101.03,84.79 101.33,84.79 101.41,84.87 v1(101.41,85.05)
  BOTTOM w0.102: v2(113.55,43.59) 113.55,43.57 112.67,42.69 112.52,42.69 112.42,42.79 112.42,42.99 113.1,43.67 113.1,43.85 113.23,43.98 113.23,44.12 113.1,44.24 JDIM2800.249
M_A_DQ60: length 54.3
  IN2 w0.079: v1(99.61,84.98) 99.26,84.49 99.26,84.48 99.2,84.39 98.8,83.62 98.8,81.38 98.91,79.88 99.11,79.19 99.15,79.08 99.15,78.34
  IN2 w0.127: v2(108.34,39.32) 108.82,43.67 108.82,44.79 97.16,56.45 97.16,70.29 97.36,70.95 97.44,71.15 97.66,71.87 99.03,75.1 99.4,75.91 99.46,76.14 99.52,77.53 99.5,77.65 99.39,77.82 99.27,78.08 99.15,78.34
  BOTTOM w0.079: U400.L28 v1(99.61,84.98)
  BOTTOM w0.102: v2(108.34,39.32) 108.85,38.81 JDIM2800.232
M_A_DQ61: length 55.9
  IN2 w0.079: 99.44,78.34 99.31,78.47 99.31,79.6 99.13,79.78 99.13,81.3 98.99,81.44 98.99,83.44 99.21,83.66 99.21,83.94 v1(99.6,84.33)
  IN2 w0.127: 99.44,78.34 99.88,77.9 99.88,75.19 99.07,74.37 99.07,74.17 99.27,73.97 99.27,73.79 99.14,73.67 98.87,73.67 98.66,73.46 98.66,73.21 98.79,73.08 99.07,73.08 99.2,72.95 99.2,72.75 99.04,72.6 98.38,72.6 98.26,72.47 98.26,72.27 98.38,72.14 98.38,71.94 98.1,71.66 98.1,70.9 97.62,70.41 97.62,56.53 109.56,44.59 109.56,44.4 109.2,44.05 109.2,43.19 109.42,42.98 109.56,42.98 v2(109.77,43.19)
  BOTTOM w0.079: U400.L29 100.16,84.4 100.16,84.29 100.03,84.15 99.78,84.15 v1(99.6,84.33)
  BOTTOM w0.102: v2(109.77,43.19) 109.96,43 109.96,42.92 110.22,42.67 110.22,42.52 110.55,42.19 110.75,42.19 110.88,42.32 110.88,42.58 110.32,43.13 110.32,44.02 110.1,44.24 JDIM2800.237
M_A_DQ62: length 56.9
  IN2 w0.127: v1(100.57,82.83) 101.18,82.23 101.18,80.82 101.38,80.61 101.38,79.64 101.79,79.23 101.79,77.65 102.23,77.21 102.23,73.98 102.14,73.89 102.14,72.65 100.71,71.21 100.71,61.46 101.42,60.75 101.42,60.07 101.66,59.83 101.66,58.99 102.17,58.48 102.17,58.02 102.52,57.67 102.52,57.01 102.93,56.6 102.93,54.94 112.45,45.41 112.45,42.07 112.71,41.81 113.67,41.81 113.8,41.69 113.8,41.43 113.67,41.31 112.81,41.31 112.63,41.13 112.63,40.87 112.76,40.75 113.24,40.75 113.37,40.62 113.37,40.37 113.24,40.24 112.63,40.24 112.5,40.11 112.5,39.83 112.63,39.71 113.11,39.71 113.24,39.58 113.24,39.4 v2(112.89,39.05)
  BOTTOM w0.079: U400.N31 100.76,83.02 100.75,83.02 v1(100.57,82.83)
  BOTTOM w0.102: JDIM2800.246 112.35,38.51 v2(112.89,39.05)
M_A_DQ63: length 58.6
  IN2 w0.127: v2(112,43.79) 112,45.33 102.52,54.8 102.52,55.3 102.4,55.43 101.92,55.43 101.71,55.65 101.71,55.8 101.84,55.94 102.42,55.94 102.55,56.06 102.55,56.37 102.42,56.49 100.87,56.49 100.62,56.75 100.62,56.93 100.75,57.05 101.99,57.05 102.14,57.21 102.14,57.49 102.01,57.61 100.38,57.61 100.26,57.74 100.26,58.07 100.38,58.19 101.28,58.19 101.4,58.32 101.4,58.57 101.28,58.7 100.45,58.7 100.33,58.83 100.33,59.08 100.45,59.21 101.15,59.21 101.28,59.34 101.28,59.59 101.15,59.72 100.45,59.72 100.33,59.84 100.33,60.1 100.45,60.23 100.9,60.23 101.02,60.35 101.02,60.61 100.9,60.73 100.45,60.73 100.33,60.86 100.33,71.44 101.08,72.19 101.33,72.19 101.86,72.73 101.86,74.21 101.9,74.24 101.9,76.98 101.74,77.15 101.48,77.15 101.35,77.27 101.35,78.44 101,78.79 101,80.45 100.72,80.73 100.72,81.44 100.82,81.54 100.82,82 v1(100.72,82.1)
  BOTTOM w0.079: v1(100.72,82.1) 100.83,81.99 101.02,81.99 101.2,82.17 101.58,82.17 101.66,82.25 101.66,82.36 101.52,82.5 101.28,82.5 101.21,82.57 U400.N32
  BOTTOM w0.102: v2(112,43.79) 112.17,43.63 112.27,43.63 112.45,43.81 112.45,43.95 112.1,44.3 JDIM2800.245
M_A_DQSN0: length 79.4
  IN1 w0.114: v2(51.45,43.02) 51.72,43.29 51.72,44.22 53.3,45.8 59.18,45.8 61.08,47.7 61.08,47.86 60.82,48.12 60.56,48.37 60.56,48.66 61.06,49.16 61.35,49.16 61.89,48.61 61.99,48.61 62.48,49.1 62.48,49.19 61.93,49.74 61.93,50.03 62.4,50.51 62.69,50.51 63.24,49.96 63.34,49.96 63.68,50.3 63.68,50.4 63.24,50.84 63.24,51.29 63.55,51.61 64,51.61 64.35,51.25 64.61,51.25 64.79,51.43 64.79,51.69 64.37,52.12 64.37,52.47 80.86,68.96 80.86,80.39 86.63,86.16 90.7,86.16 91.09,85.77 91.09,85.41 91.21,85.3 v1(91.32,85.3)
  BOTTOM w0.079: U400.C27 95.27,85.84 95.33,85.89 95.33,86.02 95.26,86.08 95.18,86.11 95.03,86.11 94.93,86.06 94.68,86.06 94.56,86.09 94.35,86.09 94.28,86.06 93.33,86.06 93.32,86.05
  BOTTOM w0.097: JDIM2800.11 51.6,44.16 51.68,44.09 51.68,43.25 v2(51.45,43.02)
  BOTTOM w0.102: 93.32,86.05 93.04,85.78 91.18,85.78 91.08,85.68 91.08,85.54 v1(91.32,85.3)
M_A_DQSN1: length 63.1
  IN1 w0.114: v1(92.8,81.9) 92.64,81.74 92.64,81.18 90.27,78.81 90.27,70.33 87.73,67.8 87.73,67.64 87.94,67.42 87.94,66.98 87.63,66.66 87.18,66.66 87.04,66.79 86.79,66.79 86.6,66.61 86.6,66.35 86.79,66.17 86.79,65.82 86.37,65.41 86.02,65.41 85.81,65.62 85.55,65.62 85.37,65.44 85.37,65.18 85.58,64.97 85.58,64.62 85.17,64.2 84.82,64.2 84.56,64.46 84.4,64.46 73.31,53.37 63.46,43.52 63.46,42.63 63.05,42.22 62.72,42.22 v2(62.52,42.02)
  BOTTOM w0.079: 93.37,82.57 93.55,82.57 93.93,82.95 94.01,82.95 94.07,82.95 94.23,82.94 94.26,82.93 94.34,82.9 94.37,82.88 94.55,82.88 94.69,82.94 94.69,82.94 95.3,82.99 U400.D31
  BOTTOM w0.097: JDIM2800.53 62.1,43.89 61.79,43.57 61.79,42.49 62.05,42.23 62.31,42.23 v2(62.52,42.02)
  BOTTOM w0.102: v1(92.8,81.9) 92.66,82.04 92.66,82.27 92.75,82.35 92.99,82.35 93.21,82.57 93.37,82.57
M_A_DQSN2: length 75.2
  IN2 w0.114: v1(97.69,87.35) 97.05,87.99 96.12,87.99 93.71,85.58 93.71,85.29 93.18,84.77 88.15,84.77 87.82,84.43 84.25,84.43 79.32,79.51 79.32,58.13 78.62,57.42 78.62,57.07 79.27,56.42 79.27,56.33 78.92,55.98 78.83,55.98 78.18,56.63 77.83,56.63 77.41,56.22 77.41,55.87 78.06,55.22 78.06,55.12 77.72,54.78 77.62,54.78 76.97,55.43 76.62,55.43 76.21,55.01 76.21,54.66 76.86,54.02 76.86,53.92 75.4,52.46 67.95,45.01 67.95,41.86 67.31,41.21 67.31,40.05 v2(67.12,39.86)
  BOTTOM w0.079: v1(97.69,87.35) 98.03,87.69 U400.H24
  BOTTOM w0.097: JDIM2800.74 67.35,37.92 67.28,38 67.28,39.7 v2(67.12,39.86)
M_A_DQSN3: length 80.2
  IN2 w0.114: v1(92.92,88.24) 92.74,88.42 92.74,88.88 92.34,89.29 89.56,89.29 89.08,89.77 83.02,89.77 74.91,81.66 74.91,61.97 70.23,57.29 70.23,56.78 70.42,56.59 70.42,56.33 70.24,56.15 69.98,56.15 69.87,56.26 69.42,56.26 69.11,55.94 69.11,55.49 69.31,55.29 69.31,55.13 59.5,45.32 58.09,45.32 56.68,43.9 56.68,41.54 56.83,41.39 56.83,40.01 56.65,39.83 v2(56.65,39.84)
  BOTTOM w0.079: U400.C23 95.27,88.35 95.35,88.28 95.35,88.2 95.3,88.12 95.28,88.12 95.16,88.09 95.06,88.09 94.9,88.13 94.68,88.13 94.58,88.1 94.38,88.1 94.25,88.13 93.91,88.13 93.65,87.86 92.75,87.86 92.69,87.92 92.69,88.02 v1(92.92,88.24)
  BOTTOM w0.097: v2(56.65,39.84) 56.65,39.83 56.99,39.49 56.99,38.06 56.85,37.93 JDIM2800.32
M_A_DQSN4: length 56.6
  IN2 w0.114: v1(94.08,75.2) 94.23,75.34 94.23,75.51 94.14,75.6 93.83,75.6 93.23,74.99 93.23,74.38 90.34,71.49 90.34,51.29 95.55,46.08 97.87,46.08 100.57,43.38 100.57,39.6 100.81,39.35 100.96,39.35 101.07,39.46 v2(101.07,39.69)
  BOTTOM w0.079: U400.J35 98.83,80.78 98.78,80.83 98.7,80.83 98.64,80.77 98.57,80.65 98.57,80.45 98.6,80.36 98.6,80.12 98.58,80.03 98.58,79.81 98.6,79.73 98.6,79.3 98.43,79.12 98.43,78.59 95.97,76.13 95.97,76.1 95.96,76.09
  BOTTOM w0.097: v1(94.08,75.2) 94.13,75.24 94.47,75.24 94.54,75.17 95.04,75.17 95.96,76.09 ; JDIM2800.198 100.35,37.97 100.47,38.08 100.47,38.38 100.39,38.45 100.39,39.17 100.61,39.38 100.95,39.38 101.07,39.5 v2(101.07,39.69)
M_A_DQSN5: length 53
  IN2 w0.114: v1(97.93,74.59) 97.93,74.82 97.81,74.94 97.39,74.94 94.89,72.44 94.89,68.85 94.75,68.71 94.75,55.45 105.42,44.79 105.42,42.42 105.59,42.26 105.75,42.26 105.88,42.39 v2(105.88,42.54)
  BOTTOM w0.079: 99.89,75.62 99.9,75.63 99.9,75.64 100.31,76.05 100.31,77.18 101.92,78.78 101.92,79.25 101.74,79.42 101.74,79.71 101.77,79.79 101.77,80.06 101.74,80.13 101.74,80.33 101.77,80.38 101.77,80.71 101.72,80.83 101.72,80.83 101.59,80.96 101.39,80.96 101.35,81 U400.P34
  BOTTOM w0.097: v1(97.93,74.59) 97.93,74.81 98.02,74.9 99.17,74.9 99.89,75.62 ; v2(105.88,42.54) 105.88,42.32 106.02,42.17 106.15,42.17 106.33,42.36 106.33,43.36 105.97,43.72 105.87,43.72 105.71,43.88 105.71,44.19 105.6,44.3 JDIM2800.219
M_A_DQSN6: length 66.6
  IN2 w0.079: v1(97.77,84.32) 97.58,84.13 97.45,84.13 97.26,83.93 97.26,82.72 97.01,82.48 96.95,82.48 96.68,82.21 96.63,82.21 96.58,82.15
  IN2 w0.114: 96.58,82.15 96.03,81.61 95.35,81.61 94.85,81.11 94.85,80.82 93.61,79.58 89.14,79.58 88.81,79.25 87.94,79.25 87.61,79.58 85.63,79.58 83.74,77.7 83.74,71.18 84.01,70.92 84.88,70.92 85.07,70.73 85.07,49.8 91.3,43.57 91.3,42.59 91.74,42.14 92.44,42.14 93.15,41.43 94.86,41.43 94.95,41.34 94.95,41.13 v2(94.73,40.91)
  BOTTOM w0.079: v1(97.77,84.32) 97.58,84.13 97.57,84.13 U400.G30
  BOTTOM w0.097: JDIM2800.177 95.1,44.3 95.22,44.19 95.22,42.92 94.98,42.68 94.98,41.16 v2(94.73,40.91)
M_A_DQSN7: length 56
  IN2 w0.079: 100.14,81.59 100.14,81.6 100.17,81.63 100.17,82.41 99.97,82.61 99.97,83.72 100.16,83.92 100.44,83.92 100.53,84 v1(100.53,84.13)
  IN2 w0.114: v2(110.72,39.38) 110.96,39.61 110.96,39.71 110.62,40.05 110.62,40.4 110.87,40.65 111.65,40.65 111.77,40.76 111.77,40.95 111.18,41.53 111.18,44.93 99.4,56.72 99.4,71.27 100.39,72.26 100.39,72.74 100.82,73.18 100.82,73.49 100.4,73.91 100.4,74.26 100.8,74.66 100.8,78.34 100.44,78.69 100.44,79.95 100.14,80.25 100.14,81.59
  BOTTOM w0.079: U400.L30 100.12,83.8 100.39,83.8 100.53,83.94 v1(100.53,84.13)
  BOTTOM w0.097: v2(110.72,39.38) 111.01,39.1 111.01,38.11 110.85,37.95 JDIM2800.240
M_A_DQSN8: length 6.2
  TOP w0.102: R2803.2 71.97,44.13 72.12,43.97 72.12,42.83 v2(71.53,42.24)
  BOTTOM w0.114: JDIM2800.95 72.6,44.23 72.39,44.02 72.39,43.1 v2(71.53,42.24)
M_A_DQSP0: length 79.6
  IN1 w0.114: v2(52.21,43.02) 52.02,43.02 51.95,43.08 51.95,44.13 53.4,45.57 59.27,45.57 61.3,47.6 61.3,47.95 60.98,48.28 60.79,48.47 60.79,48.57 61.15,48.93 61.25,48.93 61.8,48.38 62.08,48.38 62.7,49 62.7,49.29 62.16,49.84 62.16,49.93 62.5,50.28 62.6,50.28 63.14,49.73 63.43,49.73 63.91,50.21 63.91,50.49 63.47,50.94 63.47,51.19 63.65,51.38 63.91,51.38 64.26,51.02 64.71,51.02 65.02,51.34 65.02,51.79 64.6,52.21 64.6,52.38 81.09,68.86 81.09,80.29 86.72,85.93 90.61,85.93 90.86,85.68 90.86,85.53 v2(90.64,85.3)
  BOTTOM w0.079: U400.D27 95.6,85.84 95.5,85.94 95.5,86.09 95.35,86.23 95.21,86.28 95,86.28 94.9,86.23 94.7,86.23 94.58,86.26 94.31,86.26 94.25,86.23 93.23,86.23
  BOTTOM w0.097: JDIM2800.13 52.1,44.39 51.88,44.16 51.88,43.19 52.04,43.02 v2(52.21,43.02)
  BOTTOM w0.102: v2(90.64,85.3) 90.84,85.5 90.84,85.78 91.02,85.97 92.96,85.97 93.23,86.23
M_A_DQSP1: length 63.1
  IN1 w0.114: v1(92.13,81.92) 92.34,81.92 92.41,81.85 92.41,81.83 92.41,81.83 92.41,81.27 90.04,78.9 90.04,70.43 87.5,67.89 87.5,67.54 87.72,67.33 87.72,67.07 87.53,66.89 87.27,66.89 87.14,67.02 86.69,67.02 86.38,66.71 86.38,66.26 86.56,66.08 86.56,65.91 86.28,65.63 86.12,65.63 85.91,65.85 85.46,65.85 85.14,65.53 85.14,65.08 85.35,64.87 85.35,64.71 85.07,64.43 84.91,64.43 84.65,64.69 84.3,64.69 73.21,53.6 63.23,43.62 63.23,42.72 62.96,42.45 62.57,42.45 62.49,42.53 v2(62.49,42.85)
  BOTTOM w0.079: U400.C31 94.68,83.14 94.64,83.1 94.52,83.05 94.41,83.05 94.41,83.05 94.32,83.08 94.27,83.1 94.02,83.12 93.86,83.12 93.5,82.76 93.37,82.76
  BOTTOM w0.097: JDIM2800.55 62.6,44.34 62.49,44.23 62.35,44.23 62.3,44.18 62.3,43.81 61.98,43.49 61.98,42.58 62.14,42.42 62.39,42.42 62.49,42.52 v2(62.49,42.85)
  BOTTOM w0.102: v1(92.13,81.92) 92.33,81.92 92.47,82.07 92.47,82.35 92.67,82.54 92.91,82.54 93.13,82.76 93.37,82.76
M_A_DQSP2: length 75.2
  IN2 w0.114: v1(97.07,87.35) 97.07,87.65 96.96,87.76 96.21,87.76 93.94,85.48 93.94,85.2 93.28,84.54 88.24,84.54 87.91,84.21 84.34,84.21 79.55,79.42 79.55,58.04 78.85,57.33 78.85,57.17 79.49,56.52 79.49,56.23 79.02,55.75 78.73,55.75 78.08,56.4 77.92,56.4 77.64,56.12 77.64,55.96 78.29,55.31 78.29,55.03 77.81,54.55 77.53,54.55 76.88,55.2 76.72,55.2 76.44,54.92 76.44,54.76 77.09,54.11 77.09,53.82 75.63,52.37 68.18,44.92 68.18,41.76 67.54,41.12 67.54,39.94 67.65,39.83 v2(67.99,39.83)
  BOTTOM w0.079: U400.G24 97.24,87.7 97.07,87.53 v1(97.07,87.35)
  BOTTOM w0.097: JDIM2800.76 67.85,37.98 67.78,38.06 67.52,38.06 67.47,38.11 67.47,39.66 67.65,39.83 v2(67.99,39.83)
M_A_DQSP3: length 80.2
  IN2 w0.114: v1(92.29,88.24) 92.52,88.47 92.52,88.79 92.24,89.06 89.47,89.06 88.98,89.54 83.11,89.54 75.13,81.56 75.13,61.87 70.45,57.19 70.45,56.88 70.65,56.69 70.65,56.24 70.33,55.92 69.88,55.92 69.78,56.03 69.52,56.03 69.34,55.85 69.34,55.59 69.54,55.38 69.54,55.03 59.6,45.09 58.19,45.09 56.9,43.81 56.9,41.64 57.06,41.48 57.06,39.96 57.18,39.83 v2(57.41,39.83)
  BOTTOM w0.079: U400.D23 95.6,88.35 95.52,88.28 95.52,88.15 95.4,87.96 95.18,87.93 95.04,87.93 94.88,87.96 94.7,87.96 94.6,87.93 94.36,87.93 94.23,87.96 93.98,87.96 93.72,87.7 92.68,87.7 92.53,87.85 92.53,88.01 v1(92.29,88.24)
  BOTTOM w0.097: JDIM2800.34 57.35,37.91 57.19,38.08 57.19,39.68 57.34,39.83 v2(57.41,39.83)
M_A_DQSP4: length 56.4
  IN2 w0.114: v2(101.07,38.93) 100.88,39.12 100.72,39.12 100.34,39.5 100.34,43.29 97.77,45.85 95.45,45.85 90.11,51.19 90.11,71.59 93,74.48 93,75.09 93.73,75.82 94.24,75.82 94.32,75.73 v1(94.62,75.73)
  BOTTOM w0.079: U400.J34 98.83,81.05 98.78,81 98.63,81 98.5,80.87 98.4,80.69 98.4,80.41 98.44,80.32 98.44,80.15 98.41,80.05 98.41,79.78 98.44,79.7 98.44,79.37 98.26,79.19 98.26,78.66 95.85,76.24 95.83,76.24 95.82,76.23
  BOTTOM w0.097: v1(94.62,75.73) 94.51,75.62 94.51,75.48 94.62,75.37 94.95,75.37 95.82,76.23 ; JDIM2800.200 100.85,37.92 100.67,38.11 100.67,38.46 100.59,38.54 100.59,39.08 100.69,39.18 100.83,39.18 v2(101.07,38.93)
M_A_DQSP5: length 52.9
  IN2 w0.114: v1(97.93,75.32) 97.77,75.16 97.29,75.16 94.66,72.53 94.66,68.94 94.52,68.81 94.52,55.36 105.19,44.69 105.19,42.33 105.49,42.03 105.78,42.03 105.88,41.93 v2(105.88,41.78)
  BOTTOM w0.079: 99.76,75.75 99.77,75.76 99.78,75.76 100.15,76.12 100.15,77.25 101.75,78.85 101.75,79.18 101.58,79.35 101.58,79.73 101.6,79.82 101.6,80.03 101.58,80.1 101.58,80.36 101.6,80.42 101.6,80.68 101.58,80.73 101.52,80.79 101.39,80.79 101.35,80.75 U400.P35
  BOTTOM w0.097: v2(105.88,41.78) 106.07,41.97 106.23,41.97 106.53,42.27 106.53,43.45 106.06,43.92 105.96,43.92 105.91,43.97 105.91,44.15 106.1,44.35 JDIM2800.221 ; v1(97.93,75.32) 98.16,75.09 99.1,75.09 99.76,75.75
M_A_DQSP6: length 66.6
  IN2 w0.079: 96.74,81.99 96.75,82.01 96.75,82.02 96.75,82.02 96.75,82.04 97.02,82.31 97.08,82.31 97.42,82.65 97.42,83.86 97.52,83.96 97.71,83.96 97.79,83.88 v1(97.79,83.67)
  IN2 w0.114: 96.74,81.99 96.13,81.38 95.45,81.38 95.08,81.01 95.08,80.73 93.71,79.35 89.24,79.35 88.91,79.02 87.84,79.02 87.51,79.35 85.72,79.35 83.97,77.6 83.97,71.28 84.1,71.15 84.97,71.15 85.3,70.83 85.3,49.9 91.52,43.67 91.52,42.69 91.84,42.37 92.53,42.37 93.24,41.66 94.95,41.66 95.18,41.43 95.18,41.22 v2(95.49,40.91)
  BOTTOM w0.079: v1(97.79,83.67) 97.79,83.79 97.87,83.87 U400.H30
  BOTTOM w0.097: v2(95.49,40.91) 95.3,40.91 95.18,41.03 95.18,42.6 95.42,42.84 95.42,44.11 95.6,44.29 JDIM2800.179
M_A_DQSP7: length 56
  IN2 w0.079: 100.36,81.59 100.36,81.61 100.33,81.64 100.33,82.48 100.14,82.68 100.14,83.66 100.23,83.75 100.44,83.75 100.53,83.66 v1(100.53,83.47)
  IN2 w0.114: 100.36,81.59 100.36,80.35 100.67,80.04 100.67,78.79 101.02,78.43 101.02,74.56 100.63,74.17 100.63,74 101.05,73.58 101.05,73.08 100.62,72.65 100.62,72.17 99.63,71.18 99.63,56.81 111.41,45.03 111.41,41.63 111.99,41.05 111.99,40.67 111.75,40.42 110.96,40.42 110.85,40.3 110.85,40.14 111.18,39.81 111.18,39.47 111.3,39.36 v2(111.49,39.36)
  BOTTOM w0.079: v1(100.53,83.47) 100.53,83.7 100.62,83.79 100.87,83.79 U400.N30
  BOTTOM w0.097: v2(111.49,39.36) 111.3,39.36 111.2,39.26 111.2,38.08 111.35,37.94 JDIM2800.242
M_A_DQSP8: length 2.9
  TOP w0.102: R2802.2 72.98,44.35 72.8,44.17 v2(72.8,43.62)
  BOTTOM w0.114: JDIM2800.97 73.1,44.25 72.8,43.95 v2(72.8,43.62)
