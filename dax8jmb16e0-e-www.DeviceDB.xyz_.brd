# Allegro board dax8jmb16e0-e-www.DeviceDB.xyz_.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB_CYPRESS_BOT_L_DP: length 25.1
  TOP w0.097: R6317.1 219.55,109.91 219.65,110.02 220.18,110.02 220.48,110.32 220.63,110.32 220.94,110.62 220.94,111.06 221.03,111.16 221.18,111.16 221.35,110.99 U6300.10 U6300.1 222.78,110.99 222.93,111.14 222.98,111.14 223.27,110.86 224.61,110.86 226.34,109.13 227.64,109.13 227.95,108.81 227.95,108.13 228.81,107.27 229,107.27 v2(229.22,107.05)
  IN2 w0.114: CN6300.B6 234.87,115.25 234.55,115.25 234.09,114.79 234.09,113.37 232.41,111.68 232.41,110.58 232.2,110.37 232.2,108.44 231.56,107.8 230.28,107.8 229.69,107.22 229.39,107.22 v2(229.22,107.05)
USB_CYPRESS_TOP_DN: length 35.3
  TOP w0.097: v2(195.13,109.28) 195.36,109.51 195.36,110.03 194.9,110.5 193.82,110.5 193.67,110.65 192.82,110.65 192.71,110.53 U6100.27 ; R6316.2 218.31,112 217.73,112 217.46,112.27 217.28,112.27 v2(217.01,112)
  BOTTOM w0.097: v2(195.13,109.28) 195.3,109.28 195.39,109.19 195.39,108.92 195.63,108.67 197.81,108.67 202.18,104.3 204.8,104.3 206.23,105.73 211.93,105.73 213.49,107.29 213.49,108.21 213.88,108.6 213.88,109.24 214.4,109.77 215.47,109.77 215.96,110.26 215.96,110.83 216.08,110.96 216.08,111.99 216.31,112.22 216.79,112.22 v2(217.01,112)
USB_CYPRESS_TOP_DP: length 35.3
  TOP w0.097: U6100.28 192.71,111.03 192.9,110.85 193.75,110.85 193.9,110.7 194.98,110.7 195.56,110.11 195.56,109.51 v2(195.79,109.28) ; v2(217.01,112.76) 217.3,112.48 217.41,112.48 217.73,112.8 218.31,112.8 R6315.2
  BOTTOM w0.097: v2(195.79,109.28) 195.59,109.08 195.59,109 195.72,108.87 197.9,108.87 202.27,104.5 204.72,104.5 206.15,105.93 211.85,105.93 213.29,107.37 213.29,108.3 213.68,108.68 213.68,109.33 214.32,109.96 215.39,109.96 215.76,110.34 215.76,110.92 215.88,111.04 215.88,112.07 216.23,112.42 216.68,112.42 217.01,112.75 v2(217.01,112.76)
USB_CYPRESS_TOP_L_DN: length 24.4
  TOP w0.097: R6316.1 219.55,111.89 219.65,112 220.13,112 220.43,112.3 220.64,112.3 220.98,112.65 221.11,112.65 221.27,112.49 U6300.7 U6300.4 222.76,112.49 222.91,112.64 223.06,112.64 223.96,111.75 224.69,111.75 226.53,109.9 227.98,109.9 228.66,109.21 228.66,108.89 228.86,108.69 229.47,108.69 229.56,108.61 v2(229.56,108.36)
  IN2 w0.114: v2(229.56,108.36) 229.68,108.48 230.57,108.48 231,108.9 231,111.26 230.39,111.87 230.39,114.13 231.1,114.84 231.72,114.84 231.88,115 232.07,115 v2(232.26,114.81)
  BOTTOM w0.097: v2(232.26,114.81) 232.47,115.02 233.31,115.02 233.51,115.22 233.63,115.22 233.76,115.09 CN6300.A7
USB_CYPRESS_TOP_L_DP: length 24.4
  TOP w0.097: R6315.1 219.55,112.91 219.65,112.8 220.18,112.8 220.48,112.5 220.56,112.5 220.9,112.85 221.12,112.85 221.27,112.99 U6300.6 U6300.5 222.73,112.99 222.88,112.84 223.14,112.84 224.04,111.94 224.77,111.94 226.61,110.1 228.06,110.1 228.86,109.3 228.86,108.97 228.94,108.89 229.32,108.89 v2(229.56,109.13)
  IN2 w0.114: v2(229.56,109.13) 229.99,108.7 230.48,108.7 230.77,109 230.77,111.16 230.16,111.77 230.16,114.23 231,115.07 231.63,115.07 231.78,115.23 232.05,115.23 v2(232.26,115.45)
  BOTTOM w0.097: v2(232.26,115.45) 232.5,115.21 233.23,115.21 233.43,115.42 233.63,115.42 233.8,115.59 CN6300.A6
USBP1+: length 139.3
  IN1 w0.114: v2(134.31,103.47) 134.53,103.26 134.53,102.58 135.78,101.33 137.33,101.33 138.83,99.83 142.32,99.83 142.93,100.44 143.44,100.44 145.37,102.37 147.57,102.37 150.06,104.86 156.81,104.86 157.93,103.74 159.1,103.74 161.98,100.86 161.98,100.34 162.49,99.83 162.49,99.55 163.32,98.72 166.8,98.72 167.37,99.29 170.86,99.29 171.06,99.09 181.99,99.09 190.12,90.96 190.79,90.96 192.08,89.67 192.08,85.06 191.59,84.56 191.59,83.75 191.4,83.56 191.4,80.57 192.81,79.16 192.81,75.71 193.69,74.84 193.69,73.11 195.74,71.05 195.99,71.05 196.24,70.81 196.24,68.79 196.51,68.53 196.51,66.77 201.41,61.88 202.92,61.88 205.04,59.75 206.5,59.75 209,57.25 210.76,57.25 211.76,56.25 212.95,56.25 215.32,53.88 215.32,51.29 215.58,51.03 215.58,50.33 216.12,49.79 216.54,49.79 v2(216.76,49.57)
  BOTTOM w0.079: v2(134.31,103.47) 134.31,103.72 134.18,103.85 133.92,103.85 133.16,103.09 133.16,102.62 133.31,102.47 133.31,102.12 133.29,102.04 133.26,101.98 133.25,101.81 133.29,101.71 133.32,101.53 133.28,101.38 133.21,101.21 133.15,100.65 U400.CE4
  BOTTOM w0.097: v2(216.76,49.57) 216.54,49.79 216.16,49.79 215.71,50.24 215.71,51.51 216.81,52.61 217.35,52.61 217.38,52.57 217.99,52.57 218.15,52.73 218.31,52.73 v2(218.89,53.3) 218.89,52.93 219.05,52.77 219.13,52.77 219.36,52.77 219.52,52.93 219.52,53.97 219.92,54.36 220.18,54.36 220.4,54.58 L5701.2 220.82,54.58 220.93,54.69 R5701.1
USBP1+_C: length 24.3
  IN2 w0.114: CN5701.3 228.04,51.81 227.82,51.6 227.46,51.6 227.11,51.95 227.11,58.4 227.52,58.81 227.82,58.81 228.02,59.01 228.02,59.32 v2(228.25,59.55)
  BOTTOM w0.097: R5701.2 222.42,54.69 222.52,54.58 L5701.1 222.82,54.58 223.22,54.19 223.51,54.19 223.76,54.44 C5713.1 223.96,54.44 224.26,54.74 225.82,54.74 226.45,54.11 226.75,54.11 226.91,54.26 226.91,56.8 226.3,57.41 226.3,59.85 226.85,60.41 227.69,60.41 228.02,60.08 228.02,59.78 v2(228.25,59.55)
USBP1-: length 139.3
  IN1 w0.114: v2(134.93,103.74) 134.83,103.74 134.76,103.66 134.76,102.67 135.87,101.55 137.42,101.55 138.92,100.06 142.22,100.06 142.83,100.67 143.34,100.67 145.27,102.6 147.48,102.6 149.97,105.09 156.91,105.09 158.03,103.97 159.2,103.97 162.21,100.95 162.21,100.44 162.72,99.93 162.72,99.64 163.41,98.95 166.71,98.95 167.28,99.52 170.95,99.52 171.15,99.32 182.08,99.32 190.21,91.19 190.88,91.19 192.31,89.76 192.31,84.96 191.82,84.47 191.82,83.66 191.63,83.47 191.63,80.67 193.04,79.25 193.04,75.81 193.91,74.93 193.91,73.21 195.84,71.28 196.09,71.28 196.47,70.9 196.47,68.89 196.74,68.62 196.74,66.87 201.5,62.1 203.02,62.1 205.14,59.98 206.59,59.98 209.1,57.48 210.86,57.48 211.86,56.48 213.04,56.48 215.55,53.97 215.55,51.39 215.81,51.13 215.81,50.43 216.21,50.02 216.62,50.02 216.76,50.16 v2(216.76,50.34)
  BOTTOM w0.079: v2(134.93,103.74) 134.83,103.64 134.73,103.64 134.52,103.84 134.42,103.84 134.25,104.02 133.85,104.02 132.99,103.16 132.99,102.55 133.14,102.4 133.14,102.14 133.13,102.09 133.09,102.01 133.08,101.79 133.13,101.66 133.15,101.54 133.15,101.53 133.13,101.43 133.04,101.26 133.01,100.96 U400.CE3
  BOTTOM w0.097: R5700.1 220.93,53.68 220.82,53.78 L5701.3 220.32,53.78 220.26,53.84 220.26,54.09 220.2,54.16 220,54.16 219.72,53.88 219.72,52.85 219.44,52.57 219.13,52.57 219.02,52.57 218.89,52.43 v2(218.89,52.03) 218.88,52.03 218.38,52.53 218.23,52.53 218.07,52.37 217.3,52.37 217.27,52.41 216.89,52.41 215.91,51.43 215.91,50.32 216.24,49.99 216.67,49.99 216.76,50.08 v2(216.76,50.34)
USBP1-_C: length 24.3
  IN2 w0.114: CN5701.2 228.04,51.15 227.82,51.37 227.37,51.37 226.88,51.85 226.88,58.49 227.42,59.03 227.73,59.03 227.8,59.1 227.8,59.34 v2(227.59,59.55)
  BOTTOM w0.097: v2(227.59,59.55) 227.82,59.78 227.82,60 227.61,60.21 226.94,60.21 226.5,59.77 226.5,57.49 227.1,56.88 227.1,54.18 226.68,53.75 226.68,53.65 226.25,53.22 225.71,53.22 225.23,53.7 224.24,53.7 223.96,53.99 C5713.2 222.98,53.99 222.77,53.78 L5701.4 222.52,53.78 222.42,53.68 R5700.2
USBP2+: length 102.2
  TOP w0.097: U6100.23 193.71,108.53 193.99,108.25 193.99,105.45 190.84,102.29 184.87,102.29 183.29,103.87 182.15,103.87 178.49,107.52 177.58,107.52 175.53,109.58 175.08,109.58 174.39,110.26 173.82,110.26 170.84,113.24 169.22,113.24 165.98,116.48 164.6,116.48 159.88,121.21 159.88,123.16 157.96,125.08 148.08,125.08 142.96,119.96 132.7,119.96 131.02,118.29 130.46,118.29 130.06,117.89 130.06,117.46 v2(129.85,117.25)
  BOTTOM w0.079: U400.CC2 131.48,101.83 131.48,102.44 131.83,102.8 131.83,103.25 131.79,103.29 131.79,104.57 132.63,105.41 132.63,107.49 131.63,108.49 131.61,108.49 131.59,108.51
  BOTTOM w0.097: v2(129.85,117.25) 130.06,117.04 130.06,115.98 130.84,115.2 130.84,113.76 130.3,113.22 130.3,112.12 131.24,111.18 131.24,108.86 131.59,108.51
USBP2-: length 102.2
  TOP w0.097: U6100.24 192.78,109.03 192.85,108.97 192.85,108.79 192.91,108.73 193.8,108.73 194.19,108.34 194.19,105.36 190.92,102.09 184.79,102.09 183.21,103.67 182.07,103.67 178.41,107.33 177.5,107.33 175.45,109.38 174.99,109.38 174.31,110.06 173.74,110.06 170.76,113.04 169.14,113.04 165.89,116.29 164.52,116.29 159.68,121.13 159.68,123.08 157.88,124.88 148.16,124.88 143.04,119.77 132.78,119.77 131.1,118.09 130.54,118.09 130.25,117.81 130.25,117.31 130.31,117.25 v2(130.51,117.25)
  BOTTOM w0.079: U400.CC1 131.75,102.48 132,102.73 132,103.32 131.96,103.36 131.96,104.5 132.8,105.34 132.8,107.56 131.75,108.61 131.75,108.63 131.73,108.65
  BOTTOM w0.097: 131.73,108.65 131.44,108.94 131.44,111.27 130.5,112.2 130.5,113.14 131.04,113.67 131.04,115.29 130.26,116.06 130.26,117.2 130.31,117.25 v2(130.51,117.25)
USBP3+_TS: length 249.3
  TOP w0.097: R7634.2 38.8,28.16 39,28.36 39,28.57 38.92,28.66 38.12,28.66 v2(37.77,28.31)
  IN2 w0.114: v2(37.77,28.31) 38.03,28.57 38.38,28.57 38.64,28.83 38.64,32.24 37.67,33.21 37.67,43.84 37.42,44.08 37.42,48.68 37.82,49.07 37.82,62.55 39.53,64.26 39.53,66.07 39.09,66.52 39.09,72.49 36.74,74.83 36.74,74.83 36.4,75.18 34.65,75.18 32.32,77.51 32.32,81.34 21.85,91.8 21.85,101.83 16.76,106.92 16.76,114.49 18.08,115.8 21.1,115.8 26.61,121.32 33.36,121.32 33.74,120.93 35.26,120.93 35.87,121.54 35.87,121.95 39.14,125.21 45.22,125.21 45.38,125.05 48.39,125.05 48.62,125.28 59.69,125.28 60.18,125.77 63.81,125.77 64.25,126.21 66.97,126.21 67.41,125.77 70.47,125.77 71.77,124.47 73.24,124.47 73.93,123.78 77.35,123.78 77.58,123.56 82.64,123.56 85.8,120.4 88.28,120.4 90.95,117.73 93.22,117.73 93.51,118.02 93.51,118.37 v2(93.74,118.6)
  BOTTOM w0.079: U400.CG4 133.94,100.65 133.92,101.09 133.78,101.37 133.75,101.48 133.75,101.67 133.79,101.75 133.79,101.96 133.78,102.04 133.77,102.05 133.77,102.1 133.75,102.23 133.75,102.23 133.75,102.4 134.34,102.99 134.77,102.99 135.36,103.59 135.36,104.9 134.74,105.52 134.74,108.26 134.48,108.52 134.46,108.52 134.44,108.53
  BOTTOM w0.097: 134.44,108.53 133.27,109.71 133.27,112.89 132.87,113.29 132.87,116.05 132.48,116.43 132.48,118.54 131.71,119.31 126.48,119.31 124.82,117.66 111.79,117.66 111.48,117.97 108.3,117.97 106.75,119.52 93.95,119.52 93.45,119.02 93.45,118.88 v2(93.74,118.6)
USBP3+_TS_C: length 2
  TOP w0.097: CN7603.9 39.2,26.22 39.35,26.37 39.35,26.45 39.05,26.75 39.05,27.16 38.83,27.38 R7634.1
USBP3-_TS: length 249.3
  TOP w0.097: R7635.2 39.42,28.16 39.2,28.38 39.2,28.66 39,28.86 37.97,28.86 v2(37.77,29.06)
  IN2 w0.114: v2(92.97,118.6) 93.28,118.3 93.28,118.12 93.12,117.96 91.04,117.96 88.38,120.63 85.89,120.63 82.74,123.78 77.67,123.78 77.45,124.01 74.02,124.01 73.34,124.7 71.87,124.7 70.57,126 67.51,126 67.07,126.44 64.16,126.44 63.72,126 60.08,126 59.59,125.51 48.52,125.51 48.29,125.28 45.47,125.28 45.32,125.44 39.04,125.44 35.64,122.04 35.64,121.64 35.17,121.16 33.83,121.16 33.45,121.54 26.52,121.54 21,116.03 17.98,116.03 16.53,114.58 16.53,106.83 21.62,101.74 21.62,91.71 32.09,81.24 32.09,77.42 34.56,74.95 36.31,74.95 36.65,74.61 38.86,72.39 38.86,66.42 39.3,65.98 39.3,64.36 37.59,62.64 37.59,49.17 37.19,48.77 37.19,43.99 37.44,43.74 37.44,33.12 38.41,32.14 38.41,28.93 38.28,28.8 38.03,28.8 v2(37.77,29.06)
  BOTTOM w0.079: 134.58,108.67 134.6,108.66 134.6,108.64 134.91,108.33 134.91,105.59 135.53,104.97 135.53,103.52 134.84,102.82 134.41,102.82 133.92,102.33 133.92,102.25 133.94,102.12 133.94,102.11 133.94,102.08 133.96,101.97 133.96,101.7 133.91,101.62 133.91,101.51 133.94,101.43 U400.CG3
  BOTTOM w0.097: 134.58,108.67 133.47,109.79 133.47,112.97 133.06,113.37 133.06,116.13 132.68,116.51 132.68,118.63 131.8,119.51 126.39,119.51 124.74,117.86 111.87,117.86 111.56,118.17 108.38,118.17 106.83,119.72 93.87,119.72 93.26,119.1 93.26,118.88 v2(92.97,118.6)
USBP3-_TS_C: length 2
  TOP w0.097: R7635.1 39.53,27.38 39.25,27.1 39.25,26.83 39.55,26.53 39.55,26.38 39.7,26.23 CN7603.10
USBP4+: length 156.7
  TOP w0.097: L7600.3 11.44,109.03 11.72,109.31 12.11,109.31 v2(12.31,109.1)
  IN2 w0.114: v2(12.31,109.1) 12.42,109.2 12.98,109.2 13.9,110.12 13.9,112.55 17.81,116.45 20.45,116.45 22.94,118.95 22.94,120.68 25.38,123.11 27.04,123.11 27.37,122.78 30.08,122.78 31.16,123.87 33.68,123.87 34.29,124.48 34.98,124.48 36.36,125.86 42.9,125.86 43.87,126.83 47.18,126.83 48,126.01 59.33,126.01 60.18,126.87 71.01,126.87 72.76,125.12 73.66,125.12 74.18,125.63 77.32,125.63 78.75,124.2 82.91,124.2 85.49,121.63 87.97,121.63 90.07,119.53 94.97,119.53 95.31,119.19 95.31,118.9 v2(95.03,118.62)
  BOTTOM w0.079: 132.56,108.51 132.57,108.49 132.59,108.49 133.18,107.9 133.18,105.26 132.22,104.3 132.22,102.14 132.06,101.98 132.06,100.83 U400.CD4
  BOTTOM w0.097: 132.56,108.51 131.92,109.15 131.92,111.46 130.98,112.4 130.98,112.94 131.51,113.48 131.51,115.48 131.13,115.87 131.13,117.7 130.87,117.96 127.04,117.96 125.37,116.29 111.24,116.29 110.92,116.62 107.74,116.62 106.89,117.47 99.22,117.47 98.81,117.06 97,117.06 96.5,117.56 95.63,117.56 95.31,117.88 95.31,118.34 v2(95.03,118.62)
USBP4+_C: length 3.5
  TOP w0.097: CN7600.14 7.69,107.84 7.85,107.99 8.22,107.99 8.51,108.28 8.51,109.24 8.63,109.36 8.79,109.36 9.12,109.03 L7600.4
USBP4-: length 156.8
  TOP w0.097: v2(12.31,109.86) 12.31,109.64 12.18,109.5 11.95,109.5 11.62,109.83 L7600.2
  IN2 w0.114: v2(12.31,109.86) 12.31,109.7 12.58,109.43 12.89,109.43 13.67,110.22 13.67,112.64 17.71,116.68 20.35,116.68 22.72,119.04 22.72,120.78 25.28,123.34 27.14,123.34 27.47,123.01 29.98,123.01 31.07,124.1 33.58,124.1 34.19,124.71 34.89,124.71 36.27,126.08 42.81,126.08 43.78,127.06 47.28,127.06 48.09,126.24 59.23,126.24 60.08,127.09 71.11,127.09 72.86,125.34 73.57,125.34 74.08,125.86 77.42,125.86 78.85,124.43 83.01,124.43 85.58,121.86 88.07,121.86 90.17,119.75 95.07,119.75 95.54,119.28 95.54,118.88 v2(95.79,118.62)
  BOTTOM w0.079: 132.7,108.65 132.71,108.63 132.71,108.61 133.35,107.97 133.35,105.19 132.38,104.23 132.38,102.07 132.23,101.91 132.23,101.32 U400.CD3
  BOTTOM w0.097: 132.7,108.65 132.11,109.23 132.11,111.55 131.18,112.48 131.18,112.86 131.71,113.39 131.71,115.57 131.33,115.95 131.33,117.79 130.96,118.16 126.95,118.16 125.29,116.49 111.32,116.49 111,116.81 107.82,116.81 106.97,117.66 99.14,117.66 98.73,117.25 97.08,117.25 96.58,117.76 95.72,117.76 95.51,117.96 95.51,118.34 v2(95.79,118.62)
USBP4-_C: length 3.5
  TOP w0.097: CN7600.13 7.73,108.34 7.88,108.19 8.14,108.19 8.31,108.36 8.31,109.33 8.54,109.56 8.8,109.56 9.07,109.83 L7600.1
USBP5+: length 145.5
  TOP w0.097: R5703.1 220.83,32.42 L5700.2 219.99,32.42 219.24,33.18 218.17,33.18 218.1,33.11 217.85,33.11 v2(217.64,32.9)
  IN1 w0.079: v1(134.44,98.68) 134.25,98.87 134.14,98.87 133.93,99.09 133.93,100.18 134.53,100.78 136.78,100.78 138.84,98.72 139.64,98.72 139.67,98.76 139.69,98.76
  IN1 w0.114: v2(217.64,32.9) 217.82,33.08 218.01,33.08 218.35,33.41 218.35,35 216.33,37.02 216.33,44.69 215.35,45.67 215.35,46.2 213.23,48.31 213.23,51.33 213.21,51.35 213.21,54.44 212.35,55.3 211.92,55.3 210.39,56.83 208.83,56.83 206.32,59.33 204.87,59.33 202.75,61.46 200.8,61.46 199.57,62.69 199.57,62.97 196.09,66.44 196.09,68.27 194.83,69.54 194.83,71.26 193.2,72.89 193.2,74.73 191.83,76.1 191.83,78.18 191.37,78.64 191.37,79.81 190.94,80.24 190.94,83.7 191.17,83.93 191.17,87.36 191.45,87.64 191.45,89.54 190.56,90.43 190.01,90.43 181.78,98.66 172.8,98.66 172.63,98.48 169.48,98.48 168.94,97.95 163.07,97.95 161.21,99.81 158.84,99.81 158.68,99.97 158.63,99.97 154.42,104.18 150,104.18 147.33,101.51 147.33,101.13 146.78,100.58 145.35,100.58 144.15,99.38 142.61,99.38 141.99,98.76 139.69,98.76
  BOTTOM w0.079: U400.CG6 134.26,98.86 v1(134.44,98.68)
USBP5+_C: length 16.1
  TOP w0.097: R5703.2 221.79,32.42 L5700.1 222.49,32.42 222.59,32.53 222.59,32.74 222.67,32.82 222.94,32.82 223.17,33.05 223.17,34.47 223.28,34.58 223.37,34.58 223.52,34.43 C5705.1 224.05,34.14 225.1,34.14 225.64,34.68 225.77,34.68 227.05,35.96 227.05,36.47 227.29,36.71 227.29,36.97 v2(227.52,37.2)
  IN2 w0.114: CN5700.3 228.04,32.69 227.87,32.52 227.76,32.52 227.03,33.25 227.03,33.72 227.26,33.95 227.26,35.53 227.04,35.75 227.04,36.29 227.31,36.55 227.31,36.98 v2(227.52,37.2)
USBP5-: length 145.5
  TOP w0.097: R5702.1 220.78,33.22 L5700.3 220.21,33.22 219.89,32.91 219.78,32.91 219.32,33.37 218.09,33.37 218.02,33.3 217.69,33.3 217.54,33.45 217.54,33.56 v2(217.64,33.66)
  IN1 w0.079: 139.69,98.53 139.67,98.53 139.64,98.56 138.77,98.56 136.71,100.61 134.6,100.61 134.09,100.11 134.09,99.16 134.21,99.04 134.45,99.04 134.53,99.12 v1(134.53,99.26)
  IN1 w0.114: 139.69,98.53 142.08,98.53 142.71,99.15 144.24,99.15 145.44,100.36 146.87,100.36 147.56,101.04 147.56,101.42 150.09,103.95 154.32,103.95 158.54,99.74 158.58,99.74 158.74,99.58 161.11,99.58 162.97,97.72 169.04,97.72 169.57,98.25 172.72,98.25 172.9,98.43 181.68,98.43 189.91,90.2 190.46,90.2 191.22,89.45 191.22,87.74 190.94,87.46 190.94,84.02 190.71,83.79 190.71,80.14 191.14,79.71 191.14,78.55 191.6,78.08 191.6,76.01 192.97,74.64 192.97,72.79 194.6,71.17 194.6,69.44 195.86,68.18 195.86,66.35 199.34,62.87 199.34,62.6 200.71,61.23 202.65,61.23 204.78,59.1 206.23,59.1 208.73,56.6 210.3,56.6 211.83,55.07 212.25,55.07 212.98,54.34 212.98,51.26 213,51.24 213,48.22 215.12,46.1 215.12,45.58 216.1,44.59 216.1,36.92 218.12,34.9 218.12,33.51 217.91,33.3 217.76,33.3 217.59,33.48 217.59,33.61 v2(217.64,33.66)
  BOTTOM w0.079: U400.CG5 134,99.26 134.22,99.04 134.42,99.04 134.53,99.14 v1(134.53,99.26)
USBP5-_C: length 16.1
  TOP w0.097: R5702.2 222.01,33.36 222.14,33.22 L5700.4 222.44,33.22 222.64,33.02 222.86,33.02 222.97,33.13 222.97,34.55 223.2,34.78 223.43,34.78 223.52,34.88 C5705.2 224.07,35.18 225.23,35.18 225.53,34.88 225.69,34.88 226.85,36.04 226.85,36.56 227.09,36.8 227.09,37.12 227.02,37.2 v2(226.76,37.2)
  IN2 w0.114: v2(226.76,37.2) 226.97,37.2 227.08,37.09 227.08,36.64 226.81,36.38 226.81,35.66 227.03,35.44 227.03,34.04 226.8,33.81 226.8,33.15 227.67,32.29 227.87,32.29 228.04,32.12 CN5700.2
USBP6+: length 141.7
  TOP w0.097: R3409.2 28.02,128.79 28.02,128.32 27.74,128.04 27.74,127.88 v2(27.88,127.74)
  IN2 w0.114: v2(27.88,127.74) 27.75,127.6 27.75,125.15 28.81,124.09 29.42,124.09 30.07,124.74 33.26,124.74 33.87,125.35 34.62,125.35 36.04,126.77 42.46,126.77 43.4,127.7 48.07,127.7 48.86,126.91 58.85,126.91 59.86,127.93 71.27,127.93 72.66,126.54 74.04,126.54 74.08,126.58 77.84,126.58 79.33,125.08 83.28,125.08 85.85,122.5 88.33,122.5 90.44,120.4 98.1,120.4 99.47,119.03 99.47,118.14 98.81,117.48 97.4,117.48 97.06,117.82 v2(97.06,118.62)
  BOTTOM w0.079: 133.49,108.53 133.5,108.52 133.52,108.52 133.72,108.32 133.72,105.17 132.6,104.04 132.6,102.09 132.88,101.8 U400.CE2
  BOTTOM w0.097: v2(97.06,118.62) 97.06,117.96 97.28,117.73 98.53,117.73 98.66,117.86 98.66,117.86 98.97,118.17 107.14,118.17 108.02,117.29 111.2,117.29 111.52,116.97 125.1,116.97 126.76,118.63 131.18,118.63 131.8,118.01 131.8,116.15 132.19,115.77 132.19,113.01 132.59,112.61 132.59,109.43 133.49,108.53
USBP6+_C: length 3.5
  TOP w0.097: v2(28,131.27) 27.82,131.27 27.71,131.16 27.71,130.9 28.02,130.59 28.02,129.79 R3409.1
  BOTTOM w0.097: v2(28,131.27) 27.8,131.27 27.65,131.42 CN3400.32
USBP6-: length 141.6
  TOP w0.097: R3408.2 27.22,128.79 27.22,128.22 27.29,128.15 27.44,128.15 27.54,128.05 27.54,127.95 27.33,127.74 v2(26.98,127.74)
  IN2 w0.114: v2(97.82,118.62) 97.66,118.62 97.29,118.25 97.29,117.91 97.49,117.71 98.72,117.71 99.25,118.24 99.25,118.93 98.01,120.17 90.34,120.17 88.24,122.27 85.76,122.27 83.18,124.85 79.24,124.85 77.74,126.35 74.17,126.35 74.13,126.31 72.57,126.31 71.18,127.7 59.96,127.7 58.95,126.69 48.77,126.69 47.98,127.48 43.49,127.48 42.56,126.54 36.13,126.54 34.72,125.13 33.96,125.13 33.35,124.52 30.17,124.52 29.51,123.86 28.71,123.86 27.52,125.06 27.52,127.52 27.3,127.74 v2(26.98,127.74)
  BOTTOM w0.079: U400.CE1 132.76,102.32 132.76,103.97 133.89,105.1 133.89,108.39 133.64,108.64 133.64,108.66 133.63,108.67
  BOTTOM w0.097: v2(97.82,118.62) 97.67,118.62 97.26,118.21 97.26,118.04 97.37,117.93 98.45,117.93 98.46,117.94 98.88,118.36 107.22,118.36 108.1,117.49 111.28,117.49 111.6,117.17 125.02,117.17 126.67,118.83 131.26,118.83 132,118.09 132,116.23 132.39,115.85 132.39,113.09 132.79,112.69 132.79,109.51 133.63,108.67
USBP6-_C: length 3.5
  TOP w0.097: R3408.1 27.22,129.79 27.22,130.62 27.51,130.91 27.51,131.16 27.4,131.27 v2(27.22,131.27)
  BOTTOM w0.097: v2(27.22,131.27) 27.34,131.27 27.45,131.39 27.45,131.57 27.15,131.87 CN3400.33
USBP7+: length 74.8
  IN1 w0.079: 132.14,103.26 132.14,103.24 132.17,103.21 132.17,102.74 131.66,102.23 131.66,100.16 131.84,99.98 131.84,99.86 v1(131.68,99.7)
  IN1 w0.114: v2(164.65,100.77) 164.42,101 164.42,101.38 164.09,101.71 163.53,101.71 157.55,107.69 155.7,107.69 154.78,108.61 144.49,108.61 141.08,105.2 133.9,105.2 132.14,103.44 132.14,103.26
  BOTTOM w0.079: U400.CC4 131.75,99.77 v1(131.68,99.7)
  BOTTOM w0.097: v2(164.65,100.77) 164.5,100.62 164.5,100.46 164.8,100.15 164.8,95.84 166,94.65 166,94.32 v2(166.51,93.81) 166.1,93.81 165.97,93.67 165.97,93.35 165.74,93.13 165.74,92.81 166.64,91.91 166.64,89.5 165.14,88 165.14,85 164.19,84.04 162.48,84.04 162.04,84.48 162.04,84.99 161.78,85.25 158.94,85.25 157.41,83.72 157.41,80.88 157.49,80.8 157.64,80.8 157.89,81.05 158.14,81.05 158.22,81.13 R4109.2
USBP7+_C: length 4.4
  BOTTOM w0.097: CN4100.3 161.2,82.12 161.43,81.89 161.43,81.7 161.2,81.47 161.2,81.11 160.71,80.62 160.54,80.62 160.43,80.73 160.43,81.01 160.39,81.05 159.84,81.05 159.75,81.13 R4109.1
USBP7-: length 74.8
  IN1 w0.079: v1(132.24,100.06) 132,100.06 131.83,100.23 131.83,102.16 132.34,102.67 132.34,103.21 132.37,103.24 132.37,103.26
  IN1 w0.114: 132.37,103.26 132.37,103.34 134,104.97 141.17,104.97 144.58,108.38 154.68,108.38 155.6,107.46 157.46,107.46 163.44,101.48 164,101.48 164.19,101.28 164.19,101.06 v2(163.9,100.77)
  BOTTOM w0.079: v1(132.24,100.06) 132.11,100.19 132.11,100.36 131.75,100.72 U400.CC3
  BOTTOM w0.097: v2(163.9,100.77) 164.61,100.07 164.61,95.76 165.8,94.56 165.8,94.37 v2(165.24,93.81) 165.63,93.81 165.77,93.67 165.77,93.44 165.54,93.21 165.54,92.73 166.44,91.83 166.44,89.59 164.94,88.09 164.94,85.08 164.1,84.24 162.56,84.24 162.24,84.56 162.24,85.07 161.86,85.45 158.86,85.45 157.21,83.8 157.21,80.8 157.41,80.6 157.53,80.6 157.89,80.25 158.14,80.25 158.22,80.17 R4110.2
USBP7-_C: length 4.4
  BOTTOM w0.097: R4110.1 159.75,80.17 159.84,80.25 160.31,80.25 160.49,80.43 160.8,80.43 161.4,81.03 161.4,81.39 161.63,81.62 161.63,82.07 161.7,82.14 CN4100.5
USBP8+: length 190.1
  IN1 w0.079: v1(134.53,96.61) 134.53,96.74 134.61,96.83 134.83,96.83 135.01,97.01 135.01,98.42 135.05,98.46 135.05,99.46 135.04,99.47 135.04,99.93 135.17,100.07 136.39,100.07 138.63,97.83 139.81,97.83 139.84,97.8 139.86,97.8
  IN1 w0.114: 139.86,97.8 143.93,97.8 145.55,99.42 148.17,99.42 148.87,100.12 148.87,101.73 150.34,103.21 154.16,103.21 158.27,99.09 158.32,99.09 158.77,98.63 159.86,98.63 160.12,98.37 161.27,98.37 161.56,98.08 162.63,97.01 169.24,97.01 169.83,97.59 173.69,97.59 173.86,97.77 181.43,97.77 189.52,89.68 189.52,86.38 190.08,85.82 190.08,84.17 189.57,83.67 189.57,80.08 190.36,79.29 190.36,72.61 191.01,71.95 191.72,71.95 193.63,70.03 193.63,68.86 193,68.22 193,66.2 193.82,65.38 195.91,65.38 198.6,62.69 198.6,60.97 198.99,60.58 202.38,60.58 204.59,58.37 205.24,58.37 206.08,57.54 206.27,57.54 207.86,55.95 209.92,55.95 211.21,54.66 211.21,53.66 211.72,53.16 211.72,47.99 212.47,47.23 213.08,47.23 214.33,45.97 214.33,45.29 215.37,44.25 215.37,36.51 216.86,35.02 216.86,31.83 217.24,31.45 217.24,28.96 213.41,25.13 211.06,25.13 209.24,23.31 208.33,23.31 207.37,22.35 207.37,21.46 205.88,19.97 204.42,19.97 200.01,15.56 200.01,13.52 197.97,11.48 196.83,11.48 196.58,11.23 196.58,10.77 196.44,10.63 v2(196.23,10.63)
  BOTTOM w0.079: U400.CG9 134.12,96.79 134.12,96.68 134.19,96.61 v1(134.53,96.61)
  BOTTOM w0.097: R5206.2 187.5,10.7 L5200.2 188.04,10.17 188.46,10.17 189.1,9.53 190.86,9.53 191.27,9.12 192.76,9.12 194.75,11.11 196.47,11.11 196.58,11 196.58,10.75 196.46,10.63 v2(196.23,10.63)
USBP8+_C: length 8.7
  BOTTOM w0.097: CN5201.4 180.45,13.62 180.55,13.52 180.55,13.28 180.74,13.08 183.88,13.08 184.49,13.7 184.75,13.7 C5208.2 185.07,12.98 185.93,12.12 186.08,12.12 L5200.1 186.83,11.37 R5206.1
USBP8-: length 190.1
  IN1 w0.079: v1(134.48,97.19) 134.67,97 134.76,97 134.84,97.08 134.84,98.49 134.88,98.53 134.88,99.39 134.87,99.4 134.87,100 135.1,100.23 136.46,100.23 138.7,98 139.81,98 139.84,98.03 139.86,98.03
  IN1 w0.114: 139.86,98.03 143.84,98.03 145.45,99.65 148.07,99.65 148.64,100.21 148.64,101.83 150.25,103.43 154.25,103.43 158.37,99.32 158.41,99.32 158.87,98.86 159.95,98.86 160.22,98.6 161.37,98.6 161.79,98.17 162.73,97.24 169.15,97.24 169.73,97.82 173.59,97.82 173.77,98 181.52,98 189.75,89.77 189.75,86.47 190.31,85.92 190.31,84.08 189.8,83.57 189.8,80.18 190.58,79.39 190.58,72.7 191.11,72.18 191.81,72.18 193.86,70.13 193.86,68.76 193.23,68.13 193.23,66.3 193.92,65.61 196.01,65.61 198.83,62.79 198.83,61.07 199.09,60.81 202.48,60.81 204.68,58.6 205.34,58.6 206.17,57.76 206.37,57.76 207.95,56.18 210.02,56.18 211.44,54.76 211.44,53.76 211.95,53.25 211.95,48.08 212.57,47.46 213.17,47.46 214.56,46.07 214.56,45.39 215.6,44.35 215.6,36.6 217.09,35.11 217.09,31.92 217.47,31.55 217.47,28.86 213.5,24.9 211.15,24.9 209.33,23.08 208.42,23.08 207.6,22.26 207.6,21.37 205.98,19.74 204.52,19.74 200.24,15.46 200.24,13.42 198.06,11.25 196.92,11.25 196.81,11.14 196.81,10.81 v2(196.99,10.63)
  BOTTOM w0.079: v1(134.48,97.19) 134.37,97.19 U400.CG8
  BOTTOM w0.097: R5205.2 188.07,11.27 L5200.3 188.63,10.71 188.63,10.28 189.18,9.73 190.95,9.73 191.35,9.32 192.68,9.32 194.67,11.31 196.55,11.31 196.78,11.09 196.78,10.84 v2(196.99,10.63)
USBP8-_C: length 8.7
  BOTTOM w0.097: 187.51,11.94 187.39,11.94 L5200.4 186.62,12.71 186.62,12.86 185.79,13.7 C5208.1 185.19,13.9 184.41,13.9 183.8,13.28 180.82,13.28 180.75,13.36 180.75,13.49 180.95,13.69 CN5201.3
USBP10+_WWAN: length 104.1
  TOP w0.079: v1(135.41,99.13) 135.11,98.83 135.11,98.47 134.79,98.16 133.9,98.16 133.66,98.39 133.33,98.39 132.89,97.96 132.4,97.96 132.07,98.28 132.07,99.39 132.62,99.93 132.62,100.21 132.44,100.39 132.42,100.39 132.41,100.4
  TOP w0.097: 132.41,100.4 132.19,100.62 132.19,101.73 133.1,102.64 134.7,102.64 135.39,103.33 135.39,104.01 137,105.62 139.89,105.62 140.32,106.05 140.32,106.41 140.32,108.84 140.09,109.07 140.09,110.61 143.7,114.22 147.97,114.22 156.91,105.28 165.06,105.28 165.57,104.78 166.66,104.78 170.26,101.18 171.72,101.18 172.3,100.6 172.3,99.06 174.88,96.47 176.46,96.47 178.39,94.55 184.05,94.55 187.81,90.8 187.81,86.7 187.32,86.21 187.13,86.21 186.42,85.49 186.42,84.31 184.64,82.52 184.64,77.68 185.57,76.75 185.87,76.75 186.04,76.91 v2(186.04,77.28) 186.57,76.75 187,76.75 187.74,76 188.19,76 188.36,76.18 L4200.1 189.05,76.38 R4247.2
  BOTTOM w0.079: v1(135.41,99.13) 135.2,99.13 U400.CH6
USBP10+_WWAN_C: length 6.9
  TOP w0.097: v2(191.12,74.3) 190.88,74.07 190.59,74.07 190.54,74.12 190.54,74.49 191.21,75.16 191.21,75.71 190.92,76 190.75,76 190.57,76.18 L4200.2 190.06,76.18 R4247.1
  BOTTOM w0.097: CN4200.7 189.95,73.27 190.1,73.42 190.1,73.79 190.38,74.07 190.88,74.07 v2(191.12,74.3)
USBP10-_WWAN: length 104
  TOP w0.079: 132.55,100.54 132.56,100.53 132.56,100.51 132.79,100.28 132.79,99.87 132.24,99.32 132.24,98.35 132.47,98.13 132.82,98.13 133.26,98.56 133.73,98.56 133.97,98.32 134.72,98.32 134.94,98.54 134.94,98.92 134.99,98.97 134.99,99.23 135.4,99.63 v1(135.4,99.71)
  TOP w0.097: R4248.2 189.05,75.42 L4200.4 188.36,75.63 188.19,75.8 187.66,75.8 186.91,76.55 186.58,76.55 v2(186.04,76.01) 186.04,76.38 185.87,76.55 185.49,76.55 184.44,77.6 184.44,82.61 186.22,84.39 186.22,85.57 187.05,86.4 187.23,86.4 187.61,86.78 187.61,90.71 183.97,94.35 178.31,94.35 176.38,96.28 174.8,96.28 172.1,98.97 172.1,100.51 171.64,100.98 170.18,100.98 166.58,104.58 165.49,104.58 164.98,105.09 156.83,105.09 147.89,114.03 143.78,114.03 140.28,110.53 140.28,109.16 140.51,108.93 140.51,106.49 140.51,105.97 139.97,105.42 137.08,105.42 135.59,103.92 135.59,103.25 134.78,102.44 133.18,102.44 132.39,101.65 132.39,100.7 132.55,100.54
  BOTTOM w0.079: v1(135.4,99.71) 135.4,99.63 135.11,99.34 134.98,99.34 134.93,99.4 U400.CH5
USBP10-_WWAN_C: length 6.9
  TOP w0.097: v2(191.12,73.54) 191.12,73.79 191.04,73.87 190.51,73.87 190.34,74.04 190.34,74.57 191.02,75.24 191.02,75.63 190.84,75.8 190.75,75.8 190.57,75.63 L4200.3 190.06,75.63 R4248.1
  BOTTOM w0.097: v2(191.12,73.54) 191.12,73.74 190.99,73.87 190.46,73.87 190.3,73.71 190.3,73.43 190.45,73.27 CN4200.9
USIM_DETECT: length 53.4
  TOP w0.102: v2(202.22,65.74) 202.6,66.12 202.6,73.26 203.28,73.94 204.73,73.94 205.7,74.91 206.21,74.91 206.7,75.41 206.93,75.41 207.21,75.68 207.21,75.93 206.8,76.33 206.58,76.33 206.25,76 203.28,76 203.14,75.85 202.76,75.85 202.63,75.99 202.63,76.63 202.91,76.91 204.05,76.91 204.2,77.07 205.29,77.07 205.65,77.42 205.65,80.07 v2(204.61,81.11)
  BOTTOM w0.102: R4223.1 218.8,57.59 219.31,58.1 219.31,61.52 218.93,61.91 215.63,61.91 214.74,62.79 213.71,62.79 212.83,63.68 211.57,63.68 210.96,64.29 210.68,64.29 209.71,65.26 209.71,66.09 208.42,67.37 206.75,67.37 R4225.1 205.88,66.84 205.37,67.35 203.55,67.35 202.67,66.48 202.67,66.2 v2(202.22,65.74) ; v2(204.61,81.11) 204.61,80.96 204.7,80.86 CN4200.66
V_ADP_ADC4: length 24.7
  TOP w0.102: v2(194.68,49.23) 194.63,49.28 R4712.2 ; v2(197.12,31.24) 196.71,31.24 196.27,30.79 PR8507.1 PC8502.2 PR8502.1
  IN2 w0.114: v2(197.12,31.24) 197.33,31.45 197.33,33.96 199.07,35.69 199.07,39.57 197.72,40.92 197.72,43.12 196.28,44.56 196.28,45.22 196.25,45.24 196.25,46.18 195.91,46.52 195.68,46.52 195.44,46.76 195.44,47.65 194.68,48.42 v2(194.68,49.23)
V_ADP_ADC4_R: length 12.6
  TOP w0.102: U4701.C2 201.98,50.04 201.47,50.04 201.33,49.89 201.33,48.92 200.98,48.57 199.94,48.57 199.63,48.27 199.2,48.27 198.53,48.93 198.53,49.33 198.41,49.46 197.32,49.46 197.16,49.31 195.37,49.31 v2(195.3,49.24) 195.26,49.24 194.82,49.68 193.65,49.68 R4712.1 C4711.2
VADJ1: length 6.7
  TOP w0.102: v2(40.85,131.38) 40.9,131.33 C3402.1 40.43,130.3 40.43,129 40.19,128.76 40.19,127.07 39.64,126.52 R3405.1
  BOTTOM w0.102: v2(40.85,131.38) 40.65,131.58 CN3400.6
VADPBL: length 48
  TOP w0.127: v2(193.78,96.09) 193.25,95.56 192.19,95.56 PR8245.2 ; v2(209.44,100.56) 208.73,101.28 207.63,101.28 207.43,101.08 207.43,99.35 207.91,98.86 208.75,98.86 209.76,97.85 209.76,94.95 208.75,93.93 208.62,93.93 208.1,93.41 208.1,92.39 207.37,91.67 207.37,90.86 206.87,90.35 204.05,90.35 202.65,88.96 201.53,88.96 201.1,89.39 198.94,89.39 PQ8009.3
  BOTTOM w0.127: v2(193.78,96.09) 195.46,94.42 197.72,94.42 201.28,97.97 208.14,97.97 209.44,99.28 v2(209.44,100.56)
VCONN_5V_P1: length 7.6
  TOP w0.102: C6108.1 181.53,109.33 v2(181.05,109.33)
  TOP w0.254: R6115.2 182.61,108.16 181.9,108.87 C6108.1 C6107.2 183.45,108.52 183.45,108.11 183.74,107.82 184.13,107.82 184.84,108.53 U6100.8
VCORE_CS1: length 16.2
  TOP w0.203: PU8800.4 42.46,103.37 44.05,104.96 PR8813.1
  TOP w0.254: v2(49.84,111.21) 48.34,111.21 48.32,111.18 v2(47.28,111.18) ; PR8813.1 43.91,105.35 43.52,105.74 43.52,107.68 v2(43.44,107.75)
  BOTTOM w0.254: v2(49.84,111.21) 49.85,111.21 50.3,111.66 PR8903.1 ; v2(47.28,111.18) 47.02,111.18 46.74,110.9 46.74,108.31 46.19,107.75 v2(43.44,107.75)
VCORE_CS2: length 23.3
  TOP w0.203: PR8814.2 44.78,105.2 42.86,103.29 PU8800.3
  TOP w0.254: v2(45.68,115.29) 47.02,115.29 50.58,118.85 v2(50.58,118.93) ; PR8814.2 v2(45.07,104.48)
  IN2 w0.254: v2(45.68,115.29) 45.26,115.29 44.86,114.9 44.86,109.71 44.38,109.23 44.38,108.03 45.45,106.96 45.45,104.86 v2(45.07,104.48)
  BOTTOM w0.254: PR8920.1 v2(50.58,118.93)
VCORE_CS_SUM: length 21.8
  TOP w0.102: v2(44.86,106.63) 45.07,106.84 PR8855.1 PR8852.2 PR8813.2 PR8814.1
  TOP w0.203: v2(37.65,100.78) 37.8,100.63 PU8800.17
  IN1 w0.114: v2(44.86,106.63) 44.33,106.1 42.58,106.1 42.32,106.36 42.32,108.18 41.28,109.22 40.32,109.22 37.85,106.75 37.85,105.9 37.65,105.7 v2(37.65,100.78)
VCORE_PE: length 274.5
  TOP w0.102: U4701.G3 204.9,50.36 v3(204.58,50.68) ; v2(49.77,91.99) 49.77,92.03 48.89,92.91 PR8827.1
  IN1 w0.114: v2(49.77,91.99) 49.77,91.29 44.69,86.21 44.69,82.54 44.81,82.42 44.81,77.27 44.36,76.81 44.36,74.65 43.63,73.92 43.63,70.2 44.6,69.22 44.6,66.97 44.08,66.45 44.08,60.1 43.19,59.21 43.19,55.2 42.93,54.95 42.93,50.32 43.54,49.71 43.54,47.46 42.91,46.82 42.91,44.87 43.72,44.06 43.72,38.7 43.89,38.53 43.89,37.37 44.12,37.14 45.3,37.14 48.14,34.3 48.14,31.89 50.13,29.9 51.76,29.9 52.52,30.66 54.08,30.66 54.63,30.11 57.55,30.11 57.63,30.03 60.68,30.03 61.75,31.09 66.68,31.09 67.21,31.62 82.19,31.62 82.59,31.23 87.46,31.23 88.08,31.85 101.48,31.85 102.12,32.49 102.91,32.49 103.15,32.24 113.13,32.24 113.59,31.79 118.75,31.79 120.47,30.07 126.99,30.07 127.9,29.15 128.61,29.15 128.93,28.83 129.62,28.83 130.81,27.64 130.81,22.36 132.03,21.14 133.63,21.14 136.46,18.32 136.46,17.33 138.58,15.22 142.32,15.22 143.35,14.19 153.18,14.19 154.74,12.64 162.7,12.64 163.98,13.92 186.64,13.92 188.91,11.64 190.41,11.64 191.23,12.46 192.58,12.46 192.9,12.78 192.9,13.39 194.61,15.11 195.41,15.11 202.25,21.95 202.25,34.09 204.07,35.91 204.07,44.51 203.94,44.63 203.94,45.83 v2(204.98,46.86)
  IN2 w0.076: v3(204.58,50.68) 204.35,50.45 204.35,49.07 204.64,48.77 204.64,47.2 v2(204.98,46.86)
VCORE_PWM1: length 16.9
  TOP w0.203: v2(45.91,99.8) 45.4,100.31 45.02,100.31 44.94,100.23 PU8800.39
  TOP w0.254: v2(47.23,110.52) 47.86,110.52 48.52,109.86 v2(50.05,109.86)
  IN2 w0.254: v2(47.23,110.52) 47.23,107.32 46.8,106.89 46.8,101.73 45.91,100.84 v2(45.91,99.8)
  BOTTOM w0.254: PR8901.1 50.48,109.86 v2(50.05,109.86)
VCORE_PWM2: length 23.1
  TOP w0.203: PU8800.38 45.19,99.83 v2(45.22,99.8)
  TOP w0.254: v2(45.71,114.63) 47.28,114.63 50.05,117.4 v2(50.58,117.4)
  IN2 w0.254: v2(45.71,114.63) 46.62,113.73 46.62,107.72 46.19,107.29 46.19,101.91 45.22,100.94 v2(45.22,99.8)
  BOTTOM w0.254: PR8916.1 v2(50.58,117.4)
VCORE_VDIFF: length 3.5
  TOP w0.102: PC8815.1 PR8822.1
  TOP w0.203: PC8815.1 43.04,104.65 v2(42.6,104.2) 42.06,103.66 PU8800.5
VCORE_VFB: length 7.8
  TOP w0.102: PR8824.1 42.27,108.95 42.01,108.69 PR8858.2 PR8859.2 ; v2(41.14,107.45) 41.34,107.24 PR8859.2 ; PR8859.2 42.01,106.71 42.27,106.46 PR8822.2 PC8815.2
  TOP w0.203: PU8800.6 41.66,104.13 42.27,104.73 PC8815.2
VCORE_VORTN: length 2.6
  TOP w0.203: PR8829.1 40.52,104.75 40.52,104.1 40.86,103.75 PU8800.8
VCORE_VOSEN: length 2.4
  TOP w0.203: PR8828.1 v2(41.05,104.36) 41.26,104.15 PU8800.7
VGT_VCCSENSE: length 83.9
  TOP w0.102: PR8837.2 PR8835.1 36.56,106.85 v2(36.56,106.71)
  IN1 w0.127: v2(36.56,106.71) 36.56,106.36 36.17,105.97 36.17,100.02 39.69,96.5 47.27,96.5 48.14,95.64 50.33,95.64 52.1,93.87 52.1,90.23 53.32,89.02 64.4,89.02 66.94,91.56 73.47,91.56 81.23,99.32 83.12,99.32 85.25,101.45 91.97,101.45 93.39,102.88 94.7,102.88 v2(95.13,103.3)
  BOTTOM w0.079: v2(95.13,103.3) 95.3,103.13 95.78,103.13 96.07,102.84 96.07,101.96 96.36,101.67 U400.E3
VGT_VSSSENSE: length 83.6
  TOP w0.102: v2(35.57,106.71) 35.57,106.88 PR8841.1 PR8839.2
  IN1 w0.127: v2(94.49,103.31) 93.28,103.31 91.81,101.83 85.1,101.83 82.96,99.7 81.07,99.7 73.31,91.94 66.78,91.94 64.24,89.4 53.48,89.4 52.49,90.39 52.49,94.02 50.49,96.02 48.29,96.02 47.36,96.95 39.78,96.95 36.55,100.18 36.55,105.81 36.99,106.25 36.99,107.02 36.79,107.22 36.08,107.22 v2(35.57,106.71)
  BOTTOM w0.079: v2(94.49,103.31) 95.41,102.39 95.41,101.99 U400.D2
VOL_DOWN#: length 9
  TOP w0.102: R4764.2 201.09,58.06 v2(201.82,58.06) ; v3(205.88,53.93) 206.2,53.61 U4701.J8
  IN1 w0.076: 201.82,57.23 201.82,57.22 203.05,55.99 203.92,55.99 204.35,55.55 204.71,55.55 204.91,55.35 204.91,55.1 205.88,54.13 v3(205.88,53.93)
  IN1 w0.114: 201.82,57.23 v2(201.82,58.06)
VR_SCL_P: length 320.8
  TOP w0.102: v2(45.95,85.27) 45.95,87.05 44.05,88.95 44.05,93.28 PR8805.2 44.05,94.1 44.05,94.51 PR8809.1 ; v3(203.28,51.98) 202.96,51.66 U4701.D5
  IN2 w0.076: v3(203.28,51.98) 202.9,51.61 202.9,51.26 203.3,50.87 203.3,50.16 203.34,50.12 203.34,48.93 203.96,48.3 203.96,47.5 203.88,47.42
  IN2 w0.114: v2(88.38,28.07) 87.35,29.1 81.48,29.1 80.55,30.03 78.84,30.03 76.63,27.82 71.05,27.82 70.5,27.27 v2(70.28,27.27) ; 203.88,47.42 203.88,46.67 204.6,45.95 204.95,45.95 205.84,45.06 205.84,41.35 204.4,39.91 204.4,34.19 202.61,32.39 202.61,19.77 198.86,16.03 198.86,14.36 197.4,12.89 193,12.89 192.58,12.46 192.2,12.46 v2(191.75,12.92) ; v2(141.49,13.44) 141.49,13.47 140.22,14.74 138.97,14.74 137.2,16.51 134.28,16.51 132.44,18.35 132.44,19.02 131.83,19.63 130.63,19.63 130.03,20.23 v2(129.79,20.23)
  BOTTOM w0.102: v2(45.95,85.27) 48.24,85.27 52.81,80.7 52.81,77.15 53.83,76.13 53.83,70.29 54.77,69.35 54.77,56.96 56.14,55.58 56.14,54.77 56.44,54.47 56.44,52.05 54.24,49.84 53.32,49.84 52.94,49.46 52.94,48.19 52.46,47.71 49.66,47.71 48,46.05 48,43.08 46.85,41.93 46.85,40.21 48.07,38.99 48.07,36.2 48.88,35.39 65.11,35.39 68.33,32.17 68.33,29.48 67.67,28.82 67.41,28.82 66.21,27.62 66.21,26.84 66.58,26.47 68.05,26.47 68.86,27.27 v2(70.28,27.27) ; v2(129.79,20.23) 129.47,19.91 129.47,18.63 129.01,18.17 128.54,18.17 125.85,15.47 124.55,15.47 123.9,16.13 123.9,20.6 123.33,21.16 118.72,21.16 115.65,24.24 110.62,24.24 109.73,25.13 108.28,25.13 107.29,26.12 102.68,26.12 101.91,26.89 101.91,28.11 100.96,29.06 99.69,29.06 98.27,27.65 88.81,27.65 v2(88.38,28.07) ; v2(141.49,13.44) 141.49,13.37 141.84,13.01 142.22,13.01 142.83,12.4 143.2,12.4 145.81,9.79 145.81,8.12 146.74,7.19 147.89,7.19 148.82,8.12 150.31,8.12 150.65,7.78 151.4,7.78 152.53,8.9 153.86,8.9 156.95,11.99 156.95,15.3 157.97,16.31 159.75,16.31 160.26,15.8 160.26,14.41 160.13,14.28 160.13,13.65 160.78,13 162.42,13 167.56,18.14 168.19,18.14 168.83,18.78 168.83,22.97 169.51,23.65 170.51,23.65 171.2,24.34 172.73,24.34 173.39,23.68 173.39,23.35 174.39,22.34 174.39,21.12 174.51,21 174.51,20.56 174.71,20.36 174.71,19.84 175.27,19.29 177.54,19.29 178.16,18.67 182.84,18.67 187.94,13.57 191.1,13.57 v2(191.75,12.92)
VR_SDA_P: length 320.3
  TOP w0.076: U4701.D4 v3(203.28,51.34)
  TOP w0.102: v2(45.32,85.24) 45.32,87.4 43.84,88.87 43.84,93.26 PR8806.2 43.85,94.12 43.85,94.48 PR8815.1
  IN2 w0.076: 204.54,46.44 204.2,46.78 204.2,48.28 203.49,48.99 203.49,50.32 203.45,50.36 203.45,51.16 v3(203.28,51.34)
  IN2 w0.114: v2(140.75,13.49) 140.75,13.88 140.12,14.51 138.87,14.51 137.1,16.28 134.18,16.28 132.21,18.26 132.21,18.93 131.73,19.4 130.54,19.4 130.33,19.6 v2(129.9,19.6) ; v2(191.07,12.88) 191.07,12.88 191.72,12.23 192.67,12.23 193.1,12.66 197.5,12.66 199.75,14.92 199.75,15.68 201.46,17.39 201.46,18.16 202.83,19.53 202.83,32.3 204.63,34.1 204.63,39.82 206.07,41.25 206.07,45.21 205.09,46.19 204.79,46.19 204.54,46.44 ; v2(87.72,28.07) 86.92,28.87 81.38,28.87 80.45,29.8 78.94,29.8 76.74,27.6 71.22,27.6 70.36,26.74 v2(69.92,26.74)
  BOTTOM w0.102: v2(69.92,26.74) 69.63,27.03 69.13,27.03 68.37,26.27 66.5,26.27 66.01,26.76 66.01,27.7 67.32,29.02 67.58,29.02 68.13,29.57 68.13,32.09 65.03,35.19 48.79,35.19 47.87,36.11 47.87,38.9 46.65,40.12 46.65,42.01 47.8,43.16 47.8,46.14 49.57,47.91 52.28,47.91 52.74,48.37 52.74,49.56 53.22,50.04 54.15,50.04 56.24,52.13 56.24,54.38 55.94,54.68 55.94,55.5 54.57,56.87 54.57,69.04 53.58,70.03 53.58,76 52.43,77.15 52.43,80.19 47.82,84.81 45.75,84.81 v2(45.32,85.24) ; v2(140.75,13.49) 141.44,12.81 142.13,12.81 142.74,12.2 143.12,12.2 145.61,9.71 145.61,8.04 146.66,6.98 147.97,6.98 148.9,7.91 150.23,7.91 150.57,7.57 151.52,7.57 152.65,8.7 154.17,8.7 157.34,11.87 157.34,15.14 158.31,16.11 159.66,16.11 160.05,15.72 160.05,14.49 159.88,14.31 159.88,13.52 160.6,12.8 162.5,12.8 167.64,17.94 168.28,17.94 169.03,18.7 169.03,22.89 169.59,23.45 170.59,23.45 171.28,24.14 172.64,24.14 173.19,23.59 173.19,23.26 174.19,22.26 174.19,21.03 174.31,20.92 174.31,20.48 174.51,20.27 174.51,19.76 175.18,19.09 177.46,19.09 178.08,18.47 182.76,18.47 187.86,13.37 190.59,13.37 v2(191.07,12.88) ; v2(129.9,19.6) 129.68,19.38 129.68,18.54 129.09,17.96 128.63,17.96 125.94,15.27 124.47,15.27 123.7,16.04 123.7,20.51 123.25,20.96 118.63,20.96 115.56,24.03 110.53,24.03 109.64,24.92 108.2,24.92 107.2,25.91 102.6,25.91 101.71,26.8 101.71,28.03 100.88,28.86 99.77,28.86 98.36,27.44 88.35,27.44 v2(87.72,28.07)
VR_SVID_ALERT#: length 102.7
  TOP w0.102: v2(40.37,94.32) PR8802.2 39.91,94.15 39.91,94.46 PR8820.2
  IN2 w0.127: v2(101.28,114.13) 100.11,114.13 99.67,114.57 94.74,114.57 94.17,115.14 90.02,115.14 87.03,118.13 84.91,118.13 82.11,120.93 77.05,120.93 76.46,121.52 71.53,121.52 70.84,122.22 70.83,122.22 69.51,123.54 61.27,123.54 60.54,122.81 50.45,122.81 48.83,121.2 48.83,98.85 47.95,97.97 46.53,97.97 45.22,96.66 42.71,96.66 v2(40.37,94.32)
  BOTTOM w0.102: v2(101.28,114.13) 102.19,113.21 103.87,113.21 104.81,112.27 104.81,111.65 C546.2 105.33,111.04 105.95,110.42 R611.1 107.45,110.1 107.45,108.42 R612.2
VR_SVID_CLK: length 110.8
  TOP w0.102: PR8823.1 37.91,94.48 37.91,94.12 37.99,94.04 PR8803.2 v2(38.34,94.32)
  IN2 w0.127: v2(38.34,94.32) 38.82,94.8 40.13,94.8 42.5,97.17 45.01,97.17 46.32,98.48 47.74,98.48 48.32,99.07 48.32,121.41 50.23,123.32 60.32,123.32 61.04,124.05 69.72,124.05 71.05,122.73 71.74,122.03 76.67,122.03 77.26,121.44 82.32,121.44 85.12,118.64 87.24,118.64 90.23,115.65 94.38,115.65 94.95,115.08 99.95,115.08 v2(100.21,114.81)
  BOTTOM w0.079: U400.AA1 105.85,102.38 105.85,103.4 106.02,103.57 106.02,106.68 106.16,106.81
  BOTTOM w0.102: v2(100.21,114.81) 100.21,114.51 103.37,111.35 C641.2 104.88,110.5 105.52,110.5 106.08,109.94 106.97,109.94 107.26,109.64 107.26,108.34 R613.2 106.87,107.74 106.16,107.03 106.16,106.81
VR_SVID_DATA: length 108.5
  TOP w0.102: PR8821.1 38.9,94.46 38.9,94.15 PR8801.2 v2(39.35,94.29)
  IN2 w0.127: v2(99.45,114.06) 94.53,114.06 93.96,114.63 89.81,114.63 86.82,117.63 84.7,117.63 81.9,120.43 76.84,120.43 76.25,121.01 71.32,121.01 70.62,121.71 69.3,123.03 61.48,123.03 60.75,122.31 50.66,122.31 49.34,120.99 49.34,98.64 48.16,97.47 46.74,97.47 45.26,95.98 42.75,95.98 40.53,93.76 39.89,93.76 v2(39.35,94.29)
  BOTTOM w0.079: 105.9,106.91 105.9,106.81 105.85,106.76 105.85,103.64 105.66,103.45 105.66,101.92 U400.AA2
  BOTTOM w0.102: 105.9,106.91 R614.2 106.38,108.43 106.38,109.23 105.58,110.03 104.6,110.03 103.95,110.67 103.37,110.67 99.98,114.06 v2(99.45,114.06)
VR_SYNC: length 93.2
  TOP w0.102: v2(86.88,116.06) 88.15,117.33 107.28,117.33 PR9022.1 ; PR8812.2 v2(45.3,95.31)
  IN1 w0.114: v2(50.54,118.05) 50.63,118.05 51.16,118.58 51.16,118.91 53.2,120.95 55.97,120.95 56.76,121.73 62.44,121.73 63.19,122.48 64.55,122.48 64.62,122.55 69.32,122.55 71.14,120.73 75.59,120.73 76.03,120.28 79.16,120.28 82.51,116.93 86.23,116.93 86.88,116.29 v2(86.88,116.06)
  IN2 w0.114: v2(50.54,118.05) 49.84,117.35 49.84,112.19 50.27,111.76 50.27,110.95 v2(49.87,110.55) 50.78,110.55 51.28,110.05 51.28,108.58 50.84,108.14 50.84,102.17 v2(50.55,101.88) 49.84,101.17 49.84,98.44 48.36,96.96 46.95,96.96 v2(45.3,95.31)
  BOTTOM w0.102: PR9007.1 50.56,101.88 v2(50.55,101.88) ; PR8922.1 50.89,118.17 50.77,118.05 v2(50.54,118.05) ; PR8907.1 50.25,110.93 v2(49.87,110.55)
VR_VTEMP: length 92
  TOP w0.102: v2(85.89,116.49) 87.59,118.19 106.31,118.19 107.16,119.04 PR9018.1 ; PR8847.1 49.48,101.23 v2(50.27,100.44)
  IN1 w0.114: v2(50.33,116.11) 51.39,117.17 51.39,118.82 53.3,120.72 56.07,120.72 56.85,121.51 62.53,121.51 63.28,122.25 64.82,122.25 64.86,122.29 69.25,122.29 71.04,120.5 75.47,120.5 75.92,120.05 78.8,120.05 82.15,116.71 85.67,116.71 v2(85.89,116.49)
  IN2 w0.114: v2(50.33,116.11) 51.09,116.11 51.82,115.37 51.82,114.03 51.22,113.42 51.22,110.65 51.81,110.06 51.81,107.62 v2(51.79,107.6) 51.79,107.6 51.74,107.6 51.07,106.93 51.07,101 50.5,100.44 v2(50.28,100.44)
  BOTTOM w0.102: v2(51.79,107.6) 51.87,107.53 PR8906.1 ; v2(50.28,100.44) 50.28,99.4 50.91,98.76 PR9003.1 ; v2(50.33,116.11) 50.39,116.16 51.95,116.16 52.71,115.4 PR8921.1
VRAVDDQ_FB: length 23.8
  TOP w0.102: v2(149.86,9.95) 151.01,9.95 151.52,9.45 151.52,8.72 151.73,8.51 153.05,8.51 153.82,7.75 153.82,7.39 154.54,6.66 156.89,6.66 157.34,7.11 162,7.11 162.35,7.46 PR8712.2
  BOTTOM w0.102: PR8714.1 149.23,12.98 149.89,12.32 150.06,12.32 150.45,11.93 150.45,11.39 150.32,11.26 150.32,10.42 v2(149.86,9.95)
  BOTTOM w0.203: PR8714.1 148.79,13.29 147.67,13.29 PR8713.1 147.22,13.88 146.5,14.6 146.03,14.6 145.94,14.69 PU8700.6
VRAVR_ON: length 2.1
  TOP w0.102: v2(49.39,95.47) 48.81,94.89 R3311.2 PR8811.2
VRPPM_SLP_S0_N: length 143.8
  TOP w0.102: v2(164.97,51.31) 167.52,51.31 171.02,54.82 172.5,54.82 175.88,58.2 175.88,59.55 176.53,60.21 176.53,61.18 180.83,65.49 180.83,69.19 179.13,70.9 179.13,73.68 179.49,74.05 180.9,74.05 181.21,74.37 181.21,76 180.22,76.99 180.22,77.43 179.69,77.96 179.69,78.69 180.33,79.33 182.94,79.33 183.67,80.06 183.67,81.49 182.94,82.23 176.09,82.23 175.5,81.64 173.97,81.64 173.1,80.76 172.33,80.76 170.8,79.23 v2(170.8,77.84)
  IN1 w0.114: v2(155.78,75.82) 155.78,75.97 156.57,76.76 158.96,76.76 159.26,77.06 162.41,77.06 162.6,77.25 167.35,77.25 168.58,78.48 170.16,78.48 v2(170.8,77.84)
  BOTTOM w0.102: v2(155.78,75.82) 155.78,76.53 156.06,76.82 R7703.2 ; U400.BJ37 123.35,78.59 124.01,77.93 124.57,77.93 125.34,77.16 125.34,76 125.83,75.51 126.13,75.51 126.57,75.08 126.57,74.51 127.54,73.54 127.54,71.51 126.22,70.19 126.22,64.45 133.78,56.89 156.26,56.89 156.45,56.7 159.11,56.7 159.75,57.33 159.75,57.46 160.13,57.84 160.51,57.84 164.07,54.29 164.07,52.46 164.97,51.55 v2(164.97,51.31)
VRPVDDQ_PG: length 357
  IN1 w0.114: v2(43.91,81.1) 44.56,80.45 44.56,77.4 44.12,76.96 44.12,74.73 43.4,74.02 43.4,70.1 44.38,69.13 44.38,67.07 43.86,66.55 43.86,60.19 42.96,59.3 42.96,55.35 42.65,55.05 42.65,50.22 43.21,49.67 43.21,47.44 42.5,46.74 42.5,44.95 43.49,43.96 43.49,38.61 43.67,38.44 43.67,37.27 44.15,36.79 45.32,36.79 47.92,34.2 47.92,31.79 50.03,29.67 51.85,29.67 52.61,30.43 53.98,30.43 54.53,29.88 57.45,29.88 57.54,29.8 60.78,29.8 61.85,30.87 66.78,30.87 67.31,31.4 82.1,31.4 82.49,31 87.55,31 88.18,31.62 102.04,31.62 102.05,31.61 102.73,31.61 103.13,32.02 113.04,32.02 113.49,31.56 117.28,31.56 120.82,28.02 123.32,28.02 124.91,29.62 126.8,29.62 127.72,28.7 128.42,28.7 128.74,28.38 129.43,28.38 130.35,27.45 130.35,22.17 131.84,20.69 133.45,20.69 136.01,18.13 136.01,17.14 138.39,14.76 140.08,14.76 140.97,13.87 142.02,13.87 v2(142.45,13.44) ; v2(145.34,117.77) 143.44,119.66 128.15,119.66 127.34,120.48 126.98,120.48 126.43,119.92 123.95,119.92 123.88,119.99 121.19,119.99 120.46,119.26 107.67,119.26 106.64,120.29 83.93,120.29 80.88,123.33 77.75,123.33 77.07,124.01 74.5,124.01 73.39,125.12 71.17,125.12 70.55,125.74 68.7,125.74 68.12,126.32 63.97,126.32 63.3,125.65 58.18,125.65 57.6,125.07 52.43,125.07 52.01,124.64 49.02,124.64 45.36,120.99 40.56,120.99 40.33,120.76 40.33,119.72 39.16,118.55 33.18,118.55 29.77,115.13 26.92,115.13 v2(22.97,111.18)
  BOTTOM w0.102: v2(142.45,13.44) 142.89,13 PR8700.1 ; PR8106.2 16.04,113.8 17.38,112.45 18.65,112.45 18.84,112.27 21.88,112.27 v2(22.97,111.18) 23.23,110.92 23.23,92.42 26.82,88.83 36.3,88.83 36.94,88.19 40.24,88.19 43.19,85.24 43.19,81.81 v2(43.91,81.1) ; v2(145.34,117.77) 145.39,117.71 145.39,117.28 145.78,116.9 146.28,116.9 PR9216.2
VSYS: length 5
  TOP w0.254: U6100.19 190.86,105.92 190.96,105.82
  TOP w0.508: R6109.1 190.34,103.21 190.52,103.38 R6100.2 191.19,103.76 v2(191.41,103.99) 191.41,105.36 190.96,105.82
WIRELESS_ON: length 214.5
  TOP w0.102: v2(180.05,67.93) 180.63,67.36 180.63,65.57 176.33,61.27 176.33,60.29 175.67,59.64 175.67,58.28 172.41,55.02 170.94,55.02 167.79,51.87 160.86,51.87 160.2,52.53 156.86,52.53 154.62,50.29 142.87,50.29 142.15,49.56 118.42,49.56 117.44,50.54 104.85,50.54 103.41,51.99 59.98,51.99 58.16,53.81 55.39,53.81 54.74,53.17 52.78,53.17 v2(52.65,53.04) ; Q5005.3 47,55.5 Q5004.2 45.27,55.5 45.02,55.76 45.02,55.91 45.26,56.15 Q5004.3 46.2,56.15 46.27,56.22 R5012.2 v2(47.14,57.26)
  IN2 w0.114: v2(182.58,90.97) 182.21,90.97 180.28,92.9 178.55,92.9 176.9,91.24 174.34,91.24 173.66,90.56 169.52,90.56 169.27,90.31 164.16,90.31 163.27,89.43 162.29,89.43 v2(161.86,89)
  BOTTOM w0.102: v2(180.05,67.93) 179.31,67.19 178.9,67.19 178.08,68.01 178.08,70.56 178.63,71.1 178.63,73.7 177.89,74.44 177.89,75.11 179.75,76.97 181.21,76.97 181.65,77.41 181.65,82.4 181.09,82.96 181.09,84.52 181.06,84.55 181.06,85.14 180.78,85.41 180.78,86.39 181.51,87.12 181.51,89.63 182.58,90.71 v2(182.58,90.97) ; v2(52.65,53.04) 50.99,54.69 50.99,56.19 49.7,57.49 47.37,57.49 v2(47.14,57.26) ; v2(161.86,89) 161.95,89.09 CN4100.6 161.95,91.26 162.24,91.55 164.22,91.55 164.45,91.32 CN4100.16
WL_LED_ALL#_Q: length 2.3
  TOP w0.102: R5014.2 41.96,56.07 R5005.1 41.51,56.67 v2(41.75,56.9)
WLAN_ALERT#: length 2.2
  BOTTOM w0.102: CN4100.62 175.95,91.34 176.87,92.26 TP4102.1
WLAN_DISABLE: length 82.8
  TOP w0.076: U4701.E4 203.26,50.66 203.26,50.22 203.08,50.04 202.81,50.04 202.62,49.86 202.62,48.75 201.51,47.64 200.36,47.64 199.61,46.89 198.65,46.89
  TOP w0.102: v2(195.6,45.86) 195.88,46.14 195.88,46.28 196.17,46.58 196.64,46.58 196.78,46.44 R4749.2 197.16,46.26 197.42,46.51 198.28,46.51 198.65,46.89 ; Q4109.5 177.12,88.3 177.38,88.04 178.25,88.04 178.7,87.59 178.7,87.28 179.33,86.64 179.79,86.64 179.94,86.49 179.94,85.88 179.62,85.56 R4141.2 179.62,85.04 179.48,84.9 174.71,84.9 173.73,85.88 173.41,85.88 v2(172.95,85.42)
  IN1 w0.114: v2(195.6,45.86) 195.41,45.86 194.99,46.28 194.99,46.74 194.34,47.39 193.36,47.39 191.96,48.79 189.72,48.79 188.62,49.89 188.47,49.89 187.37,50.99 186.64,50.99 174.11,63.51 174.11,65.06 176.14,67.08 176.35,67.3 176.35,69.99 176.06,70.28 176.06,71.23 176.51,71.68 177.4,71.68 178.32,72.6 178.32,76.83 178.83,77.34 178.83,78.88 176.91,80.8 174.07,80.8 172.7,82.17 172.7,85.14 172.95,85.39 v2(172.95,85.42)
WLAN_DISABLE#: length 4.5
  TOP w0.102: v2(178.36,86.7) 178.19,86.87 Q4109.3 177.77,86.01 177.6,85.83 177.22,85.83 177.11,85.72 R4136.2 176.47,85.99 Q4109.1
WLAN_I2CCLK: length 3
  BOTTOM w0.102: CN4100.60 175.45,91.35 176.03,91.93 TP4101.1
WLAN_I2DATA: length 1.8
  BOTTOM w0.102: TP4100.1 174.95,91.99 CN4100.58
WLAN_LED_EN: length 380.7
  TOP w0.102: v2(90.86,131.22) 90.61,131.22 89.32,129.93 89.32,128.58 85.44,124.7 80.01,124.7 78.74,123.43 73.96,123.43 73.36,124.03 69.86,124.03 64.68,129.22 50.31,129.22 v2(49.46,128.37) ; Q5005.2 49.59,54.56 48.01,56.15 R5015.2 48.01,57.38 47.45,57.94 46.59,57.94 46.18,58.36 42,58.36 39.02,61.34 39.02,61.78 38.7,62.1 v2(38.36,62.1) ; v2(183.14,84.43) 182.89,84.43 182.43,83.98 182.43,83.6 181.67,82.83 175.84,82.83 175.25,82.25 173.59,82.25 172.73,81.39 172.1,81.39 169.78,79.07 v2(169.78,78.06)
  IN1 w0.114: v2(155.14,75.8) 155.3,75.64 155.3,75.62 155.56,75.37 156.07,75.37 156.19,75.49 158.02,75.49 159.35,76.83 162.5,76.83 162.69,77.02 167.44,77.02 168.53,78.11 169.73,78.11 v2(169.78,78.06) ; v2(38.36,62.1) 38.05,62.41 38.05,63.31 39.3,64.57 39.3,65.93 38.05,67.18 38.05,75.91 37.83,76.13 37.83,81.72 28.6,90.95 28.6,92.02 26.7,93.92 25.82,93.92 17.83,101.9 17.83,103.84 16.93,104.74 16.93,107.37 20.94,111.38 20.94,113.55 26.4,119 26.4,122.46 24.68,124.18 24.68,126.89 25.28,127.49 26.58,127.49 26.76,127.31 28.66,127.31 29.32,127.97 31.19,127.97 31.78,127.38 35.19,127.38 35.68,126.89 37.83,126.89 39.02,128.08 39.9,128.08 40.41,128.59 49.24,128.59 v2(49.46,128.37) ; v2(158.25,129.49) 157.6,128.84 147.47,128.84 146.73,128.1 142.04,128.1 141.32,128.82 132.63,128.82 131.67,127.85 122.39,127.85 120.89,129.35 91.66,129.35 90.88,130.13 90.88,131.2 v2(90.86,131.22)
  BOTTOM w0.079: U400.CN4 137.7,100.25 137.96,99.99 138.21,99.99 138.36,100.14 138.92,100.14 139.6,100.83 141.5,100.83 141.83,100.5 142.73,100.5 144.46,98.78
  BOTTOM w0.102: v2(155.14,75.8) 155.14,76.21 155.56,76.62 155.56,79.05 155.45,79.16 155.45,80.39 156.04,80.98 156.04,83.01 155.28,83.77 155.28,85.98 156.68,87.38 156.68,89.74 158.02,91.09 158.02,91.82 157.72,92.13 157.72,92.39 158.15,92.82 158.15,93.48 156.7,94.93 154.77,94.93 154.31,95.38 154.31,95.8 154.4,95.88 154.4,95.96 152.77,97.59 R535.2 152.31,98.25 149.86,98.25 149.46,98.65 146.8,98.65 146.67,98.78 144.46,98.78 ; v2(158.25,129.49) 157.39,128.63 157.39,126.3 158.61,125.07 158.61,122.51 157.97,121.87 157.97,121.13 162.93,116.17 162.93,115.42 167.62,110.72 174.63,110.72 179,106.35 179,100.66 183.65,96.01 183.65,93.8 184.14,93.31 184.14,90.5 182.73,89.08 182.73,86.94 182.89,86.78 182.89,84.69 v2(183.14,84.43)
