# Allegro board dax8jmb16e0-e-www.DeviceDB.xyz_.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BOOT_SPI#: length 17.9
  TOP w0.079: 132.19,81.46 132.19,81.56 132.47,81.85 132.47,82.17 131.99,82.65 131.99,83.21 v1(131.48,83.72)
  TOP w0.102: R501.1 137.89,70.73 v2(137.89,70.74) 138.04,70.88 138.04,72.97 138.32,73.25 138.32,74.76 134.51,78.56 134.51,79.38 133.27,80.61 132.79,80.61 132.19,81.21 132.19,81.46
  BOTTOM w0.079: U400.CA30 131.33,83.87 v1(131.48,83.72)
BQACDET: length 9.7
  BOTTOM w0.102: v2(126.93,30.92) 126.95,30.89 128.12,30.89
  BOTTOM w0.178: PC8213.1 128.37,28.5 PR8228.2 127.59,29.57 127.67,29.65 128.28,29.65 128.81,30.18 128.81,30.64 128.56,30.89 PD8206.1 128.12,30.89 ; PC8213.1 PR8215.1 PR8213.2 ; PC8213.1 128.42,28.3 128.42,27.71 128.37,27.67 128.37,27.15 128.29,27.07 PU8200.6
BQACDRV: length 1.2
  BOTTOM w0.178: TP8200.1 127.49,27.46 PU8200.4
BQACN: length 4.2
  BOTTOM w0.178: PR8211.1 123.74,29.25 PR8206.2 125.21,27.78 125.21,27.45 125.76,26.9 126.12,26.9 126.29,26.73 PU8200.1
BQACP: length 2.6
  BOTTOM w0.178: PR8205.2 125.7,28.3 v2(125.7,27.67) 126.19,27.18 126.55,27.18 126.69,27.04 PU8200.2
BQBATDRV: length 4
  BOTTOM w0.178: PU8200.18 127.49,22.13 127.66,21.96 127.66,18.79 TP8202.1
BQBATPRES: length 5.2
  BOTTOM w0.178: PU8200.15 128.69,22.17 128.89,21.98 129.09,21.98 129.65,22.54 130.21,22.54 130.41,22.33 PR8224.2 130.27,22.14 130.09,21.96 130.08,21.96 129.97,21.84 129.97,21.84 129.95,21.82 129.95,21.06 130.67,20.34 PR8222.2
BQBATSRC: length 5
  BOTTOM w0.102: v2(128.85,18.76) 128.39,18.76 127.9,19.25 127.9,20.37 PR8223.1
  BOTTOM w0.178: PR8223.1 128.48,21.53 127.89,22.12 PU8200.17
BQCMPIN: length 10
  BOTTOM w0.178: PU8200.13 129.92,23.77 131.35,22.33 PC8224.2 131.89,22.04 131.89,21.79 132.34,21.34 PR8241.1
  BOTTOM w0.254: PR8243.1 134.59,24.72 133.91,24.72 PR8240.2 133.94,23.72 133.94,22.91 v2(133.18,22.14) PR8241.1
BQCMPOUT: length 6.4
  BOTTOM w0.102: v2(133.45,19.71) 132.78,20.38 PR8242.1
  BOTTOM w0.178: PU8200.14 129.9,23.37 130.86,22.4 130.86,21.75 131.28,21.34 PR8241.2 131.6,20.93 131.66,20.88 PR8238.1 PR8242.1
BQCMSRC: length 3.3
  BOTTOM w0.178: PU8200.3 127.09,27.15 126.82,27.42 126.82,27.96 127.06,28.2 127.06,29.14 126.87,29.33 PR8209.1
BQHIDRV: length 15.3
  TOP w0.102: v4(111.9,29.85) 111.41,29.85 v2(111.2,29.63)
  IN2 w0.508: v4(124.04,24.97) 122.66,26.35 117.29,26.35 115.14,28.49 112.73,28.49 111.9,29.33 v4(111.9,29.85)
BQIADP: length 5
  BOTTOM w0.178: PU8200.7 128.69,27.47 v2(128.87,27.65) 128.94,27.72 129.39,27.72 PC8220.1 130.34,28.06 130.97,28.06 131.01,28.11 131.03,28.11 131.6,28.67 PR8229.2
BQIDCHG: length 5
  BOTTOM w0.178: PU8200.8 130.16,25.77 130.44,26.04 v2(130.44,26.54) 130.73,26.54 131.6,27.4 PC8221.1 132.19,27.12 132.97,27.12 132.98,27.12 PR8230.2
BQILIM: length 21.4
  TOP w0.102: v2(126.42,15.04) 127.9,16.52 127.9,17.91 125.84,19.97 v2(125.84,21.81)
  IN1 w0.114: v2(131.78,18.75) 131.78,18.35 130.91,17.48 128.86,17.48 v2(126.42,15.04)
  BOTTOM w0.102: PQ8206.3 133.46,18.12 132.83,18.75 v2(131.78,18.75) ; PU8200.21 126.29,22.82 126.2,22.92 125.24,22.92 PR8233.1 125.28,21.81 v2(125.84,21.81)
BQLODRV: length 9.5
  BOTTOM w0.762: 124.57,23.14 121.29,23.14 120.61,23.83 119.45,23.83 v2(119.44,23.82) 119.43,23.83 118.76,23.83 116.34,26.24
BQPHASE: length 15.4
  TOP w0.508: v2(112.86,29.24) 112.43,29.24 111.78,28.59 PR8216.2
  IN2 w0.508: v4(124.63,25.52) 123.19,26.97 117.54,26.97 115.4,29.11 112.99,29.11 v2(112.86,29.24)
  vias: v2(123.99,25.84)
BQPMON: length 6.4
  BOTTOM w0.178: PU8200.9 130.3,25.37 131.15,26.22 PR8237.1 131.91,26.84 132.98,26.84 133.13,26.69 133.68,26.69 133.92,26.93 133.92,27.42 PR8235.1
BQPROCHOT: length 1.9
  BOTTOM w0.178: PU8200.10 130.46,24.97 130.75,25.25 PR8221.2
BQSCL: length 2.2
  BOTTOM w0.178: PR8220.1 130.77,23.32 129.93,24.17 PU8200.12
BQSDA: length 2
  BOTTOM w0.178: PU8200.11 129.94,24.57 130.22,24.29 v2(130.55,24.29) PR8219.1
BQSRN: length 1.6
  BOTTOM w0.178: PR8227.1 127.06,21.72 127.09,21.75 PU8200.19
BQSRP: length 3.5
  BOTTOM w0.102: v2(124.64,21.53) 125.23,20.95 PR8225.1
  BOTTOM w0.178: PU8200.20 126.69,21.67 125.97,20.95 PR8225.1
BQTB_STAT: length 1.9
  BOTTOM w0.178: PU8200.16 128.29,22.12 128.84,21.57 129.4,21.57 TP8201.1
BQVCC:
  vias: v2(125.01,26.29)
BRD_ID1: length 13.3
  BOTTOM w0.079: U400.CR28 139.67,85.19 140,85.53 140.09,85.53
  BOTTOM w0.102: 140.09,85.53 140.14,85.48 143.21,85.48 143.37,85.32 143.37,84.89 143.64,84.61 148.4,84.61 R504.1 149.03,85.24 R505.1 149.56,86.25 v2(149.86,85.96)
BRD_ID2: length 9.6
  BOTTOM w0.079: 140.24,85.76 139.99,85.76 139.6,85.36 139.1,85.36 139.01,85.45 138.37,85.45 U400.CP28
  BOTTOM w0.102: 140.24,85.76 143.61,85.76 143.94,85.43 144.23,85.43 144.24,85.43 144.79,85.43 145.2,85.02 R507.1 R506.1 146.25,85.68 v2(146.1,85.84)
BRD_ID3: length 12.8
  BOTTOM w0.079: 140.17,85.27 140.06,85.27 139.76,84.97 139.58,84.97 139.52,84.92 137.83,84.92 U400.CN28
  BOTTOM w0.102: v2(148.65,84) 148.35,84.3 147.49,84.3 R508.1 147.01,83.83 R509.2 146.07,84.17 145.83,84.41 143.56,84.41 143.16,84.81 143.16,85.22 143.11,85.27 140.17,85.27
BRD_ID4: length 14.3
  BOTTOM w0.079: U400.CM28 137.09,85.55 137.98,85.55 138.11,85.68 138.11,86.09 138.16,86.14 139.78,86.14
  BOTTOM w0.102: v2(147.94,88.01) 148.05,87.9 R511.2 148.05,86.47 R510.1 147.29,86.57 146.72,86.57 146.41,86.26 145.87,86.26 145.27,85.65 144,85.65 143.69,85.96 140.39,85.96 140.21,86.14 139.78,86.14
BT_OFF: length 35.4
  TOP w0.102: Q4102.5 165.5,85.64 165.25,85.38 165.25,84.78 165.05,84.58 163.96,84.58 163.84,84.71 163.84,85.22 163.45,85.61 162.09,85.61 161.84,85.86 161.84,86.6 161.14,87.31 160.89,87.31 160.51,86.92 159.37,86.92 158.71,87.58 157.36,87.58 155.74,85.96 155.72,85.96 155.41,85.65 v2(153.35,85.65) R473.1 152.43,85.42 152.18,85.18 151.42,85.18 150.94,85.66 149.79,85.66 149.18,86.27 146.18,86.27 145.91,86.54 145.91,86.54 145.5,86.95 144.92,86.95 144.86,86.9 R4147.1 144,86.9 143.59,87.31 140.86,87.31 140.65,87.11 137.37,87.11 137.02,87.46 v1(136.5,87.46)
  BOTTOM w0.102: U400.CM24 136.82,87.78 v1(136.5,87.46)
C_TX0_HDMI+: length 2.2
  TOP w0.097: U3501.6 211.43,89.62 211.35,89.55 211.35,89.4 211.26,89.31 210.85,89.31 210.5,88.95 210.34,88.95 210.22,89.07 C3513.1
C_TX0_HDMI-: length 2.2
  TOP w0.097: U3501.7 211.87,89.22 211.45,89.22 211.34,89.11 210.93,89.11 210.22,88.4 C3514.1
C_TX1_HDMI+: length 2.1
  TOP w0.097: U3501.4 211.44,90.42 211.35,90.33 211.04,90.33 210.22,91.15 C3511.1
C_TX1_HDMI-: length 2.1
  TOP w0.097: C3512.1 210.22,90.43 210.32,90.53 210.56,90.53 210.96,90.14 211.35,90.14 211.46,90.02 U3501.5
C_TX2_HDMI+: length 2.8
  TOP w0.097: C3509.1 210.81,92.79 210.92,92.79 211.15,92.55 211.15,91.72 211.28,91.58 211.43,91.58 211.47,91.62 U3501.1
C_TX2_HDMI-: length 2.7
  TOP w0.097: C3510.1 210.65,92.59 210.83,92.59 210.95,92.47 210.95,91.63 211.21,91.37 211.31,91.37 211.46,91.22 U3501.2
C_TXC_HDMI+: length 2.9
  TOP w0.097: C3515.1 210.22,87.08 210.37,86.93 210.58,86.93 210.99,87.34 210.99,88.06 211.19,88.25 211.3,88.25 211.47,88.42 U3501.9
C_TXC_HDMI-: length 2.9
  TOP w0.097: U3501.10 211.43,88.02 211.4,88.06 211.27,88.06 211.19,87.97 211.19,87.26 210.59,86.66 210.59,86.66 210.23,86.3 C3516.1
CABLE_SIZE_DET: length 257.9
  TOP w0.102: v1(136.38,92.64) 136.9,92.64 136.94,92.68 137.41,92.68 138.19,91.9 138.74,91.9 139.05,91.59 140.17,91.59 v2(140.6,92.02) ; v2(190.33,89.24) 190.27,89.3 190.27,91.64 185.05,96.85 182.56,96.85 181.17,98.23 178.07,98.23 172.83,103.48 171.35,103.48 163.92,110.91 159.22,110.91 154.78,115.35 154.78,116.66 149.13,122.31 149.13,122.74 v2(148.63,123.24)
  IN1 w0.114: v2(40.68,127.94) 40.75,128.01 48.58,128.01 49.1,127.49 50.83,127.49 52.55,129.21 57.73,129.21 58.21,128.73 72.83,128.73 72.99,128.57 73.13,128.57 73.92,127.78 74.42,127.78 75.04,128.41 78.81,128.41 80.93,126.29 85.09,126.29 89.01,130.21 89.01,131.8 89.08,131.87 89.08,134.22 v2(88.37,134.93)
  IN2 w0.114: v2(190.33,89.24) 189.48,89.24 184.45,94.27 177.98,94.27 176.33,92.61 172.04,92.61 171.13,91.71 168.86,91.71 168.66,91.5 162.96,91.5 162.32,90.86 160.13,90.86 159.8,91.19 158.43,91.19 157.92,90.68 157.49,90.68 156.75,91.42 156.55,91.42 156.12,91.85 152.51,91.85 v2(152.03,91.37) ; v2(88.37,134.93) 88.81,134.49 88.81,128.61 90.76,126.67 90.76,124.74 91.78,123.72 100.22,123.72 104.74,119.2 106.26,119.2 106.79,118.67 114.74,118.67 115.02,118.95 117.37,118.95 121.19,122.76 126.56,122.76 127.25,123.45 128.5,123.45 129.19,122.76 131.93,122.76 132.54,122.15 133.2,122.15 133.81,122.76 147,122.76 147.52,123.28 148.59,123.28 v2(148.63,123.24)
  BOTTOM w0.079: 142.85,92.42 142.72,92.42 141.92,91.62 141,91.62 v2(140.6,92.02)
  BOTTOM w0.102: v2(152.03,91.37) 151.9,91.24 R517.2 150.38,91.99 149.61,91.99 149.39,91.77 149.05,91.77 148.89,91.93 R518.1 148.15,91.49 147.92,91.27 146.57,91.27 145.41,92.42 142.85,92.42 ; U400.CK17 136.38,92.36 v1(136.38,92.64) ; CN3400.11 38.15,131.79 38.31,131.63 38.44,131.63 38.69,131.37 38.69,130.53 39.53,129.7 39.53,128.67 39.89,128.31 40.31,128.31 v2(40.68,127.94)
CABLE_SIZE_DET_2: length 12.2
  TOP w0.102: v2(44.39,123.86) 44.66,123.86 44.93,124.13 R3425.1
  BOTTOM w0.102: CN3400.4 41.65,131.74 41.89,131.5 42.27,131.5 42.53,131.24 42.53,130.49 42.27,130.23 42.02,130.23 41.89,130.1 41.89,126.07 42.86,125.11 43.59,125.11 44.39,124.3 v2(44.39,123.86)
CAMERA_ON: length 408.7
  TOP w0.102: v2(185.47,88.8) 184.87,88.8 184.66,88.58 184.66,88.09 182.35,85.79 181.39,85.79 180.83,85.22 180.83,84.76 180.59,84.51 179.96,83.88 175.4,83.88 174.81,83.29 173.16,83.29 172.46,82.6 171.82,82.6 167.2,77.98 162.13,77.98 159.91,75.76 159.91,75.12 159.27,74.48 159.22,74.48 155.92,71.18 146.42,71.18 146.02,70.79 146.02,68.75 145.25,67.98 142.92,67.98 142.21,67.27 139.33,67.27 138.93,67.67 R483.1 136.91,67.67 136.52,68.07 136.52,68.69 137.31,69.49 137.31,70.81 137.69,71.2 137.69,72.92 138.11,73.35 138.11,74.55 134.19,78.48 134.19,79.21 133.12,80.27 132.64,80.27 131.66,81.26 131.66,82.78 v1(131.54,82.89) ; v2(29.83,21.98) 30.01,22.15 R7636.2 ; v2(38.73,74.43) 37.58,73.28 37.58,32.88 v2(37.17,32.47)
  IN1 w0.114: v2(29.83,21.98) 30.31,21.98 34.02,25.68 35.27,25.68 36.13,26.54 36.13,28.28 36.48,28.63 36.48,31.78 v2(37.17,32.47) ; v2(38.73,74.43) 39.35,75.05 39.35,76.76 39.86,77.27 39.86,81.44 29.45,91.84 29.45,93.24 21.92,100.77 20.26,100.77 18.96,102.07 18.96,104.01 17.85,105.12 17.85,106.99 21.63,110.77 21.63,113.12 27.87,119.36 39.12,119.36 39.68,119.92 39.68,121.65 40.83,122.8 46.57,122.8 v2(47,123.23) 48.64,124.87 51.91,124.87 52.33,125.29 57.39,125.29 57.97,125.88 63.21,125.88 64.06,126.73 68.03,126.73 68.8,125.97 70.64,125.97 71.27,125.34 73.46,125.34 73.85,125.74 77.06,125.74 78.87,123.93 81.25,123.93 84.27,120.9 107.12,120.9 108.28,119.74 111.44,119.74 112.18,120.48 114.11,120.48 114.36,120.22 119.25,120.22 119.6,120.58 124.44,120.58 124.62,120.4 125.79,120.4 126.6,121.21 132.57,121.21 133.66,120.12 143.97,120.12 144.4,119.69 148.3,119.69 151.48,122.87 155.77,122.87 156.56,122.07 157.38,122.07 157.67,122.36 158.29,122.36 159.8,120.84 159.8,119.47 160.49,118.77 160.49,116.86 160.8,116.55 160.8,113.31 165.91,108.2 168.32,108.2 168.87,107.65 179.18,107.65 v2(179.46,107.93)
  BOTTOM w0.102: U400.CA31 131.21,83.22 v1(131.54,82.89) ; v2(185.47,88.8) 185.85,88.8 186.87,89.82 186.87,93.88 185.99,94.77 185.99,96.51 182.02,100.47 182.02,106.66 180.48,108.21 179.74,108.21 v2(179.46,107.93) ; v2(47,123.23) 44.33,123.23 43.92,123.63 43.92,124.14 43.37,124.69 42.86,124.69 41.56,125.99 41.56,130.21 41.01,130.76 39.43,130.76 39.15,131.04 CN3400.9
CAMERA_WP#: length 287.7
  TOP w0.076: v3(203.93,53.93) 203.61,53.61 U4701.E8
  TOP w0.102: v2(51.16,53.02) 51.8,52.38 51.8,51.75 52.18,51.36 52.64,51.36 53.09,51.82 53.16,51.82 53.67,52.34 53.99,52.34 54.38,51.95 56.96,51.95 57.6,52.59 57.94,52.59 59.56,50.97 102.98,50.97 105.04,48.91 117.12,48.91 117.97,48.06 143.62,48.06 144.37,48.82 169.95,48.82 179.07,57.94 185.97,57.94 186.42,58.4 R4768.2 186.87,58.29 v2(186.87,57.61)
  IN1 w0.076: 199.2,56.03 199.47,56.03 199.76,56.32 200.78,56.32 201.34,55.76 201.34,55.08 201.95,54.46 202.74,54.46 202.95,54.26 203.61,54.26 v3(203.93,53.93)
  IN1 w0.114: v2(186.87,57.61) 188.38,59.11 191.08,59.11 194.17,56.03 199.2,56.03
  IN2 w0.114: v2(38.8,65.78) 38.44,66.14 38.44,72.22 36.13,74.53 34.39,74.53 31.6,77.31 31.6,79.06 30.23,80.43 30.23,82.42 21.2,91.45 21.2,101.51 17.83,104.89 17.23,104.89 14.29,107.83 14.21,107.9 9.94,107.9 9.66,108.18 9.66,110.87 15.89,117.1 20.18,117.1 21.99,118.91 21.99,121.88 23.87,123.76 28.07,123.76 v2(28.23,123.6)
  BOTTOM w0.102: CN3400.25 31.15,131.84 31.04,131.73 30.82,131.73 30.69,131.59 30.69,131.44 30.54,131.29 30.54,130.23 30.85,129.92 30.85,128.45 31.99,127.32 31.99,125.85 32.14,125.7 32.14,124.46 31.9,124.21 28.59,124.21 28.23,123.86 v2(28.23,123.6) ; v2(38.8,65.78) 39.2,65.38 39.2,60.68 40.45,59.43 42.21,59.43 45.35,56.29 47.3,56.29 47.91,56.9 49.18,56.9 50.58,55.49 50.58,53.98 51.16,53.4 v2(51.16,53.02)
CAPS_LED#: length 151.5
  TOP w0.102: v2(52.47,51.78) 52.47,52.28 52.83,52.64 53.2,52.64 53.52,52.96 57.12,52.96 57.35,53.2 58.19,53.2 59.81,51.58 103.24,51.58 105.29,49.52 117.38,49.52 118.17,48.73 143.42,48.73 144.12,49.43 169.7,49.43 179.08,58.82 R4735.1 179.08,60.22 179.76,60.9 C5023.2 180.93,60.9 180.93,60.9 U4700.4 182.65,60.9 182.81,61.07 182.81,61.67 R4737.2 ; v2(44.34,50.41) 43.96,50.03 42.68,50.03 R5004.1
  BOTTOM w0.102: v2(44.34,50.41) 45.14,50.41 45.4,50.15 50.63,50.15 51.11,50.63 51.11,51.01 51.88,51.78 v2(52.47,51.78)
CATERR#: length 11.4
  BOTTOM w0.079: TP401.1 107.2,106.28 107.2,106.29 106.92,106.56 106.61,106.56 106.36,106.31 106.36,103.43 106.19,103.26 106.19,102.68 106.45,102.42 106.45,102.06 106.44,102.02 106.4,101.84 106.4,101.84 106.47,101.61 106.47,101.49 106.44,101.35 106.37,101.22 106.28,100.67 U400.AA4
  BOTTOM w0.102: R400.1 108.48,108.87 108.48,106.82 107.63,105.97 TP401.1
CCG5_HOTPLUG_DET_P1_C: length 18.6
  TOP w0.102: v2(189.05,104.02) 189.31,103.76 R6100.1 190.52,104.54 R6113.1 190.52,105.74 190.36,105.89 U6100.18 ; v2(197.11,100.16) 196.63,99.67 Q6100.3 196.63,98.51 196.3,98.18 194.7,98.18 194.27,97.74 R6112.2
  BOTTOM w0.102: v2(189.05,104.02) 192.92,100.16 v2(197.11,100.16)
CCG5_I2C_SCL_MUX: length 160.7
  TOP w0.102: v2(199.59,103.28) 199.59,103.5 199.89,103.8 201.04,103.8 201.05,103.79 201.17,103.79 201.38,103.59 R5807.2 201.69,103.31 202.45,104.06 202.45,105.21 202.69,105.46 Q5800.6 ; v2(187.82,105.75) 187.86,105.79 U6100.13
  IN1 w0.127: v2(173.17,16.77) 174.38,17.97 184.86,17.97 185.68,17.16 187.73,17.16 189.5,15.39 190.89,15.39 191.86,16.36 193.37,16.36 193.75,16.74 194.78,16.74 200.68,22.64 200.68,35.27 201.15,35.74 201.15,42.86 200.73,43.27 200.73,44.79 199.07,46.46 198.23,47.29 198.23,48.42 196.13,50.53 194.17,50.53 192.71,51.98 190.94,51.98 189.4,53.52 188.77,53.52 188.01,54.27 187.12,54.27 182.96,58.43 182.96,65.61 181.69,66.88 181.69,67.28 v2(182.26,67.85)
  BOTTOM w0.102: R7734.1 172.22,15.59 172.51,15.88 172.89,15.88 173.17,16.16 v2(173.17,16.77) ; v2(199.59,103.28) 199.55,103.32 196.31,103.32 193.87,105.75 193.87,107.29 193.2,107.96 191.76,107.96 190.23,106.44 189.95,106.44 188.75,105.24 188.33,105.24 v2(187.82,105.75) 187.34,106.23 186.18,106.23 184.08,104.13 184.08,100.41 187.31,97.18 187.31,95.32 188.19,94.43 188.19,89.27 186.47,87.55 186.47,83.54 185.43,82.5 185.43,79.37 184.29,78.24 184.29,76.74 181.13,73.58 181.13,68.98 v2(182.26,67.85)
CCG5_I2C_SCL_MUX_C: length 2.8
  BOTTOM w0.102: CN7702.4 172.45,12.88 172.22,13.11 R7734.2 171.39,14.62 v2(171.39,14.66)
CCG5_I2C_SDA_MUX: length 157.2
  TOP w0.102: Q5800.3 201.38,104.45 201.02,104.45 200.8,104.23 R5808.2 200.47,104.27 199.56,104.27 v2(199.03,103.73) ; v2(188.45,105.75) 188.45,106.13 188.36,106.22 U6100.14
  IN1 w0.127: v2(173.84,16.77) 174.65,17.59 184.71,17.59 185.52,16.78 187.48,16.78 189.24,15.01 191.24,15.01 192.16,15.93 193.48,15.93 193.91,16.36 194.94,16.36 201.09,22.51 201.09,34.9 201.63,35.45 201.63,43.01 201.16,43.48 201.16,44.9 198.61,47.45 198.61,48.58 196.28,50.91 194.34,50.91 192.89,52.36 191.86,52.36 191.26,52.96 190.5,52.96 189.56,53.9 188.92,53.9 188.17,54.66 187.28,54.66 183.82,58.12 183.82,65.58 v2(182.26,67.14)
  BOTTOM w0.102: R7733.1 173.31,14.64 173.31,15.63 173.84,16.15 v2(173.84,16.77) ; v2(182.26,67.14) 180.77,68.62 180.77,73.72 183.93,76.88 183.93,78.38 185.07,79.52 185.07,82.65 186.11,83.69 186.11,87.69 187.84,89.42 187.84,94.28 186.95,95.17 186.95,97.03 183.73,100.26 183.73,104.28 186.03,106.58 187.61,106.58 v2(188.45,105.75) 188.47,105.73 188.74,105.73 189.81,106.8 190.08,106.8 191.61,108.32 193.35,108.32 194.23,107.45 194.23,105.9 196.46,103.67 198.97,103.67 v2(199.03,103.73)
CCG5_I2C_SDA_MUX_C: length 3.5
  BOTTOM w0.102: v2(172.67,15.41) 172.67,14.35 R7733.2 172.95,13.5 CN7702.3
CCG5_SWD_CLK: length 88.9
  TOP w0.102: U6100.2 185.26,111.53 TP6103.1 183.9,112.9 R6107.1 183.51,113.24 183.42,113.15 R6106.2 182.91,111.47 182.44,111 181.74,111 180.37,109.64 180.37,108.59 181.22,107.74 181.22,106.59 182.54,105.26 v2(182.66,105.26)
  IN2 w0.114: v2(177.55,67.95) 177.55,67.96 177.14,68.37 173.59,68.37 172.81,69.15 168.17,69.15 167.4,69.93 166.04,69.93 164.94,68.82 159.85,68.82 159.79,68.89 157.18,68.89 156.39,69.68 155.64,69.68 v2(155.11,70.2)
  BOTTOM w0.102: v2(177.55,67.95) 178.51,66.99 179.95,66.99 180.61,67.64 180.61,68.28 180.42,68.46 180.42,73.77 180.02,74.17 180.02,75.09 180.35,75.42 181.68,75.42 183.38,77.11 183.38,78.61 184.51,79.75 184.51,82.88 185.56,83.92 185.56,87.93 187.28,89.65 187.28,94.05 186.39,94.94 186.39,96.67 182.66,100.41 v2(182.66,105.26) ; R7708.1 153.81,72.12 153.81,71.5 v2(155.11,70.2)
CCG5_SWD_CLK_R: length 12.8
  BOTTOM w0.102: R7702.2 152.3,73.06 152.68,72.68 R7708.2 152.68,71.97 v2(153.05,71.61) 154.96,69.69 156.35,69.69 157.11,68.93 158.42,68.93 159.03,69.54 CN7701.14
CCG5_SWD_IO: length 89.3
  TOP w0.102: v2(183.35,105.26) 182.84,105.77 182.34,105.77 181.43,106.68 181.43,107.83 180.58,108.69 180.58,109.52 181.83,110.77 TP6104.1 185.12,110.42 185.12,109.86 185.45,109.53 U6100.6
  IN1 w0.114: v2(171.76,78.83) 171.04,78.83 170.74,79.13 168.58,79.13 167.16,77.71 162.41,77.71 162.22,77.52 156.22,77.52 155.77,77.06 155.34,76.64 151.93,76.64 151.77,76.48 151.77,75.88 152.62,75.02 v2(152.85,75.02)
  IN2 w0.114: v2(171.76,78.83) 171.76,77.92 172.52,77.16 173.64,77.16 174.24,77.76 174.24,78.74 175.06,79.56 177.9,79.56 178.67,78.8 179.73,78.8 179.84,78.91 180.4,78.91 181.26,78.05 181.26,75.64 v2(180.6,74.98)
  BOTTOM w0.102: v2(152.85,75.02) 153.27,74.61 153.27,74.26 153.4,74.13 153.4,73.5 R7710.1 ; v2(180.6,74.98) 181.53,74.98 183.58,77.03 183.58,78.53 184.72,79.67 184.72,82.8 185.76,83.84 185.76,87.84 187.48,89.56 187.48,94.14 186.6,95.02 186.6,96.76 183.35,100.01 v2(183.35,105.26)
CCG5_SWD_IO_R: length 16.4
  BOTTOM w0.102: R7700.2 151.33,73.64 152.37,73.64 152.58,73.44 R7710.2 152.78,73.33 152.78,73.32 153.17,72.93 153.8,72.93 153.96,73.09 v2(153.96,74.42) 154.4,73.98 154.4,73.84 154.67,73.57 155.13,73.57 155.45,73.25 156.07,73.25 156.96,72.36 156.96,71.3 157.34,70.92 157.84,70.92 158.23,71.3 158.23,73.31 158.48,73.56 159.72,73.56 160.03,73.25 CN7701.12
CCG5_VBUS: length 2.6
  TOP w0.305: U6100.22 192.97,108.03
  TOP w0.508: R6111.1 193.38,106.72 v2(193.38,107.62) 192.97,108.03
CCG5_VBUS_C_CTRL_P1: length 29.9
  TOP w0.102: v2(199.8,92.54) 199.92,92.43 PR8012.1 199.97,91.85 PR8007.2 199.63,90.66 199.4,90.89 199.4,93.25 199.91,93.76 PQ8005.5 ; U6100.12 187.36,106.1 187.41,106.05 187.41,105.48 187.06,105.14 186.7,105.14 186.54,104.99 186.54,103.88 v2(186.43,103.77)
  IN1 w0.114: v2(199.8,92.54) 199.39,92.54 197.39,94.55 197.39,97.55 196.96,97.97 196.07,97.97 191.51,102.53 188.54,102.53 188.32,102.75 188.32,103.26 187.92,103.66 186.54,103.66 v2(186.43,103.77)
CCG5_XRES: length 82.1
  TOP w0.102: U6100.10 185.62,107.53 185.53,107.45 185.53,106.69 TP6102.1 185.07,106.46 184.23,105.62 R6108.2 C6106.2 184.79,104.89 184.79,104.38 v2(185.23,103.94)
  IN2 w0.114: v2(158.32,69.47) 158.68,69.12 159.88,69.12 159.95,69.05 164.3,69.05 164.73,69.49 164.73,70.52 165.42,71.2 166,71.2 167.05,70.15 167.49,70.15 168.27,69.38 173.84,69.38 174.62,68.6 177.74,68.6 178.1,68.24 178.1,67.47 178.73,66.84 178.73,66.65 v2(179.07,66.31)
  BOTTOM w0.102: v2(158.32,69.47) 157.76,70.03 157.46,70.03 156.83,70.67 156.32,70.67 155.99,71 R7706.1 ; v2(185.23,103.94) 184.64,103.35 184.64,100.39 189.09,95.94 189.09,94.36 188.55,93.82 188.55,89.12 187.54,88.12 187.54,86.73 186.83,86.01 186.83,83.4 185.78,82.36 185.78,79.23 184.65,78.09 184.65,76.59 181.49,73.43 181.49,69.81 182.96,68.33 182.96,66.92 182.08,66.03 179.35,66.03 v2(179.07,66.31)
CCG5_XRES_R: length 7.6
  BOTTOM w0.102: R7704.2 155.17,72.63 v2(155.23,72.57) 156,72.57 R7706.2 156.45,72.18 156.45,71.43 157.46,70.41 158.35,70.41 158.53,70.6 CN7701.15
CD_WP_POL#: length 2.8
  TOP w0.102: U7600.27 44.22,27.38 v2(44.74,26.86) 44.74,26.32 45.12,25.94 R7613.2
CFG0: length 135.2
  TOP w0.102: R7718.2 30.31,122 v2(30.34,122.02) ; R632.2 38.16,121.31 38.08,121.24 38.08,120.65 v2(38.37,120.36) 38.76,119.97 CN7700.9
  IN1 w0.114: v2(38.37,120.36) 37.63,119.62 30.02,119.62 29.65,119.99 29.65,121.34 v2(30.34,122.02)
  IN2 w0.114: v2(100.36,106.13) 100.32,106.13 98.45,108 92.56,108 91.92,108.64 85.12,108.64 79.13,102.65 78.78,102.65 70.65,94.53 68.9,94.53 66.22,91.85 61.38,91.85 59.63,90.1 58.34,88.81 58.07,88.54 40.41,88.54 39.23,89.72 35.3,89.72 33.57,91.44 33.57,92.84 36.1,95.37 36.1,102.32 39.77,105.98 39.77,108.74 40.36,109.33 40.95,109.33 41.68,110.06 41.68,111.58 40.6,112.66 40.6,114.83 40.98,115.21 40.98,115.67 41.99,116.68 41.99,117.07 39.98,119.08 39.65,119.08 v2(38.37,120.36)
  BOTTOM w0.079: v2(100.36,106.13) 100.77,105.72 101.18,105.72 101.77,105.13 101.93,105.13 103.33,103.73 103.33,101.55 103.28,101.5 103.28,101.08 103.03,100.83 U400.T4
CFG1: length 127.5
  TOP w0.102: R633.2 37.77,121.04 37.86,120.95 37.86,120.22 38.26,119.82 CN7700.11 38.26,117.43 38.58,117.11 41.06,117.11 41.28,117.33 41.28,118.07 v2(41.6,118.39) 43.75,120.54 v2(43.74,120.54)
  IN2 w0.114: v2(41.6,118.39) 42.47,117.51 42.47,114.92 41.95,114.4 41.95,111.96 42.14,111.77 42.14,108.98 40.86,107.7 40.86,106.13 36.56,101.83 36.56,95.18 34.03,92.65 34.03,91.63 35.43,90.23 39.73,90.23 40.97,88.99 57.88,88.99 58.4,89.52 61.19,92.3 66.03,92.3 68.71,94.98 70.46,94.98 78.59,103.11 78.94,103.11 84.93,109.1 92.11,109.1 92.75,108.46 98.95,108.46 100.71,106.69 101.03,106.69 101.44,106.29 101.44,104.18 v2(101.28,104.02)
  BOTTOM w0.079: v2(101.28,104.02) 101.61,103.69 102.12,103.69 102.4,103.41 102.4,102.55 102.19,102.34 102.19,101.4 102.21,101.05 102.21,101.05 102.21,100.76 U400.R4
CFG2: length 122.5
  TOP w0.102: v2(40.94,116.23) 40.94,116.36 40.41,116.9 38.49,116.9 38.08,117.3 37.35,117.3 37.26,117.39 CN7700.15 37.26,119.82 37.02,120.06 37.02,120.37 37.07,120.42 R634.2
  IN2 w0.114: v2(99.73,106.12) 99.73,106.39 98.35,107.77 92.47,107.77 91.83,108.41 85.21,108.41 79.22,102.42 78.87,102.42 70.75,94.3 68.99,94.3 66.32,91.62 61.47,91.62 59.79,89.94 58.16,88.31 40.25,88.31 39.1,89.46 35.23,89.46 33.34,91.35 33.34,92.93 35.87,95.46 35.87,102.65 39.54,106.31 39.54,108.83 40.47,109.76 41,109.76 41.45,110.22 41.45,111.48 40.37,112.57 40.37,114.93 40.74,115.3 40.74,116.04 v2(40.94,116.23)
  BOTTOM w0.079: U400.T3 103.03,101.48 103.17,101.62 103.17,103.66 101.87,104.96 101.7,104.96 101.12,105.54 100.21,105.54 99.73,106.02 v2(99.73,106.12) 99.73,106.32 v2(98.87,107.18)
CFG3: length 123.9
  TOP w0.102: R7726.1 37.72,122.69 37.32,122.29 37.32,122.1 36.63,121.41 R635.2 36.6,121.25 36.68,121.25 36.81,121.12 36.81,119.95 36.76,119.9 CN7700.17 36.76,117.33 37,117.1 38,117.1 38.41,116.69 39.78,116.69 40.06,116.41 v2(40.32,116.41)
  IN2 w0.114: v2(40.32,116.41) 40.34,116.39 40.34,115.22 40.14,115.02 40.14,112.47 40.8,111.81 40.8,110.95 40.32,110.47 40.32,109.94 39.31,108.93 39.31,106.49 35.64,102.82 35.64,95.56 33.12,93.03 33.12,91.25 35.16,89.21 38.97,89.21 40.1,88.08 58.26,88.08 61.57,91.39 66.41,91.39 69.09,94.07 70.84,94.07 78.97,102.2 79.32,102.2 85.31,108.18 91.73,108.18 92.37,107.54 97.96,107.54 v2(99.14,106.36)
  BOTTOM w0.079: v2(99.14,106.36) 99.14,106.02 99.79,105.37 101.05,105.37 101.63,104.79 101.8,104.79 103,103.59 103,101.69 102.46,101.15 U400.R3
CFG4: length 117.7
  TOP w0.102: v2(38.14,116.39) 37.63,116.9 36.78,116.9 36.37,117.3 34.32,117.3 34.26,117.37 CN7700.27 34.26,119.92 34.17,120.01 v2(34.17,120.65)
  IN2 w0.114: v2(95.03,104.89) 93.15,104.89 90.05,101.78 84.44,101.78 83.48,102.74 82.22,102.74 80.07,100.6 79.63,100.6 71.5,92.47 69.75,92.47 67.07,89.79 62.23,89.79 58.92,86.48 35.62,86.48 31.52,90.59 31.52,93.69 33,95.17 33,100.45 32.37,101.07 32.37,103.14 35.14,105.9 35.14,106.89 35.53,107.28 35.82,107.28 36.38,107.84 36.38,110.54 37,111.16 37,113.96 38.14,115.1 v2(38.14,116.39)
  BOTTOM w0.079: R605.2 95.03,105.34 v2(95.03,104.89) 95.92,103.99 96.47,103.99 97.9,102.56 97.9,101.44 97.88,101.41 97.88,101.08 98.06,100.9 98.24,100.9 98.71,100.43 U400.J4
CFG5: length 120.5
  TOP w0.102: v2(36.87,116.44) 36.24,117.07 34.02,117.07 33.76,117.33 CN7700.29 33.76,120.28 33.66,120.38 33.66,120.99 33.76,121.09 33.87,121.09 33.95,121.17 R637.2
  IN2 w0.114: v2(36.87,116.44) 36.87,115.45 35.69,114.27 35.69,109.68 33.97,107.96 33.54,107.96 32.98,107.39 32.98,106.34 32.44,105.8 32.44,104.59 31.46,103.61 31.46,100.69 32.08,100.07 32.08,95.55 30.6,94.07 30.6,90.21 36.27,84.54 58.27,84.54 62.61,88.87 67.45,88.87 70.13,91.55 71.88,91.55 80.01,99.68 83.98,99.68 85.17,100.87 90.41,100.87 91.23,101.69 94.85,101.69 95.23,102.07 97.29,102.07 98.74,103.52 98.9,103.52 v2(99.32,103.94)
  BOTTOM w0.079: v2(99.32,103.94) 99.32,103.65 100.48,102.49 100.48,101.75 100.48,101.71 100.48,101.71 100.28,101.28 100.28,101.1 U400.M4
CFG6: length 118.7
  TOP w0.102: R638.2 32.9,120.04 32.76,119.9 CN7700.33 32.76,117.38 33.27,116.87 36.15,116.87 36.46,116.56 36.46,116.27 36.73,115.99 37.09,115.99 v2(37.5,116.41)
  IN2 w0.114: v2(95.66,104.86) 95.23,104.42 93.01,104.42 90.14,101.56 84.34,101.56 83.38,102.51 82.31,102.51 80.16,100.37 79.73,100.37 71.6,92.24 69.85,92.24 67.17,89.56 62.32,89.56 59.01,86.25 35.53,86.25 31.29,90.49 31.29,93.78 32.77,95.27 32.77,100.36 32.15,100.98 32.15,103.33 34.91,106.09 34.91,106.98 35.44,107.5 35.72,107.5 36.15,107.93 36.15,113.44 37.87,115.16 37.87,116.04 v2(37.5,116.41)
  BOTTOM w0.079: v2(95.66,104.86) 96.31,104.21 96.59,104.21 98.18,102.63 98.18,101.64 98.71,101.11 U400.J3
CFG7: length 121.6
  TOP w0.102: R639.2 32.78,121.3 32.62,121.15 32.62,120.17 32.26,119.81 CN7700.35 32.26,117.33 33.18,116.41 35.09,116.41 v2(35.12,116.45)
  IN2 w0.114: v2(35.12,116.45) 35.33,116.24 36.21,116.24 36.52,115.93 36.52,115.42 35.46,114.36 35.46,109.77 33.87,108.18 33.45,108.18 32.76,107.49 32.76,106.43 32.21,105.89 32.21,104.69 31.23,103.7 31.23,100.6 31.85,99.98 31.85,95.64 30.37,94.16 30.37,90.11 36.18,84.31 58.36,84.31 62.7,88.64 67.55,88.64 70.23,91.32 71.98,91.32 80.1,99.45 84.07,99.45 85.26,100.64 90.48,100.64 91.3,101.46 94.95,101.46 95.33,101.84 97.39,101.84 98.83,103.28 99.3,103.28 v2(99.96,103.94)
  BOTTOM w0.079: v2(99.96,103.94) 99.96,103.27 100.65,102.57 100.65,101.76 100.66,101.64 U400.M3
CFG8: length 109.8
  TOP w0.102: CN7700.10 38.76,111.01 R640.2 39.81,110.82 TP7700.1 39.99,110.29 v2(39.68,109.99)
  IN2 w0.114: v2(100.94,104.95) 100.32,105.56 99.65,105.56 99.42,105.8 99.07,105.8 98.85,106.02 98.84,106.02 97.55,107.31 92.28,107.31 91.64,107.96 85.4,107.96 79.41,101.97 79.06,101.97 70.93,93.84 69.18,93.84 66.5,91.16 61.66,91.16 58.35,87.85 39.82,87.85 38.72,88.96 35.09,88.96 32.89,91.16 32.89,93.12 35.31,95.54 35.31,96.13 34.69,96.75 34.69,98.92 35.42,99.65 35.42,103.03 39.08,106.69 39.08,109.26 39.68,109.86 v2(39.68,109.99)
  BOTTOM w0.079: v2(100.94,104.95) 101.26,104.62 101.66,104.62 102.83,103.46 102.83,101.92 U400.R2
CFG9: length 113.5
  TOP w0.102: CN7700.12 38.26,111.53 38.55,111.24 38.55,110.63 38.37,110.45 R641.2 37.96,110.45 37.9,110.39 37.9,110.23 37.28,109.6 34.18,109.6 34.16,109.58 33.76,109.58 v2(33.31,109.12)
  IN2 w0.114: v2(33.31,109.12) 32.07,107.89 32.07,106.72 31.53,106.17 31.53,104.97 30.55,103.99 30.55,95.31 29.69,94.45 29.69,89.83 35.89,83.62 58.65,83.62 62.99,87.96 67.83,87.96 70.51,90.64 72.26,90.64 80.39,98.77 84.36,98.77 85.54,99.95 90.72,99.95 91.53,100.77 95.23,100.77 95.61,101.16 97.67,101.16 98.43,101.92 99.91,101.92 v2(101.33,103.34)
  BOTTOM w0.079: U400.N2 101.24,101.75 101.4,102.09 101.41,102.22 101.41,102.24 101.52,102.35 101.52,103.15 v2(101.33,103.34)
CFG10: length 118.1
  TOP w0.102: v2(39.92,115.4) 39.92,114.99 39.66,114.73 37.82,114.73 37.26,114.17 CN7700.16 37.26,111.6 37.22,111.56 37.22,111.05 37.04,110.87 R642.2
  IN2 w0.114: v2(39.92,115.4) 39.92,112.38 40.51,111.78 40.51,111.08 39.9,110.47 39.06,110.47 38.57,109.98 38.57,106.68 34.46,102.57 34.46,95.01 32.66,93.22 32.66,91.06 35.02,88.7 38.59,88.7 39.67,87.62 58.45,87.62 61.75,90.93 66.6,90.93 69.28,93.61 71.03,93.61 79.16,101.74 79.51,101.74 85.5,107.73 91.54,107.73 92.18,107.09 97.45,107.09 98.97,105.57 99.32,105.57 99.56,105.33 99.9,105.33 v2(100.3,104.93)
  BOTTOM w0.079: U400.R1 102.57,102.31 102.57,103.48 101.65,104.4 100.83,104.4 v2(100.3,104.93)
CFG11: length 109.7
  TOP w0.102: v2(34.8,110.04) v2(35.48,110.04) 35.81,110.37 R643.2 36.51,110.37 36.66,110.52 36.66,110.86 36.98,111.18 36.98,111.52 36.76,111.74 CN7700.18
  IN2 w0.114: v1(100.72,103.33) 100.21,102.82 99.02,102.82 97.57,101.38 95.52,101.38 95.14,101 91.46,101 90.64,100.18 85.45,100.18 84.26,99 80.29,99 72.17,90.87 70.42,90.87 67.74,88.19 62.89,88.19 58.55,83.85 35.99,83.85 29.92,89.92 29.92,94.35 30.77,95.21 30.77,103.89 31.76,104.88 31.76,106.08 32.3,106.62 32.3,107.68 33.26,108.64 33.68,108.64 34.8,109.76 v2(34.8,110.04)
  BOTTOM w0.079: U400.N1 101.15,102.9 v1(100.72,103.33)
CFG12: length 114.7
  TOP w0.102: R644.2 34.04,110.42 33.93,110.53 33.93,111.28 34.26,111.61 CN7700.28 34.26,114.3 34.83,114.87 v2(36.89,114.87)
  IN2 w0.114: v2(96.29,104.88) 95.61,104.2 93.11,104.2 90.24,101.33 84.25,101.33 83.29,102.29 82.41,102.29 80.26,100.14 79.82,100.14 71.69,92.01 69.94,92.01 67.26,89.33 62.42,89.33 59.11,86.02 35.43,86.02 31.06,90.4 31.06,93.88 32.54,95.36 32.54,100.26 31.92,100.88 31.92,103.42 34.69,106.19 34.69,107.08 35.34,107.73 35.63,107.73 35.92,108.03 35.92,113.89 v2(36.89,114.87)
  BOTTOM w0.079: U400.J2 98.71,101.64 98.38,101.97 98.38,102.69 96.29,104.78 v2(96.29,104.88)
CFG13: length 106.2
  TOP w0.102: CN7700.30 33.76,111.69 33.61,111.53 R645.2 33.61,109.94 33.32,109.65 33.09,109.65 32.88,109.43 32.88,106.54 33.28,106.14 33.28,105.85 v2(33.21,105.78)
  IN2 w0.114: v2(33.21,105.78) 33.21,105.04 31.69,103.51 31.69,100.79 32.31,100.17 32.31,95.45 30.83,93.97 30.83,90.3 36.37,84.77 58.18,84.77 62.51,89.1 67.36,89.1 70.04,91.78 71.79,91.78 79.92,99.91 83.88,99.91 85.07,101.1 90.33,101.1 91.15,101.92 94.76,101.92 95.14,102.3 97.2,102.3 98.69,103.79 v2(98.69,103.94)
  BOTTOM w0.079: U400.L2 100.31,102.09 100.31,102.42 99.55,103.18 99.45,103.18 v2(98.69,103.94)
CFG14: length 118.7
  TOP w0.102: R646.2 32.52,111.37 32.76,111.61 CN7700.34 32.76,114.17 34.39,115.8 35.59,115.8 35.76,115.96 36.14,115.96 36.53,115.58 38.84,115.58 v2(39.07,115.35)
  IN2 w0.114: v2(97.83,105.44) 97.63,105.64 93.26,105.64 89.86,102.24 84.63,102.24 83.67,103.2 82.03,103.2 79.88,101.05 79.44,101.05 71.31,92.92 69.56,92.92 66.88,90.25 62.04,90.25 58.73,86.94 35.81,86.94 31.97,90.78 31.97,93.5 33.77,95.3 33.77,102.91 37.03,106.16 37.03,109.41 38.1,110.48 38.1,114.38 v2(39.07,115.35)
  BOTTOM w0.079: U400.J1 98.58,102.33 98.58,102.76 97.59,103.75 97.59,105.2 v2(97.83,105.44) 97.96,105.57 v2(97.96,106.06)
CFG15: length 127.2
  TOP w0.102: v2(39.69,116.03) 39.32,116.4 38.73,116.4 38.11,115.78 36.63,115.78 36.24,116.17 35.63,116.17 35.46,116 34.09,116 32.26,114.17 CN7700.36 32.26,111.61 32.16,111.51 32.16,109.66 32.31,109.51 R647.2 32.52,108.72 v2(32.18,108.38)
  IN2 w0.114: v2(99.67,104.89) 99.23,105.33 98.88,105.33 97.36,106.86 93.83,106.86 89.67,102.7 84.82,102.7 83.86,103.66 81.84,103.66 79.69,101.51 79.25,101.51 71.12,93.38 69.37,93.38 66.69,90.7 61.85,90.7 58.54,87.39 36,87.39 32.43,90.97 32.43,93.31 34.23,95.11 34.23,102.66 38.34,106.77 38.34,110.08 38.96,110.7 39.81,110.7 40.28,111.18 40.28,111.68 39.49,112.48 39.49,115.83 v2(39.69,116.03)
  BOTTOM w0.079: U400.L1 99.92,102.31 99.92,102.56 99.47,103.01 99.08,103.01 98.31,103.78 98.31,104.1 98.71,104.5 99.27,104.5 v2(99.67,104.89)
CFG16: length 108.2
  TOP w0.102: v2(39.86,111.35) 39.76,111.45 CN7700.6
  IN2 w0.114: v2(98.98,104.91) 98.02,105.87 93.17,105.87 89.76,102.47 84.72,102.47 83.76,103.43 81.93,103.43 79.79,101.28 79.35,101.28 71.22,93.15 69.47,93.15 66.79,90.47 61.94,90.47 58.64,87.17 35.91,87.17 32.2,90.87 32.2,93.41 34,95.2 34,102.76 38.11,106.87 38.11,110.17 38.87,110.93 39.44,110.93 39.86,111.35 v2(39.86,111.35)
  BOTTOM w0.079: U400.L3 99.75,101.46 99.75,101.56 99.8,101.76 99.8,101.87 99.75,102.22 99.75,102.49 99.4,102.85 99.01,102.85 98.14,103.71 98.14,104.17 98.87,104.91 v2(98.98,104.91)
CFG17: length 121.7
  TOP w0.102: v2(41.24,110.98) 40.81,110.98 40.26,111.53 CN7700.4 40.26,114.93 41.56,116.23 41.56,116.59 v2(41.38,116.77)
  IN2 w0.114: v2(98.25,104.96) 97.64,104.96 97.19,105.42 93.35,105.42 89.95,102.01 84.53,102.01 83.57,102.97 82.12,102.97 79.98,100.82 79.54,100.82 71.41,92.7 69.66,92.7 66.98,90.02 62.13,90.02 58.83,86.71 35.72,86.71 31.74,90.68 31.74,93.59 33.54,95.39 33.54,101.96 32.9,102.6 32.9,103.18 36.1,106.38 36.1,107.07 36.8,107.76 36.8,110.64 37.23,111.07 37.23,113.87 38.6,115.24 38.6,116.05 39.46,116.9 41.25,116.9 v2(41.38,116.77)
  BOTTOM w0.079: v2(98.25,104.96) 98.25,104.59 97.97,104.32 97.97,103.64 98.94,102.68 99.31,102.68 99.58,102.4 99.58,102.21 99.62,101.95 99.62,101.73 99.58,101.58 99.58,101.42 99.6,101.37 99.69,101.2 99.7,101.05 99.78,100.75 U400.L4
CFG18: length 120.4
  TOP w0.102: CN7700.24 35.26,114.12 35.53,114.38 37.13,114.38 37.4,114.65 37.4,115.14 37.21,115.33 36.18,115.33 v2(35.98,115.53)
  IN2 w0.114: v2(35.98,115.53) 35.7,115.53 32.74,112.57 32.74,109.04 31.84,108.14 31.84,106.81 31.3,106.27 31.3,105.07 30.32,104.08 30.32,95.4 29.46,94.54 29.46,89.73 35.8,83.39 58.74,83.39 63.08,87.73 67.93,87.73 70.61,90.41 72.36,90.41 80.48,98.54 84.45,98.54 85.64,99.73 90.79,99.73 91.61,100.54 95.33,100.54 95.71,100.93 97.76,100.93 98.53,101.69 100.34,101.69 v2(101.96,103.31)
  BOTTOM w0.079: U400.N3 101.36,101.36 101.4,101.41 101.4,101.46 101.48,101.86 101.57,102.05 101.68,102.17 101.68,103.03 v2(101.96,103.31)
CFG19: length 111.5
  TOP w0.102: v2(34.83,110.69) 35.26,111.11 35.27,111.11 35.76,111.61 CN7700.22
  IN2 w0.114: v2(100.59,103.94) 99.7,103.05 98.92,103.05 97.48,101.61 95.42,101.61 95.04,101.23 91.38,101.23 90.56,100.41 85.35,100.41 84.17,99.22 80.2,99.22 72.07,91.1 70.32,91.1 67.64,88.42 62.8,88.42 58.46,84.08 36.08,84.08 30.14,90.02 30.14,94.26 31.63,95.74 31.63,99.88 31,100.5 31,103.8 31.99,104.78 31.99,105.98 32.53,106.53 32.53,107.58 33.35,108.41 33.78,108.41 35.23,109.87 35.23,110.28 v2(34.83,110.69)
  BOTTOM w0.079: v2(100.59,103.94) 100.34,103.69 100.34,103.21 100.82,102.73 100.82,101.76 100.83,101.65 100.83,101.63 100.89,100.77 100.89,100.76 100.95,100.7 U400.N4
CFG_RCOMP: length 8.6
  TOP w0.381: v2(105.28,106.87) R603.1 105.28,105.59 105.65,105.23 105.65,100.47 v1(106.75,99.37)
  BOTTOM w0.254: U400.AB5 106.61,99.51 v1(106.75,99.37)
CHA_SA0: length 4.7
  TOP w0.102: R2819.2 v2(113.93,39.78) R2814.1
  BOTTOM w0.114: JDIM2800.256 114.85,38.04 115.08,38.26 115.08,39.06 114.36,39.78 v2(113.93,39.78)
CHA_SA1: length 5.8
  TOP w0.102: R2820.2 v2(113.9,40.57) R2815.1
  BOTTOM w0.114: v2(113.9,40.57) 114.28,40.57 116.01,38.84 116.01,38.18 115.85,38.03 JDIM2800.260
CHA_SA2: length 3.7
  TOP w0.102: v2(92.35,38.35) 92.44,38.26 R2821.2 R2816.1 92.44,36.51 v2(92.07,36.14)
  BOTTOM w0.114: v2(92.35,38.35) JDIM2800.166
CHB_SA0: length 5.4
  TOP w0.102: v2(191.38,40.03) 191.24,39.88 R2826.1 190.1,40.41 R2823.2
  BOTTOM w0.114: v2(191.38,40.03) 191.38,38.72 191.62,38.48 191.62,38.15 191.82,37.95 JDIM2801.256
CHB_SA1: length 7.3
  TOP w0.102: R2824.2 190.86,41.46 190.77,41.36 R2827.1 190.77,40.77 190.95,40.59 191.77,40.59 v2(191.84,40.52) v2(192.65,39.71)
  BOTTOM w0.114: JDIM2801.260 192.82,39.91 192.2,40.52 v2(191.84,40.52)
CHB_SA2: length 5.1
  TOP w0.102: R2825.2 170.24,37.34 170.18,37.28 169.7,37.28 169.51,37.47 R2828.1 169.51,38.16 169.55,38.2 v2(169.55,38.64) v2(168.85,39.34)
  BOTTOM w0.114: JDIM2801.166 169.32,38.4 v2(169.55,38.64)
CK_XDP_N: length 110.1
  TOP w0.097: CN7700.42 30.76,111.71 30.92,111.56 30.92,111.13 v2(30.69,110.9)
  IN2 w0.114: v2(30.69,110.9) 30.92,111.13 30.92,114.45 36.57,120.1 36.57,121.89 39.29,124.6 44.69,124.6 44.88,124.41 49.54,124.41 49.91,124.78 59.9,124.78 60.39,125.27 70.27,125.27 71.57,123.97 72.85,123.97 73.55,123.27 77.16,123.27 77.37,123.06 82.44,123.06 85.63,119.87 87.96,119.87 90.68,117.15 93.38,117.15 93.64,117.4 95.87,117.4 96.53,116.74 96.53,116.23 v2(96.68,116.07)
  BOTTOM w0.097: 115.09,106.64 115.09,106.75 115.34,107.01 115.34,113.42 113.09,115.68 111,115.68 110.7,115.98 107.51,115.98 106.64,116.86 99.49,116.86 98.18,115.55 96.53,115.55 96.48,115.6 96.48,115.87 v2(96.68,116.07)
  BOTTOM w0.102: R585.3 115.09,106.64
CK_XDP_N_R: length 4.5
  BOTTOM w0.079: U400.AU1 115.58,101.99 115.38,101.99 115.25,102.12 115.25,103.59 114.61,104.23 114.61,104.72 114.71,104.83 114.89,104.83 115.09,105.03 R585.4
CK_XDP_P: length 110.1
  TOP w0.097: CN7700.40 31.26,111.71 31.12,111.57 31.12,111.19 v2(31.38,110.92)
  IN2 w0.114: v2(95.92,116.07) 96.11,116.07 96.3,116.26 96.3,116.65 95.77,117.18 93.73,117.18 93.48,116.92 90.58,116.92 87.87,119.64 85.54,119.64 82.34,122.83 77.28,122.83 77.07,123.04 73.45,123.04 72.75,123.74 71.47,123.74 70.17,125.04 60.48,125.04 60,124.55 50,124.55 49.63,124.19 44.79,124.19 44.6,124.38 39.38,124.38 36.8,121.8 36.8,120.01 31.15,114.36 31.15,111.16 v2(31.38,110.92)
  BOTTOM w0.097: 114.54,106.82 114.68,106.97 115.02,106.97 115.15,107.09 115.15,113.34 113.01,115.48 110.92,115.48 110.62,115.78 107.43,115.78 106.55,116.66 99.57,116.66 98.26,115.35 96.45,115.35 96.28,115.52 96.28,115.94 96.14,116.07 v2(95.92,116.07)
  BOTTOM w0.102: 114.54,106.82 114.44,106.72 R585.1
CK_XDP_P_R: length 4.5
  BOTTOM w0.079: R585.2 114.44,104.16 115.08,103.52 115.08,102.06 115.31,101.82 115.53,101.82 U400.AU2
CL_CLK: length 49.2
  IN2 w0.114: v2(171.84,97.13) 171.01,96.3 162.5,96.3 161.89,95.68 159.34,95.68 157.63,97.39 153.48,97.39 152.8,96.7 152.18,96.7 151.93,96.96 150.34,96.96 150.11,97.19 148.94,97.19 148.26,97.86 148.26,98.37 147.97,98.66 145.75,98.66 145.7,98.72 143.5,98.72 142.99,99.22 142.73,99.22 141.83,98.33 139.31,98.33 138.54,97.55 138.54,96.86 137.7,96.02 136.2,96.02 135.92,96.3 135.27,96.3 134.98,96.58 134.98,97.31 134.52,97.78 v1(134.49,97.78)
  BOTTOM w0.102: C4108.2 R4115.1 171.38,93.76 171.1,94.05 171.1,94.46 171.84,95.21 v2(171.84,97.13) ; v1(134.49,97.78) 134.49,97.86 134.84,98.21 U400.CH7
CL_DATA: length 42.9
  IN2 w0.114: v1(135.39,97.93) 135.85,97.47 135.85,96.75 136.31,96.29 137.65,96.29 138.31,96.95 138.31,97.65 139.22,98.55 141.73,98.55 142.63,99.45 143.08,99.45 143.59,98.94 148.01,98.94 148.49,98.46 148.49,97.96 148.99,97.46 150.23,97.46 150.5,97.19 151.88,97.19 152.31,97.62 157.72,97.62 159.43,95.91 161.79,95.91 162.41,96.53 170.58,96.53 v2(171.18,97.13)
  BOTTOM w0.102: v1(135.39,97.93) 135.31,97.93 U400.CH8 ; R4114.1 171.18,96.08 v2(171.18,97.13)
CL_RST: length 42.8
  IN2 w0.114: v1(135.39,97.33) 135.38,97.33 134.98,97.73 134.98,98.15 135.9,99.07 135.9,99.66 136.19,99.95 136.77,99.95 137.93,98.78 141.64,98.78 142.54,99.68 143.18,99.68 143.69,99.17 148.1,99.17 148.72,98.56 148.72,98.05 149.08,97.69 150.46,97.69 150.73,97.41 151.79,97.41 152.22,97.85 157.82,97.85 159.53,96.14 161.7,96.14 162.31,96.75 170.1,96.75 v2(170.5,97.15)
  BOTTOM w0.102: v2(170.5,97.15) 170.16,96.82 R4113.1 ; v1(135.39,97.33) 135.35,97.33 U400.CH9
CLICKPAD_INT#: length 265.5
  TOP w0.102: v2(144.53,89.64) 144.93,89.24 146.17,89.24 147.31,88.1 150.3,88.1 150.54,88.34 151.9,88.34 152.47,87.76 153.86,87.76 154.5,88.4 156.02,88.4 158,90.37 159.26,90.37 v2(159.38,90.25)
  IN1 w0.114: v2(56.95,92.69) 57.15,92.49 63.33,92.49 65.31,94.47 72.26,94.47 82.08,104.29 82.08,105.97 86.59,110.48 v2(86.59,111.91)
  IN2 w0.114: v2(86.59,111.91) 86.59,112.02 87.65,113.08 90,113.08 90.29,112.8 108.07,112.8 110.91,115.65 115.99,115.65 116.27,115.93 118.64,115.93 119.93,117.22 122.1,117.22 124.38,119.5 131.4,119.5 131.56,119.34 140.58,119.34 141.04,118.88 143.28,118.88 144.24,119.85 152.49,119.85 v2(152.94,120.3) ; v2(65.75,72.86) 65.75,72.21 65.52,71.99 65.16,71.99 58.53,65.36 58.53,64.93 55.27,61.67 55.27,61.16 53.7,59.59 53.7,56.27 54.16,55.81 54.16,55.22 53.13,54.19 50.16,54.19 49.51,53.55 49.51,49.33 49.85,48.99 49.85,46.69 46.15,42.99 46.15,39.8 50.11,35.84 51.64,35.84 52.12,35.36 60.43,35.36 61.06,34.74 61.57,34.74 61.88,34.42 v2(62.14,34.42)
  BOTTOM w0.102: U400.CR22 141.32,89.02 141.72,89.42 144.3,89.42 v2(144.53,89.64) ; v2(56.95,92.69) 57.21,92.69 58,91.9 58,91.08 57.86,90.94 57.86,76.4 59.44,74.82 63.78,74.82 v2(65.75,72.86) ; v2(159.38,90.25) 159.37,90.26 159.37,90.51 159.34,90.53 159.34,91.65 159.42,91.72 159.42,92.56 160.13,93.27 160.13,94.75 158.38,96.5 158.38,98.13 161.6,101.35 161.6,105.64 159.62,107.63 159.62,108.56 152.76,115.42 152.76,120.13 v2(152.94,120.3) ; v2(62.14,34.42) 62.14,34.02 60.94,32.82 60.94,30.94 60.84,30.85 60.84,29.97 R9647.2 60.82,28.98 60.82,28.62 61.01,28.43 CN6200.7
CLK_PCI_EC_R: length 10.1
  TOP w0.102: R442.1 129.45,73.75 v2(129.45,74.76) 129.45,74.92 129.86,75.33 129.86,76.42 128.4,77.88 128.4,80.75 128.51,80.87 128.51,82.03 v1(128.68,82.2)
  BOTTOM w0.079: v1(128.68,82.2) 128.74,82.2 129.1,82.57 U400.BV32
CLK_PCIE_LANN: length 126.8
  TOP w0.097: v2(125.28,114.41) 125.28,114.89 125.41,115.02 125.71,115.02 125.79,114.94 126.85,113.88 127.33,113.88 127.84,113.38 129.61,113.38 130.49,114.26 131.9,114.26 134.06,116.42 137.24,116.42 137.35,116.31 138.46,116.31 138.81,115.97 142.29,115.97 142.31,115.99 150.62,115.99 160.13,106.48 165.74,106.48 170.55,101.67 171.92,101.67 172.79,100.8 172.79,99.45 174.16,98.08 175.55,98.08 178.59,95.04 184.29,95.04 188.28,91.05 188.28,86.3 187.78,85.8 187.78,84.98 185.13,82.34 185.13,80.61 187.04,78.7 188.55,78.7 190.32,76.93 190.89,76.93 191.94,75.88 191.94,75.54 192.34,75.13 192.34,73.99 192.75,73.58 192.75,70.53 193.07,70.22 193.55,70.22 193.73,70.04 193.73,69.88 193.53,69.67 U4000.16
  BOTTOM w0.097: v2(125.28,114.41) 125.28,114.93 125.19,115.02 124.7,115.02 124.34,115.38 120.47,115.38 119.17,114.07 119.17,111.3 120.51,109.96 120.51,108.92 120.23,108.64 120.23,105.91 119.13,104.81 119.13,103.39 120.01,102.52 120.01,101.33 U400.BD3
CLK_PCIE_LANP: length 126.8
  TOP w0.097: v2(125.28,115.41) 125.47,115.22 125.79,115.22 125.99,115.02 126.93,114.08 127.42,114.08 127.92,113.57 129.53,113.57 130.41,114.46 131.82,114.46 133.97,116.62 137.32,116.62 137.43,116.51 138.54,116.51 138.89,116.17 142.2,116.17 142.23,116.19 150.7,116.19 160.21,106.68 165.82,106.68 170.63,101.87 172,101.87 172.99,100.88 172.99,99.53 174.24,98.28 175.63,98.28 178.67,95.23 184.38,95.23 188.48,91.13 188.48,86.22 187.98,85.72 187.98,84.9 185.33,82.25 185.33,80.69 187.12,78.9 188.63,78.9 190.4,77.12 190.97,77.12 192.13,75.96 192.13,75.62 192.54,75.21 192.54,74.07 192.95,73.66 192.95,70.61 193.15,70.41 193.63,70.41 193.93,70.12 U4000.15
  BOTTOM w0.097: U400.BC3 119.55,101.13 119.82,101.4 119.82,102.44 118.95,103.31 118.95,104.88 120.05,105.98 120.05,108.74 120.31,109 120.31,109.87 118.97,111.22 118.97,114.15 120.39,115.58 124.42,115.58 124.78,115.21 125.09,115.21 v2(125.28,115.41)
CLK_PCIE_SSDN: length 186.5
  IN2 w0.102: 139.66,100.15 139.63,100.15 139.62,100.16 137.24,100.16 136.58,100.82 129.32,100.82 128.79,101.35 123.43,101.35 123.15,101.63 120.53,101.63 118.49,103.67 117.61,103.67 v2(117.3,103.36)
  IN2 w0.114: v2(211.36,20.22) 211.54,20.22 211.68,20.36 211.68,20.73 212.03,21.09 215.44,21.09 217.09,22.74 217.09,23.86 219.24,26.01 220.21,26.01 221.6,27.41 221.6,35.95 220.2,37.34 220.2,43.85 219.64,44.4 219.64,46.59 218.5,47.74 218.5,53 217.88,53.62 217.88,57.28 216.55,58.6 215.25,58.6 212.02,61.84 210.09,61.84 208.87,63.06 208.87,63.22 207.56,64.53 207.21,64.53 206.83,64.15 205.14,64.15 203.97,65.32 203.97,66.38 203.59,66.76 203.59,67.61 200.17,71.02 199.84,71.02 196.59,74.27 196.59,75.17 195.3,76.46 195.3,80.21 195.05,80.45 195.05,81.54 195.51,82 195.51,83.55 194.32,84.74 194.32,89.62 186.51,97.43 183.48,97.43 182.06,98.85 176.42,98.85 175.97,98.4 174.26,98.4 171.82,100.84 170.31,100.84 169.72,100.26 165.48,100.26 164.67,99.45 163.31,99.45 162.77,99.98 162.77,100.57 160.65,102.7 159.19,102.7 156.91,100.41 156.09,100.41 155.79,100.11 154.64,100.11 153.65,99.12 153.06,99.12 152.68,99.5 150.35,99.5 150.1,99.25 148.79,99.25 148.39,99.65 143.86,99.65 143.36,100.15 139.66,100.15
  BOTTOM w0.079: v2(117.3,103.36) 117.67,103.36 117.77,103.27 117.77,101.94 117.39,101.55 U400.AW2
  BOTTOM w0.097: CN4300.53 212.92,18.34 212.85,18.41 212.85,18.54 212.75,18.64 212.31,18.64 211.69,19.26 211.69,20.11 211.58,20.22 v2(211.36,20.22)
CLK_PCIE_SSDP: length 186.5
  IN2 w0.102: 139.66,100.37 139.63,100.37 139.62,100.36 137.33,100.36 136.67,101.02 129.4,101.02 128.87,101.55 123.51,101.55 123.23,101.83 120.62,101.83 118.58,103.87 117.5,103.87 v2(117.3,104.08)
  IN2 w0.114: 139.66,100.37 143.45,100.37 143.95,99.88 148.49,99.88 148.89,99.48 150.01,99.48 150.26,99.73 152.78,99.73 153.16,99.35 153.56,99.35 154.55,100.34 155.7,100.34 156,100.64 156.81,100.64 159.1,102.93 160.74,102.93 163,100.67 163,100.08 163.4,99.67 164.57,99.67 165.39,100.49 169.63,100.49 170.21,101.07 171.91,101.07 174.35,98.63 175.88,98.63 176.32,99.08 182.15,99.08 183.57,97.66 186.61,97.66 194.55,89.72 194.55,84.84 195.74,83.64 195.74,81.9 195.28,81.44 195.28,80.55 195.53,80.3 195.53,76.55 196.82,75.27 196.82,74.37 199.93,71.25 200.27,71.25 203.82,67.7 203.82,66.86 204.2,66.48 204.2,65.41 205.23,64.38 206.74,64.38 207.12,64.76 207.66,64.76 209.1,63.31 209.1,63.16 210.19,62.07 212.11,62.07 215.35,58.83 216.64,58.83 218.1,57.37 218.1,53.71 218.73,53.09 218.73,47.83 219.87,46.69 219.87,44.5 220.43,43.94 220.43,37.44 221.83,36.04 221.83,27.31 220.3,25.79 219.34,25.79 217.32,23.77 217.32,22.65 215.53,20.86 212.12,20.86 211.9,20.64 211.9,20.39 v2(212.08,20.22)
  BOTTOM w0.079: v2(117.3,104.08) 117.3,103.97 117.94,103.34 117.94,101.87 117.67,101.6 U400.AY3
  BOTTOM w0.097: CN4300.55 212.39,18.84 211.89,19.34 211.89,20.03 v2(212.08,20.22)
CLK_PCIE_WLANN: length 91
  IN2 w0.102: v2(121.23,104.37) 121.45,104.15 121.89,104.15 123.13,102.9 127.91,102.9 128.06,102.75 129.23,102.75 129.89,102.09 135.17,102.09 136.05,102.97 136.8,102.97 137.18,102.59 138.89,102.59 138.9,102.6 138.91,102.6
  IN2 w0.114: v2(175.08,100.36) 174.84,100.61 174.84,101.07 173.17,102.74 167.07,102.74 166.42,103.38 162.77,103.38 160.82,105.34 157.02,105.34 156.37,106 152.9,106 151.21,104.3 150.1,104.3 147.76,101.96 145.05,101.96 144.96,101.87 141.93,101.87 141.2,102.6 138.91,102.6
  BOTTOM w0.079: v2(121.23,104.37) 121.65,103.95 121.65,103.85 122.02,103.48 122.02,103.19 122.69,102.52 122.69,101.74 122.45,101.5 122.45,101.33 U400.BH3
  BOTTOM w0.097: v2(175.08,100.36) 174.8,100.08 174.8,99.59 180.75,93.64 180.75,91.91 181.1,91.56 181.1,90.32 180.28,89.51 179.42,89.51 177.23,87.31 174.91,87.31 174.61,87.61 173.45,87.61 173.01,87.17 173.01,86.39 172.24,85.62 172.24,84.63 172.56,84.31 172.56,83.89 172.7,83.75 CN4100.49
CLK_PCIE_WLANP: length 91
  IN2 w0.102: 138.91,102.37 138.9,102.37 138.89,102.39 137.1,102.39 136.72,102.77 136.14,102.77 135.26,101.88 129.8,101.88 129.14,102.55 127.97,102.55 127.82,102.7 123.05,102.7 121.8,103.94 121.44,103.94 v2(121.23,103.73)
  IN2 w0.114: 138.91,102.37 141.1,102.37 141.84,101.64 145.06,101.64 145.15,101.73 147.85,101.73 150.2,104.07 151.31,104.07 153,105.77 156.27,105.77 156.93,105.11 160.72,105.11 162.68,103.15 166.33,103.15 166.98,102.51 173.07,102.51 174.61,100.97 174.61,100.49 174.48,100.36 v2(174.27,100.36)
  BOTTOM w0.079: U400.BH4 122.28,100.85 122.28,101.57 122.52,101.81 122.52,102.45 121.85,103.12 121.85,103.41 121.53,103.73 v2(121.23,103.73)
  BOTTOM w0.097: v2(174.27,100.36) 174.6,100.03 174.6,99.51 180.55,93.56 180.55,91.83 180.9,91.48 180.9,90.41 180.2,89.7 179.34,89.7 177.15,87.51 174.99,87.51 174.69,87.81 173.37,87.81 172.81,87.26 172.81,86.47 172.04,85.7 172.04,84.55 172.36,84.23 172.36,83.91 172.2,83.75 CN4100.47
CLK_PCIE_WWANN: length 110.6
  IN2 w0.102: v2(119.67,104.18) 120.01,103.84 120.44,103.84 120.68,103.59 120.68,103.25 120.9,103.03 121.87,103.03 122.55,102.34 127.4,102.34 127.58,102.16 128.97,102.16 129.58,101.55 137.13,101.55 137.54,101.14 139.62,101.14 139.63,101.15 139.66,101.15
  IN2 w0.114: 139.66,101.15 144.74,101.15 145.32,100.56 147.23,100.56 147.66,101 148.42,101 148.7,101.28 148.7,101.96 150.3,103.56 151.73,103.56 153.5,105.33 155.76,105.33 157.18,103.92 161.11,103.92 163.44,101.59 168.13,101.59 168.5,101.96 172.04,101.96 174.58,99.42 175.69,99.42 176.04,99.76 182.54,99.76 183.96,98.34 186.84,98.34 195.79,89.4 195.79,87.78 195.61,87.61 195.61,85.93 198.83,82.71 199.12,82.71 199.63,82.2 199.63,80.7 200.77,79.56 200.77,76.78 201.79,75.76 201.79,75.25 201.49,74.95 201.21,74.95 v2(201.02,74.77)
  BOTTOM w0.079: v2(119.67,104.18) 120.1,103.75 120.1,103 120.47,102.63 120.47,102.41 U400.BE1
  BOTTOM w0.097: CN4200.53 201.45,74.81 201.38,74.88 201.14,74.88 v2(201.02,74.77)
CLK_PCIE_WWANP: length 110.7
  IN2 w0.102: v2(119.7,103.47) 119.87,103.64 120.35,103.64 120.48,103.51 120.48,103.16 120.82,102.82 121.78,102.82 122.47,102.14 127.31,102.14 127.49,101.96 128.89,101.96 129.5,101.35 137.04,101.35 137.46,100.93 139.62,100.93 139.63,100.92 139.66,100.92
  IN2 w0.114: v2(200.98,75.43) 200.98,75.34 201.14,75.18 201.39,75.18 201.56,75.34 201.56,75.67 200.54,76.68 200.54,79.46 199.4,80.61 199.4,82.11 199.02,82.48 198.74,82.48 195.39,85.83 195.39,87.7 195.56,87.88 195.56,89.3 186.74,98.12 183.87,98.12 182.45,99.54 176.13,99.54 175.79,99.19 174.49,99.19 171.95,101.73 168.6,101.73 168.23,101.36 163.34,101.36 161.02,103.69 157.08,103.69 155.67,105.1 153.6,105.1 151.83,103.33 150.39,103.33 148.93,101.87 148.93,101.18 148.52,100.77 147.75,100.77 147.32,100.33 145.23,100.33 144.64,100.92 139.66,100.92
  BOTTOM w0.079: v2(119.7,103.47) 119.93,103.24 119.93,103.24 119.93,102.93 120.3,102.56 120.3,101.92 U400.BE2
  BOTTOM w0.097: CN4200.55 201.95,73.32 201.89,73.39 201.71,73.39 201.65,73.45 201.65,74.92 201.44,75.13 201.21,75.13 201.17,75.17 201.06,75.17 200.98,75.26 v2(200.98,75.43)
