# Allegro board dax8jmb16e0-e-www.DeviceDB.xyz_.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N38538150: length 4.4
  TOP w0.102: R7723.2 30.75,109.51 30.32,109.94 30.32,110.33 v2(29.76,110.89) CN7700.46
N38881137: length 3.1
  TOP w0.102: PR8838.1 PR8863.2 32.18,97.37 v2(30.74,97.37)
N38904312: length 8.7
  TOP w0.102: PQ8505.2 168.89,7.93 169.71,8.74 171.4,8.74 PC8509.2 172.32,9.67 PR8513.2 172.88,10.79 172.88,11.33 172.55,11.66 v2(172.55,12.21) PR8511.1
N38904357: length 8.1
  TOP w0.102: PQ8506.2 164.6,8.74 164.68,8.82 166.25,8.82 166.45,9.02 166.45,10.11 166.71,10.37 PR8514.2 167.74,9.96 PQ8505.3 169.54,10.15 v2(170.37,10.15)
N38936226: length 12.6
  TOP w0.381: PQ8200.4 114.5,35.03 PR8207.1 114.58,34.37 v2(114.56,34.35) ; PQ8202.6 104.95,34.97 v2(105.47,35.49)
  BOTTOM w0.381: v2(105.47,35.49) 106.61,34.35 v2(114.56,34.35)
N38936233: length 4.7
  TOP w0.102: v2(100.26,31.16) PD8201.2
  TOP w0.381: PD8201.2 101.08,32.44 101.09,32.43 PR8204.1 102,32.43 102.16,32.59 103.13,32.59 PQ8201.2
N38936236: length 25.7
  TOP w0.178: v2(140.57,23.09) 140.28,22.81 PR8201.1
  IN2 w0.254: v2(131.96,31.25) 132.22,30.99 132.75,30.99 132.98,31.22 134.32,31.22 136.1,29.44 136.1,25.33 136.54,24.88 138.34,24.88 140,23.22 140.44,23.22 v2(140.57,23.09)
  BOTTOM w0.254: v2(131.96,31.25) 131.76,31.45 125.89,31.45 125.22,30.78 PC8203.2 PC8204.1 124.25,30.04 124.54,29.75 125.04,29.75 PR8205.1
N38936237: length 25.9
  TOP w0.178: PR8202.1 140.44,23.88 v2(140.59,23.73)
  IN2 w0.254: v2(140.59,23.73) 140.44,23.59 140.15,23.59 138.49,25.25 136.7,25.25 136.47,25.48 136.47,29.6 134.45,31.62 132.64,31.62 v2(132.55,31.53)
  BOTTOM w0.254: PR8206.1 124.52,29.26 PC8204.2 123.47,30.44 PC8205.1 125.24,31.3 125.74,31.81 132.27,31.81 v2(132.55,31.53)
N38936238: length 5.2
  TOP w0.102: v2(103.91,29.08) 103.49,29.5 PQ8201.1
  TOP w0.381: PQ8202.4 104.44,31.63 103.49,30.68 PQ8201.1
N38936239: length 2.3
  TOP w0.381: PQ8202.3 102.17,33.67 v2(101.75,34.09) 101.27,34.57 PR8203.2
N38936251: length 7.1
  TOP w0.102: v2(98.82,35.38) 99.13,35.07 PR8208.1
  TOP w0.381: PQ8202.5 PQ8202.2 102.36,34.32 101.23,35.45 100,35.45 PR8208.1
N38936280:
  vias: v2(120.85,26.87)
N38936318: length 1.3
  BOTTOM w0.102: PR8212.1 120.89,24.39 v2(120.5,24.79)
N38936322: length 295.8
  TOP w0.254: PD8207.3 187.77,95.43 v2(188.01,95.19) ; v2(178.8,65.49) 178.8,64.14 176.05,61.38 176.05,60.41 175.35,59.71 175.35,58.35 172.3,55.3 170.82,55.3 167.67,52.15 160.97,52.15 160.31,52.81 156.75,52.81 154.5,50.57 142.76,50.57 142.03,49.84 118.53,49.84 117.55,50.82 104.97,50.82 103.52,52.27 60.1,52.27 58.2,54.17 55.25,54.17 54.89,53.81 v2(54.31,53.81)
  IN1 w0.254: v2(192.39,81.23) 192.11,81.51 192.11,83.27 192.31,83.46 192.31,84.26 192.8,84.76 192.8,90.65 191.44,92.01 190.08,92.01 187.87,94.23 187.87,95.05 v2(188.01,95.19) ; v2(54.31,53.81) 51.07,53.81 49.13,51.87 49.13,48.19 47.15,46.21 47.15,44.03 45.81,42.68 45.81,39.64 49.91,35.54 69.99,35.54 70.61,34.92 82.76,34.92 83.43,34.24 86.21,34.24 87.5,35.54 92.74,35.54 92.86,35.65 104.01,35.65 104.67,34.99 115.42,34.99 116.07,34.35 119.86,34.35 121.58,32.63 129.45,32.63 132.4,29.68 v2(132.76,29.68)
  BOTTOM w0.254: v2(192.39,81.23) 192.22,81.23 191.19,80.21 191.19,79.15 190.71,78.67 188.41,78.67 188.03,79.05 187.29,79.05 185.77,77.53 185.77,76.15 182.59,72.97 182.59,72.01 184.26,70.34 184.26,67.07 182.54,65.35 178.94,65.35 v2(178.8,65.49) ; v2(132.76,29.68) 131.04,29.68 PR8213.1
N38936359: length 2.7
  TOP w0.102: v2(116.48,27.02) 116.43,27.06 114.7,27.06 114.2,27.56 PC8216.1
N38936366: length 38.6
  BOTTOM w0.127: PR8217.1 99.47,30.35 99.47,29.86 99.73,29.6 101.4,29.6 102.55,28.45 102.55,27.49 103.14,26.9 109.76,26.9 111.63,25.02 116.11,25.02 v2(118.13,23.01) 118.13,22.77 118.96,21.94 123.59,21.94 124.7,20.83 124.7,16.79 124.82,16.67 PC8218.1 125.22,17.36 125.15,17.44 125.15,18.12 PC8217.1 125.56,19.08 125.64,19.16 PR8225.2
N38936367: length 41
  BOTTOM w0.127: PR8218.1 98.89,30.71 99.2,30.41 99.2,29.74 99.62,29.32 101.29,29.32 102.27,28.33 102.27,27.44 103.09,26.62 109.64,26.62 111.52,24.74 116.06,24.74 117.63,23.18 117.63,22.8 118.77,21.66 123.55,21.66 124.4,20.81 124.4,16.56 124.73,16.23 125.56,16.23 PC8218.2 126.11,16.67 126.97,17.53 126.97,18.09 PC8219.1 127.06,19.06 PR8227.2
N38936486: length 7
  BOTTOM w0.102: PR8236.1 102.84,35.13 100.44,35.13 99.79,34.48 PU8201.3 v2(96.68,34.48)
N38936522: length 1
  BOTTOM w0.102: PR8244.1 136.72,24.16 PR8243.2
N39054084: length 2.4
  TOP w0.102: PR8245.1 v2(190.93,95.11)
  TOP w0.508: PR8245.1 190.32,95.43 PD8207.2
N39054087: length 4.3
  TOP w0.102: PD8207.1 187.04,96.75 v2(186.81,96.98)
  TOP w0.508: PR8246.1 190.68,96.75 PD8207.1
N39054316: length 3.5
  BOTTOM w0.102: PD8206.2 131.22,30.89 131.78,30.33 PR8247.2 133.22,31.5 PR8248.2
N39109711:
  vias: v2(174.48,34.8) v2(174.47,34.14) v2(175.04,35.13) v2(175.04,34.45) v2(175.67,34.98) v2(175.7,34.27) v2(176.34,34.98) v2(176.36,34.17) v2(177,34.96) v2(177.4,34.42) v2(177.78,34.93)
N39166693: length 1.3
  TOP w0.178: PU9502.12 154.17,33.52 PC9533.1
N39166694: length 1.2
  TOP w0.178: PC9534.1 154.97,33.54 PU9502.10
N39176871: length 19
  TOP w0.102: v1(136.3,85.17) 136.71,85.17 138.28,83.6 138.28,83.5 139.13,82.65 140.66,82.65 140.72,82.59 141.95,82.59 142.14,82.4 146.09,82.4 146.49,82.8 148.78,82.8 148.78,82.8 v2(149,82.8) 149.73,82.8 R472.1
  BOTTOM w0.079: U400.CJ31 135.59,83.41 135.72,83.54 135.87,83.7 135.87,83.99 135.66,84.19 135.52,84.19 135.31,84.4 135.31,84.63 135.38,84.7 135.38,84.99 135.31,85.05 135.31,85.29 135.47,85.45 136.02,85.45 v1(136.3,85.17)
N39250128: length 2.5
  TOP w0.102: U3600.2 216.12,13.93 215.7,14.35 214.74,14.35 R3606.1
N39250180: length 6.7
  TOP w0.102: U3600.3 216.12,13.53 215.93,13.71 215.93,13.83 215.62,14.14 215.18,14.14 214.53,13.49 213.29,13.49 212.88,13.08 R3607.1 212.63,13.11 212.12,13.63 212.12,14.2 v2(212.6,14.68)
N39252871: length 3.1
  TOP w0.203: C3616.1 223.71,9.67 v2(223.71,10.42) 223.46,10.67 222.79,10.67 222.34,11.13 U3600.22
N39252874: length 5.7
  TOP w0.203: U3600.21 222.26,10.73 222.46,10.52 222.46,9.92 v2(222.6,9.78) 223.65,8.73 C3615.2 223.2,8.19 223.2,7.43 R3612.2
N39253153: length 3.8
  TOP w0.102: U3600.27 222.32,13.13 223.03,13.83 224.02,13.83 224.79,14.59 C3617.2
N39253381: length 2.1
  TOP w0.102: U3600.28 222.32,13.53 223.18,14.39 C3618.2
N39253577: length 2.7
  TOP w0.102: C3618.1 222.58,15.59 222.13,15.14 222.13,14.48 221.98,14.33 U3600.30
N39254281: length 21.1
  IN1 w0.381: v2(221.19,7.47) 222.39,7.47 225.94,11.03 225.94,11.74 227.76,13.55 227.76,14.95 227.52,15.19 227.52,15.86 227.16,16.22 227.16,18.43 226.62,18.97 226.62,21.04 225.99,21.68 225.99,22.27 v2(226.14,22.42)
  BOTTOM w0.381: R3627.2 227.25,23.47 226.2,22.42 v2(226.14,22.42)
N39254866: length 4.5
  TOP w0.102: U3600.12 217.78,9.09 217.61,8.92 217.61,8.23 217.32,7.95 R3613.2 217.78,7.12 217.85,7.12 v2(218.12,6.85) R3614.1
N39255557: length 6.2
  TOP w0.102: U3600.6 216.09,12.33 215.83,12.06 215.83,12 214.92,11.08 214.92,10.98 214.61,10.67 213.96,10.67 C3623.2 213.05,11.59 211.74,11.59 v2(211.6,11.44)
N39257337: length 4.1
  TOP w0.102: C3628.1 223.32,16.59 222.98,16.59 v2(222.58,16.19) 222.36,16.41 221.67,16.41 221.13,15.87 220.85,15.87 220.79,15.8 220.79,15.8 220.59,15.6 U3600.32
N39257569:
  vias: v2(221.13,16.47)
N39257899:
  vias: v2(220.22,19.66)
N39295059:
  vias: v2(197.49,33.9)
N39295158: length 2.2
  BOTTOM w0.508: PR8615.1 188.93,25.64 v2(188.11,25.64) 187.7,25.23 PC8630.1
N39300434: length 5.5
  TOP w0.102: v2(217.5,24.91) 217.19,24.59 R3622.1 217.64,23.64 217.64,21.55 216.62,20.53 Q3600.1
N39300462: length 3.5
  TOP w0.102: R3623.1 212.23,18.66 v2(212.55,18.98) 212.75,19.18 213.34,19.18 214.18,20.03 Q3600.2
N39344253: length 7.7
  TOP w0.102: R3624.2 217.56,6.24 220.37,6.24 v2(220.72,6.6) 220.64,6.68 220.64,8.01 220.25,8.4 220.25,8.54 219.38,9.41 U3600.16
N39344256: length 1.9
  TOP w0.102: U3600.15 218.99,9.26 219.62,8.63 C3610.2
N39350388: length 4.4
  BOTTOM w0.102: PR9215.1 141.67,117.69 v2(141.76,117.59)
  BOTTOM w0.254: PU9202.4 141.25,115.61 140.89,115.97 PR9211.2 140.89,116.21 140.67,116.42 140.67,117.44 PR9215.1
N39350435: length 4.3
  BOTTOM w0.102: PR9217.1 147.82,115.41 147.43,115.8 PR9214.2 PR9216.1 146.41,116.26 v2(145.53,116.26) 145.52,116.26 PU9202.2
N39350871: length 2
  TOP w0.102: PR9618.1 136.64,115.5 v2(136.38,115.25) 136.13,115.25 135.81,114.92 PU9601.1
N39404743: length 7.8
  TOP w0.254: v2(75.83,107.24) 75.74,107.24 v2(74.2,108.78) 74.2,109.85 PR8908.1
  BOTTOM w0.254: PR8902.1 75.5,109.35 75.83,109.02 v2(75.83,107.24)
N39404748: length 62.3
  TOP w0.254: PR8908.2 PR8912.1 76.05,110.5 v2(75.85,110.7)
  IN1 w0.254: v2(50.69,115.5) 50.22,115.03 50.22,112.97 50.68,112.51 50.68,103.56 51.82,102.42 51.82,97.96 53.74,96.04 62.67,96.04 63.43,96.8 71.38,96.8 78.55,103.97 78.55,106.81 75.85,109.51 v2(75.85,110.7)
  BOTTOM w0.254: v2(50.69,115.5) 51.04,115.5 51.27,115.73 PC8912.1 51.83,115.73 PR8911.2
N39429458: length 3.5
  TOP w0.254: PR8127.1 38.72,79.91 38.34,80.29 38.34,82.1 38.61,82.37 PU8102.1
N39429526: length 4.8
  TOP w0.254: PR8127.2 38.09,78.79 37.57,79.3 PR8125.2 37.52,81.26 36.66,81.26 36.45,81.05 PQ8100.3
N39429563: length 5
  TOP w0.102: PU8102.2 39.48,81.72 39.73,81.46 39.73,80.7 40.5,79.93 PC8105.1 PR8121.1 41.5,78.56 PR8123.1
N39429571: length 3.3
  TOP w0.254: PQ8100.5 35.8,83.63 PR8126.2 35.54,83.75 35.15,83.35 PQ8100.6
N39429642: length 2.6
  TOP w0.305: PR8130.2 92.18,32.07 91.27,32.97 PD8101.1
N39429644: length 109
  TOP w0.305: PD8101.2 88.2,33.29 PR8129.1 87.43,36.43 82.71,36.43 82.02,35.74 55.1,35.74 54.59,36.25 50.4,36.25 46.69,39.96 46.69,42.35 52.56,48.21 52.56,48.95 52.31,49.21 v2(52,49.21) ; PQ8100.2 35.8,79.56 v2(35.92,79.43)
  BOTTOM w0.305: v2(52,49.21) 52,49.56 53.02,50.58 53.81,50.58 55.23,52 55.23,52.89 54.85,53.27 54.85,55.56 53.7,56.7 53.7,60.13 53.07,60.76 53.07,62.29 53.58,62.79 53.58,66.99 53.07,67.49 53.07,68.26 51.8,69.53 51.8,73.97 47.73,78.03 47.73,79.69 47.35,80.07 44.94,80.07 44.46,79.58 36.08,79.58 v2(35.92,79.43)
N39437629: length 2
  TOP w0.102: v2(32.1,99.68) 32.66,99.13 PR8862.1 PR8836.2
N39495583: length 34
  TOP w0.254: PR8927.1 74.18,115.8 74.17,115.81 PR8923.2 74.4,116.77 v2(74.84,116.77)
  IN2 w0.254: v2(74.84,116.77) 74.81,116.79 74.81,119.67 74.41,120.07 70.91,120.07 68.92,122.06 64.2,122.06 63.39,121.25 57.06,121.25 56.19,120.38 52.77,120.38 51.96,121.18 v2(51.49,121.18)
  BOTTOM w0.254: v2(51.49,121.18) 51.47,121.21 PC8925.1 51.47,122.07 52,122.6 v2(52.3,122.6) 52.73,122.6 PR8926.2
N39495593: length 42.7
  TOP w0.254: PR8928.2 PR8925.2 76.81,114.02 77,114.2 77,116.06 76.87,116.19 v2(76.87,116.54)
  IN2 w0.254: v2(76.87,116.54) 76.89,116.57 76.89,118.7 75.15,120.44 71.09,120.44 69.07,122.46 64.08,122.46 63.24,121.62 56.32,121.62 55.44,120.75 53,120.75 52.02,121.73 51.21,121.73 v2(50.65,121.17)
  BOTTOM w0.254: PR8929.2 PC8926.2 49.99,120.87 49.99,121.5 50.46,121.97 PC8925.2 50.77,121.89 50.77,121.29 v2(50.65,121.17) ; PR8919.1 76.87,118.52 v2(76.87,116.54)
N39496223: length 6
  TOP w0.254: PR8923.1 73.12,115.03 72.88,115.27 72.88,116.16 74.02,117.3 v2(74.25,117.3)
  BOTTOM w0.254: PR8918.1 74.25,118.87 v2(74.25,117.3)
N39496240: length 12.7
  TOP w0.254: v2(76.13,116.71) v2(76.13,115.6) 76.13,115.15 PR8925.1
  BOTTOM w0.254: v2(76.13,116.71) 75.93,116.92 75.93,120.1 80.23,124.4 80.23,125.21 PR8924.2
N39496246: length 12.7
  TOP w0.254: PR8928.1 75.47,115.07 75.23,115.31 PR8927.2 75.48,116.05 v2(75.48,116.71)
  BOTTOM w0.254: v2(75.48,116.71) 75.57,116.81 75.57,120.24 79.84,124.51 79.84,125.17 PR8924.1
N39505770: length 2.2
  TOP w0.102: PC8924.1 v2(68.93,118.12)
  TOP w0.508: PC8924.1 69,117.28 PR8917.2
N39507993: length 1.3
  BOTTOM w0.508: PC8911.1 69.62,114.49 PR8904.2
N39508098: length 59.7
  TOP w0.254: v2(76.84,107.19) 77.07,107.42 PR8910.2 PR8913.2
  IN1 w0.254: v2(76.84,107.19) 78.18,105.86 78.18,104.12 71.23,97.17 63.28,97.17 62.52,96.41 53.9,96.41 52.19,98.11 52.19,102.57 51.05,103.71 51.05,112.67 50.59,113.12 50.59,114.68 v2(50.72,114.81)
  BOTTOM w0.254: v2(50.72,114.81) 50.86,114.95 PC8912.2 51.56,114.74 50.9,114.08 PC8913.2 PR8914.2 ; PR8905.1 76.61,109.35 76.41,109.15 76.41,108.79 76.84,108.36 v2(76.84,107.19)
N39508207: length 7.2
  TOP w0.254: v2(77.35,110.8) 77.64,110.52 v2(77.64,109.9) 77.64,109.34 PR8910.1
  BOTTOM w0.254: PR8909.2 81.18,112.28 80.72,111.83 78.32,111.83 78.09,111.6 78.09,111.37 77.52,110.8 v2(77.35,110.8)
N39508213: length 8.2
  TOP w0.254: v2(77.35,111.44) 77.25,111.44 76.83,111.01 PR8912.2 76.06,109.14 PR8913.1
  BOTTOM w0.254: PR8909.1 80.63,112.23 77.86,112.23 77.35,111.72 v2(77.35,111.44)
N39511106: length 1.3
  BOTTOM w0.508: PC9015.1 60.49,107.12 60.61,107.24 PR9004.2
N39511208: length 27.9
  IN2 w0.254: v2(64.4,97.72) 63.87,97.72 61.93,95.78 53.75,95.78 51.85,97.68 51.85,104.57 52.67,105.39 v2(52.67,106.01)
  BOTTOM w0.254: v2(52.67,106.01) 52.68,106.02 53.16,106.02 PR9011.2 52.87,105.4 PC9016.1 ; v2(64.4,97.72) 64.04,97.72 63.86,97.9 PR9008.2 64.88,98.22 65.01,98.09 65.01,97.22 PR9012.1
N39511215: length 36.8
  IN2 w0.254: v2(52.38,104.37) 52.22,104.21 52.22,97.83 53.91,96.14 61.7,96.14 64.93,99.37 v2(68.03,99.37)
  BOTTOM w0.254: v2(68.03,99.37) 67.28,99.37 PR9010.2 PR9013.2 65.31,99 65.17,99.14 65.17,99.29 66.27,100.39 66.27,102.59 66.68,103 PR9006.1 ; PC9016.2 51.44,105.53 PC9017.2 50.56,105.4 51.39,104.57 PR9014.2 52.33,104.43 v2(52.38,104.37)
N39511310: length 7.3
  BOTTOM w0.102: PR9008.1 63.17,98.3 v2(63.01,98.3)
  BOTTOM w0.254: PR9005.1 65.31,102.97 65.69,102.6 65.69,100.82 PR9008.1
N39511324: length 2.1
  BOTTOM w0.102: v2(68,97.84) PR9009.2
  BOTTOM w0.254: PR9010.1 67.35,98.66 PR9009.2
N39511330: length 5.4
  BOTTOM w0.254: PR9013.1 65.9,97.74 65.65,97.5 PR9012.2 v2(66.72,97.08) 67.93,97.08 68.78,97.93 PR9009.1
N39518726: length 1.3
  BOTTOM w0.508: PC9032.1 109.82,129.77 PR9019.2
N39518792: length 7.9
  TOP w0.254: PC9033.1 114.29,119.24 PR9026.2 114.69,120.3 115.22,120.83 v2(115.22,121.08) 115.22,122.35 PR9027.1 114.18,123.25 112.5,124.93 PR9023.2
N39518799: length 20.1
  TOP w0.254: v2(118.32,126.24) 117.74,125.66 114.91,125.66 PR9028.2 PR9025.2 116.18,125.01 117.33,123.86 117.33,120.76 115.01,118.44 114.31,118.44 PC9033.2 113.25,119.12 112.28,118.16 PC9034.2 112.04,118.06 PR9029.2
  BOTTOM w0.254: v2(118.32,126.24) 118.35,126.27 PR9021.1
N39518892: length 4.2
  TOP w0.254: v2(116.11,126.27) 114.39,126.27 PR9023.1
  BOTTOM w0.254: PR9020.1 v2(116.11,126.27)
N39518906: length 2.9
  TOP w0.254: v2(116.85,122.99) 116.85,123.28 115.89,124.23 PR9025.1
  BOTTOM w0.254: PR9024.2 116.85,122.47 v2(116.85,122.99)
N39518912: length 4.6
  TOP w0.102: v2(116.18,122.98) 116.18,121.99 v2(116.53,121.64)
  TOP w0.254: v2(116.18,122.98) 115.91,123.25 PR9027.2 114.26,124.09 PR9028.1
  BOTTOM w0.254: PR9024.1 v2(116.18,122.98)
N39639429: length 8.7
  TOP w0.102: CN7603.7 38.2,25.32 36.7,23.82 33.02,23.82 R7636.1
N39639481: length 10.1
  TOP w0.102: CN7603.6 37.7,25.33 36.39,24.02 32.82,24.02 31.92,23.12 R7637.1 30.36,23.89 v2(29.35,23.89)
N40345900: length 11.6
  TOP w0.102: TP4707.1 195.28,58.1 v2(195.39,58.1) ; U4701.F10 204.26,54.91 v3(204.58,55.23)
  IN1 w0.076: 198.23,57.23 198.31,57.16 201.36,57.16 202.84,55.67 204.02,55.67 204.46,55.23 v3(204.58,55.23)
  IN1 w0.114: v2(195.39,58.1) 197.37,58.1 198.23,57.23
N40797009: length 2.3
  BOTTOM w0.102: U7601.4 65.62,124.56 v2(65.43,124.74) 65.09,125.09 R7628.2
N40803839: length 6.9
  TOP w0.102: Q7600.3 13.07,106.88 13.19,106.77 13.63,106.77 13.72,106.86 Q7600.2 13.72,108.36 13.42,108.67 C7616.1 R7618.1 R7617.2 v2(16.49,109.14)
N42265562: length 13.8
  BOTTOM w0.102: CN4000.13 240.32,85.56 239.12,84.36 236.71,84.36 235.51,85.56 CN4000.14 234.52,85.56 R4013.2 230.94,81.21 v2(230.31,80.59)
N42433669: length 13.3
  BOTTOM w0.102: CN4000.15 240.19,101.86 238.95,103.1 236.3,103.1 CN4000.16 233.59,101.86 231.21,104.24 R4012.2
N43333369: length 3.1
  TOP w0.102: Q3400.2 24.88,123.13 25.57,123.81 R3402.1 ; R3402.1 25.96,123.64 v2(26.7,123.64) ; R3402.1 25.79,124.21 25.69,124.31 R3400.1
N53993617: length 6.8
  BOTTOM w0.102: Q5002.2 138.72,19.97 138.72,22.08 139,22.36 Q5003.3 139,23.7 139.36,24.06 R5011.1 138.8,24.67 v2(138.68,24.55)
N54863788: length 10.4
  BOTTOM w0.079: TP404.1 140.38,76.8 139.62,76.8 138.67,77.75 135.53,77.75 134.3,78.99 134.3,79.76 134.39,79.86 134.39,79.94 134.3,80.04 134.3,80.32 U400.CG35
N55084151: length 1.9
  BOTTOM w0.102: TP4300.1 205.41,20.78 206.27,21.64 CN4300.68
N267342533: length 2.9
  TOP w0.102: U5300.11 68.54,24.03 68.26,24.31 68.26,25.28 TP5300.1
N396393270: length 8.4
  TOP w0.102: TP7606.1 28.84,25.63 28.84,25.17 29.29,24.72 30.97,24.72 31.09,24.83 34.7,24.83 35.2,25.33 CN7603.1
N396393460: length 9.4
  TOP w0.102: CN7603.2 35.7,25.33 35,24.63 31.19,24.63 31.07,24.52 29.11,24.52 28.01,25.62 TP7607.1
N396393590: length 9.7
  TOP w0.102: CN7603.4 36.7,25.11 36.01,24.43 31.29,24.43 31.17,24.31 28.56,24.31 TP7608.1
N396393720: length 6.9
  TOP w0.102: TP7609.1 31.67,24.22 36.14,24.22 37.2,25.28 CN7603.5
N447193501: length 1.8
  TOP w0.102: PR8840.1 PR8864.2 v2(32.66,95.97)
N3850189818: length 19.9
  TOP w0.079: 139.16,80 v1(139.16,80.4)
  TOP w0.102: TP428.1 155.56,78.54 153.87,78.54 153.7,78.71 152.37,78.71 152.1,78.44 150.22,78.44 148.1,80.56 144.67,80.56 143.31,79.2 140.97,79.2 140.62,79.55 139.38,79.55 139.16,79.76 139.16,80
  BOTTOM w0.079: v1(139.16,80.4) 138.88,80.68 U400.CR35
N4193523427: length 2.5
  TOP w0.102: v2(91.35,38.33) 90.97,37.95 TP2801.1
  BOTTOM w0.114: v2(91.35,38.33) JDIM2800.162
N4193523428: length 8.1
  TOP w0.102: TP2802.1 91.42,44.38 91.42,42.73 91.98,42.17 91.98,41.81 v2(91.5,41.33)
  BOTTOM w0.114: JDIM2800.165 92.1,44.28 92.46,43.93 92.46,42.7 91.5,41.74 v2(91.5,41.33)
N4193827027: length 2.1
  TOP w0.102: TP2800.1 168.66,37.98 v2(168.32,38.33)
  BOTTOM w0.114: v2(168.32,38.33) JDIM2801.162
N4193827028: length 3.2
  TOP w0.102: TP2803.1 169.16,42.49 v2(169.16,43.13)
  BOTTOM w0.114: v2(169.16,43.13) 169.08,43.21 169.08,44.19 169.07,44.2 JDIM2801.165

## Copper pours and planes (outline as drawn)
+1.0V_STG on BOTTOM (solid shape): 121.72,103.13 121.72,103.07 122.31,102.48 122.31,101.78 122.16,101.62 122.16,100.79 122.22,100.73 122.24,100.69 122.22,100.65 122.13,100.56 121.75,100.56 121.59,100.73 121.59,101.34 121.55,101.38 121.55,101.83 121.55,101.93 121.55,102.21 121.49,102.27 121.48,102.3 121.48,102.31 121.32,102.62 120.98,102.6 120.81,102.6 120.61,102.8 120.61,103.03 120.86,103.28 121.57,103.28
+1.2V_VCCPLL_OC on TOP (solid shape): 123.48,72.07 124.19,72.07 124.21,72.09 124.27,72.09 124.39,71.96 124.39,71.23 125.74,69.88 125.74,69.87 126.53,69.08 126.53,66.96 126.59,66.9 126.6,66.88 126.6,66.86 126.6,64.5 124.98,62.87 124.98,62.41 124.62,62.06 124.62,61.14 124.39,60.92 123.06,60.92 122.64,60.5 122.62,60.49 122.6,60.48 121.93,60.48 121.85,60.56 120.3,60.56 120.15,60.71 120.15,61.62 120.18,61.68 120.2,61.75 120.71,62.26 120.74,62.27 123.03,62.77 124.76,64.36 124.76,64.36 125.36,64.95 125.36,65.78 125.36,65.78 125.47,66.79 125.36,67.79 125.36,67.8 125.36,68.66 124.69,69.33 124.69,69.33 124.15,69.99 123.49,70.53 123.49,70.53 123.27,70.74 123.27,71.94 123.43,72.09 123.46,72.09
+1.2VSUS on TOP (solid shape): 121.7,39.78 121.7,39.43 121.6,39.32 121.42,39.32 121.12,39.02 120.91,39.02 120.86,39.07 120.86,39.43 120.66,39.63 120.66,39.88 120.79,40.01 121.47,40.01
+1.2VSUS on TOP (solid shape): outline of 4607 points within 67.85,59.54 123.2,83.37
+1.2VSUS on TOP (solid shape): outline of 17343 points within 48.19,31.58 188.7,49.51
+1.2VSUS on BOTTOM (solid shape): 149.73,21.61 149.73,20.85 149.23,20.35 146.8,20.35 146.69,20.45 146.69,20.96 146.87,21.14 148.85,21.14 149.45,21.74 149.6,21.74
+1.2VSUS on BOTTOM (solid shape): 106.28,38.49 106.28,38.23 105.98,37.92 105.98,36.15 105.95,36.13 105.76,36.13 105.73,36.16 105.73,38.43 105.89,38.6 106.18,38.6
+1.2VSUS on BOTTOM (solid shape): 148.47,34.68 148.47,32.21 148.24,31.98 144.66,31.98 144.23,32.42 144.23,33.1 144.41,33.29 144.85,33.29 145.03,33.46 145.03,34.47 145.53,34.98 148.17,34.98
+1.2VSUS on BOTTOM (solid shape): outline of 119 points within 203.26,106.12 210.04,113.82
+1.2VSUS on BOTTOM (solid shape): outline of 4705 points within 48.22,35.9 108.2,64.19
+1.2VSUS on SVCC (solid shape): outline of 398 points within 92.67,31.65 171.97,47.58
+1.2VSUS on IN1 (solid shape): outline of 340 points within 140.34,19.34 152.26,34.3
+1.2VSUS on IN2 (solid shape): 149.02,32.85 149.02,31.86 148.79,31.64 144.75,31.64 144.17,32.22 144.17,33.25 144.18,33.28 144.22,33.3 148.57,33.3
+1.2VSUS_S on BOTTOM (solid shape): 138.92,34.93 138.92,32.03 139.18,31.78 140.67,31.78 140.93,32.03 140.93,32.44 140.57,32.8 140.24,32.8 140.19,32.85 140.19,33.69 140.37,33.86 142.53,33.86 143.04,34.37 143.65,34.37 143.77,34.5 144.51,34.5 144.61,34.4 144.61,33.56 144.55,33.5 144.47,33.5 144.13,33.15 144.13,27.79 144,27.67 142.12,27.67 141.92,27.87 141.92,28.68 141.83,28.77 141.3,28.77 141.23,28.71 141.23,28.22 141.13,28.12 139.81,28.12 139.05,28.89 135.82,28.89 135.11,29.6 134.04,29.6 133.87,29.77 133.87,30.42 134.45,31 134.48,31.03 134.51,31.06 135.34,31.89 135.34,32.37 135.36,32.39 135.36,34.85 135.59,35.08 138.77,35.08
+1.05V_DEEP_SUS on TOP (solid shape): 139.89,108.67 139.89,106.23 139.71,106.05 136.41,106.05 135.62,106.84 135.62,107.37 135.31,107.68 134.76,107.68 134.53,107.45 134.53,107.07 134.11,106.65 134.05,106.6 133.99,106.53 133.87,106.41 133.64,106.41 133.36,106.13 132.98,106.13 132.82,106.28 132.82,106.86 132.39,107.29 132.39,108.51 132.49,108.62 132.5,108.62 132.68,108.79 134.98,108.79 136.05,109.86 138.69,109.86
+1.05V_DEEP_SUS on BOTTOM (solid shape): outline of 494 points within 136.79,103.82 158.3,129.61
+1.05V_DEEP_SUS on BOTTOM (solid shape): outline of 979 points within 125.17,89.13 132.28,95.63
+1.05V_DEEP_SUS on SVCC (solid shape): outline of 126 points within 117.08,90.93 154.57,129.62
+1.05V_DEEP_SUS_S on BOTTOM (solid shape): outline of 109 points within 139.96,118.39 147.38,128.29
+1.05V_LAN_R on TOP (solid shape): 189.33,67.43 189.34,67.41 189.34,67.39 189.34,67.36 189.34,67.23 189.4,67.09 189.55,67.03 189.65,67.02 189.7,67.02 189.74,67.02 189.8,66.96 190.1,66.96 190.18,66.88 190.18,66.43 190.05,66.3 189.52,66.3 189.19,66.63 188.25,66.63 188.2,66.67 188.19,66.7 188.19,66.72 188.2,66.76 188.2,66.81 188.2,67.19 188.24,67.22 188.27,67.26 188.35,67.34 188.35,67.8 188.4,67.85 188.91,67.85
+1.05V_LAN_R on BOTTOM (solid shape): 198.36,69.09 198.36,69.05 198.35,69.04 198.26,68.76 198.37,68.5 198.38,68.48 198.38,68.38 198.27,68.27 198.26,68.02 198.27,67.95 198.27,66.85 198.49,66.64 198.49,66.4 198.74,66.15 198.98,66.15 198.98,66.1 199.09,65.84 199.36,65.74 199.38,65.74 199.46,65.66 200.16,65.66 200.33,65.48 200.33,63.93 200.08,63.68 198.38,63.68 198.12,63.94 198.12,64.9 196.66,66.37 196.66,68.72 196.78,68.85 196.88,68.85 196.96,68.84 197.04,68.85 197.48,68.85 197.77,69.14 198.31,69.14
+1.05V_LAN_REGOUT on TOP (solid shape): 192.33,65.81 193.3,65.81 193.34,65.8 193.35,65.76 193.35,65.55 193.32,65.52 193.32,64.77 192.87,64.32 192.87,64.26 192.86,64.23 192.82,64.21 192.54,64.05 192.51,63.74 192.49,63.65 192.41,63.6 192.39,63.6 192.32,63.54 191.9,63.54 191.6,63.84 191.17,63.84 190.96,64.04 190.59,64.04 190.37,64.26 190.37,64.77 190.37,64.79 190.39,64.81 190.45,64.84 190.46,64.89 190.48,64.94 191.05,65.51 191.85,65.51 192.16,65.82 192.33,65.82
+1.05V_LAN_REGOUT on BOTTOM (solid shape): 197.25,65.57 197.25,63.85 197.08,63.68 195.99,63.68 195.84,63.83 195.84,64.06 195.47,64.43 194.84,64.43 193.8,63.39 192.07,63.39 190.98,64.48 190.98,65.38 191.39,65.79 197.04,65.79
+1.8V on TOP (solid shape): 222.61,21.62 222.61,20.6 222.87,20.35 222.87,19.84 222.64,19.61 221.6,19.61 221.51,19.71 221.51,21.27 221.78,21.53 221.78,21.85 221.85,21.93 222.31,21.93
+1.8V on TOP (solid shape): 198.22,38.1 198.22,37.12 198,36.9 197.46,36.9 197.12,37.24 196.4,37.24 195.14,35.98 194.88,35.98 194.88,35.97 194.57,35.97 194.29,36.25 194.29,36.68 194.38,36.77 194.9,36.77 195.95,37.82 195.99,37.82 196.46,38.3 198.03,38.3
+1.8V on BOTTOM (solid shape): 152.97,90.35 152.97,90.1 152.71,89.84 152.71,88.7 152.99,88.43 152.99,86.12 151.43,84.56 150.63,84.56 150.48,84.71 150.48,85.04 150.63,85.2 151.37,85.2 151.5,85.33 151.52,85.33 151.75,85.43 151.85,85.66 151.85,85.68 152.03,85.86 152.03,88.63 151.56,89.09 151.56,89.75 151.62,89.81 151.84,89.81 151.93,89.9 151.94,89.9 152.15,90 152.25,90.21 152.26,90.23 152.48,90.45 152.87,90.45
+1.8V on IN1 (solid shape): 198.78,38.65 198.78,37.68 198.79,37.67 198.79,36.45 198.56,36.23 198.38,36.23 197.38,37.24 197.38,37.83 198,38.46 198,38.72 198.01,38.76 198.05,38.77 198.66,38.77
+1.8V on IN1 (solid shape): outline of 272 points within 176.07,62.88 178.87,70.03
+1.8V on IN1 (solid shape): outline of 558 points within 141.18,84.41 175.78,92.47
+1.8V_DEEP_SUS on TOP (solid shape): 151.18,35.17 151.18,34.15 151.47,33.87 151.47,33.18 151.24,32.95 150.28,32.95 150.06,33.16 150.06,33.46 150.12,33.65 150.07,33.84 150.07,34.96 150.4,35.29 151.06,35.29
+1.8V_DEEP_SUS on TOP (solid shape): 137.96,73.76 137.96,73.41 137.54,72.99 137.54,72.72 137.44,72.63 137.44,71.7 137.34,71.59 136.87,71.59 136.76,71.7 136.76,72.33 136.54,72.55 136.53,72.61 136.58,72.64 136.63,72.64 136.63,73.22 136.35,73.22 136.15,73.42 136.15,73.8 136.25,73.9 136.26,73.9 136.35,73.93 136.43,73.98 137.74,73.98
+1.8V_DEEP_SUS on TOP (solid shape): outline of 123 points within 141.46,71.33 161.4,86.39
+1.8V_DEEP_SUS on BOTTOM (solid shape): 132.66,93.95 132.66,93.9 132.97,93.59 133.06,93.59 133.08,93.57 133.09,93.56 133.16,93.45 133.27,93.39 133.33,93.34 133.34,93.26 133.33,93.12 133.4,93 133.41,92.99 133.43,92.95 133.43,92.37 133.41,92.33 133.4,92.32 133.32,92.14 133.4,91.96 133.41,91.95 133.43,91.92 133.43,91.8 133.42,91.78 133.37,91.6 133.42,91.42 133.43,91.41 133.43,91.33 133.41,91.29 133.37,91.25 133.35,91.21 133.34,91.18 133.29,91.13 133.29,91 132.95,90.66 132.08,90.66 132.07,90.68 132.01,90.77 131.93,90.83 131.92,90.84 131.91,90.86 131.91,91.11 131.91,91.13 131.93,91.15 132.05,91.4 131.93,91.66 131.91,91.67 131.91,91.7 131.91,91.95 131.91,91.97 131.93,91.99 131.98,92.03 132.02,92.1 132.36,92.44 132.36,92.8 132.05,93.11 132.05,93.13 132.01,93.25 131.91,93.35 131.9,93.35 131.88,93.39 131.88,93.51 132.12,93.75 132.12,94.02 132.18,94.08 132.24,94.11 132.5,94.11
+1.8V_DEEP_SUS on IN1 (solid shape): 164.92,89.45 165.01,89.39 165,89.29 165.29,88.69 165.58,89.29 165.56,89.39 165.65,89.45 166.59,89.45 166.79,89.26 166.79,87.14 166.62,86.97 166.41,86.97 165.16,88.21 164.85,88.21 164.69,88.37 164.57,88.37 164.48,88.43 164.5,88.54 164.47,89.06 163.95,89.04 163.89,89 163.81,89.02 163.25,88.88 163.53,88.37 163.55,88.37 163.56,88.35 163.58,88.32 163.56,88.28 163.49,88.21 161.8,88.21 161.52,88.49 161.52,88.59 161.57,88.68 161.67,88.68 161.9,88.63 162.1,88.72 162.17,88.75 162.24,88.72 162.76,88.75 162.73,89.27 162.71,89.39 162.8,89.45
+1.8V_DEEP_SUS on IN1 (solid shape): outline of 172 points within 141.46,56.84 152.59,73.31
+1.8V_DEEP_SUS on IN1 (solid shape): outline of 525 points within 132.09,85.22 159.01,94.19
+1.8V_DEEP_SUS on IN1 (solid shape): outline of 1130 points within 150.05,32.47 191.8,50.2
+1.8VPCU on TOP (solid shape): 153.45,30.59 153.45,29.9 153.48,29.88 153.58,29.88 153.6,29.9 153.67,29.9 153.67,29.97 153.68,29.98 153.68,30.64 153.7,30.66 153.81,30.66 153.86,30.61 153.86,29.83 153.49,29.46 153.49,29.37 153.47,29.33 153.44,29.32 153.11,29.32 153.1,29.32 152.98,29.35 152.86,29.34 152.75,29.34 152.35,28.94 152.23,28.94 152.11,29.06 152.11,29.49 152.03,29.57 152.03,29.81 152.08,29.94 152.08,30.08 152.09,30.1 152.1,30.12 152.21,30.23 152.66,30.23 153.12,30.69 153.35,30.69
+1.8VPCU on TOP (solid shape): 155.42,30.69 155.45,30.67 155.47,30.64 155.47,29.9 155.67,29.9 155.67,30.64 155.68,30.67 155.72,30.69 155.89,30.69 156.24,30.33 156.25,30.33 156.28,30.31 156.45,30.31 156.46,30.29 156.54,30.22 156.63,30.2 156.93,30.2 157.02,30.22 157.09,30.29 157.11,30.31 158.51,30.31 158.68,30.14 158.68,29.26 158.5,29.09 157.84,29.09 157.76,29.12 157.74,29.21 157.45,29.62 157.04,29.34 157.04,29.33 156.88,29.18 156.49,29.18 156.47,29.16 155.69,29.16 155.59,29.26 155.59,29.45 155.28,29.76 155.28,30.64 155.33,30.69
+2.5VSUS on TOP (solid shape): 166.01,62.67 166.01,61.78 165.78,61.55 163.18,61.55 162.87,61.85 162.87,62.77 162.89,62.81 162.92,62.83 165.86,62.83
+2.5VSUS on TOP (solid shape): 193.28,44.68 193.28,42.93 193.12,42.78 192.72,42.78 192.44,42.5 191.52,42.5 191.3,42.73 191.3,43.08 192.24,44.02 192.24,44.51 192.44,44.71 193.25,44.71
+2.5VSUS on BOTTOM (solid shape): 166.3,53.98 166.3,52.61 166.12,52.43 164.45,52.43 164.27,52.61 164.27,53.77 164.31,53.86 164.41,53.87 164.81,53.97 164.84,54.39 164.84,54.87 164.85,54.91 164.89,54.92 165.36,54.92
+2.5VSUS on BOTTOM (solid shape): outline of 488 points within 163.51,40.42 192.92,43.78
+2.5VSUS on IN1 (solid shape): 165.06,62.15 165.06,60.81 166.19,59.68 166.19,56.53 166.2,56.52 166.2,54.16 165.91,53.87 165.06,53.87 164.89,54.03 164.88,54.05 164.88,54.08 164.87,54.35 164.68,54.54 164.67,54.55 164.65,54.57 164.65,58.88 164.58,58.95 164.53,59.02 164.46,59.07 164.32,59.21 163.36,59.21 162.7,59.87 162.7,62.28 163.06,62.64 164.57,62.64
+2.5VSUS_S on TOP (solid shape): 167.72,62.43 168.06,62.43 168.49,62.01 169.12,62.01 169.27,61.85 169.27,60.43 169.02,60.18 163.64,60.18 163.58,60.23 163.58,60.48 163.3,60.76 162.54,60.76 162.31,60.53 162.11,60.53 162.08,60.57 162.06,60.59 162.07,60.62 162.08,60.65 162.08,61.23 162.05,61.25 162.05,61.26 162.04,61.29 162.06,61.32 162.21,61.47 162.92,61.47 163.08,61.32 166.05,61.32 166.43,61.7 166.43,62.69 166.56,62.83 167.32,62.83
+3V on TOP (solid shape): 113.47,41.86 113.47,41.41 113.01,40.95 113.01,39.58 112.96,39.53 112.1,39.53 112,39.63 112,40.34 111.57,40.77 111.57,41.59 112,42.02 113.32,42.02
+3V on TOP (solid shape): 138.05,69.01 138.05,68.09 137.89,67.94 137.13,67.94 136.83,68.24 136.82,68.24 136.71,68.35 136.71,68.68 136.83,68.8 136.99,68.8 137.29,69.1 137.96,69.1
+3V on TOP (solid shape): 161.32,99.27 161.32,98.53 161.02,98.23 159.14,98.23 156.98,96.07 156.27,96.07 155.73,96.6 155.73,96.93 155.82,97.02 157.04,97.02 157.25,97.22 157.25,97.71 158.86,99.32 161.27,99.32
+3V on TOP (solid shape): 45.75,34.4 45.75,33.41 45.42,33.08 44.18,33.08 43.92,32.82 43.92,31.81 43.9,31.77 43.87,31.76 43.72,31.76 43.72,31.76 43.72,32.75 43.7,32.77 43.7,33.34 44.03,33.67 44.03,34.55 44.04,34.59 44.08,34.6 45.55,34.6
+3V on TOP (solid shape): 212.38,86.19 212.38,85.68 212.89,85.17 212.89,83.23 212.72,83.07 211.89,83.07 211.44,83.52 211.44,83.98 211.85,84.39 211.89,84.42 211.92,84.46 212.01,84.55 212.01,84.98 211.86,85.13 211.13,85.13 210.88,85.38 210.88,85.75 211.06,85.92 211.5,85.92 211.67,86.09 211.67,86.29 211.74,86.37 212.2,86.37
+3V on TOP (solid shape): 215.01,94.95 215.12,94.95 215.13,94.94 215.23,94.89 215.34,94.88 215.91,94.88 215.98,94.95 217.28,94.95 217.43,94.8 217.43,94.34 217.28,94.19 215.39,94.19 215.29,94.28 214.56,94.28 214.51,94.28 214.34,94.26 214.32,94.26 214.15,94.43 214.15,94.86 214.38,95.1 214.86,95.1
+3V on TOP (solid shape): 191.14,42.65 191.14,41.97 191.04,41.86 190.58,41.86 190.48,41.76 190.48,41.46 190.31,41.28 189.85,41.28 189.8,41.23 189.8,40.68 189.76,40.6 189.67,40.58 189.48,40.58 189.31,40.49 189.2,40.46 189.14,40.56 189.14,41.71 190.2,42.78 191.02,42.78
+3V on TOP (solid shape): 182.1,35.84 182.1,35.78 182.02,35.69 182.02,34.86 182.1,34.77 182.1,34.55 181.77,34.21 181.77,33.15 181.74,33.12 181.73,33.11 181.61,33.04 181.57,32.92 181.57,32.64 181.59,32.55 181.65,32.48 181.68,32.4 181.65,32.33 181.56,32.23 181.56,31.75 181.74,31.58 181.99,31.58 181.99,30.32 181.42,29.75 180.48,29.75 180.2,30.03 180.2,34.47 181.69,35.97 181.97,35.97
+3V on TOP (solid shape): 36.72,126.68 36.73,126.67 36.8,126.6 36.89,126.58 37.17,126.58 37.2,126.58 37.23,126.59 37.26,126.59 37.28,126.57 37.4,126.46 37.4,125.99 37.47,125.92 37.47,125.79 37.53,125.65 37.67,125.59 37.95,125.59 38.01,125.6 38.07,125.62 38.08,125.63 38.54,125.63 38.74,125.43 38.74,123.91 38.56,123.73 37.65,123.73 35.36,121.44 35.01,121.44 34.17,122.28 34.17,123.32 34.25,123.4 34.25,124.97 34.9,125.63 34.9,126.38 35.21,126.69 36.7,126.69
+3V on TOP (solid shape): 47,92.59 47.03,92.57 47.05,92.54 47.05,90.66 50.1,87.61 50.1,87.24 51.16,86.17 51.16,79.2 50.91,78.95 48.27,78.95 48.07,79.15 48.07,81.01 48.17,81.26 48.07,81.51 48.07,85.45 44.2,89.31 44.2,91.91 44.24,91.96 44.29,91.95 44.31,91.93 44.8,91.92 44.83,92.42 44.81,92.43 44.81,92.5 44.83,92.54 44.87,92.55 46.46,92.55 46.51,92.56 46.62,92.57 46.66,92.57 46.7,92.59
+3V on TOP (solid shape): 212.12,17.99 212.18,17.99 212.22,17.97 212.25,17.95 212.38,17.88 212.55,17.86 212.57,17.85 212.71,17.71 214.99,17.71 215.22,17.48 215.22,17 215.5,16.72 215.86,16.72 216.01,16.57 216.01,16.31 216.06,16.27 216.06,16.25 216.12,16.12 216.24,16.06 216.26,16.06 216.31,16.01 216.77,16.01 217.05,15.73 217.05,14.36 216.92,14.23 216.16,14.23 216.06,14.33 216.06,14.86 215.82,15.1 215.81,15.12 215.81,15.15 215.82,15.17 215.81,15.46 215.58,15.65 215.52,15.69 215.51,15.77 215.43,16.07 215.13,16.19 214.84,16.07 214.76,15.76 214.76,15.73 214.75,15.71 214.63,15.59 214.5,15.59 214.28,15.8 214,15.8 213.93,15.88 213.93,16.19 213.62,16.49 212.43,16.49 212.41,16.5 212.38,16.55 212.35,16.59 212.25,16.66 212.13,16.7 212.12,16.7 211.93,16.89 211.93,17.28 211.92,17.34 211.91,17.4 211.76,17.68 211.48,17.83 211.45,17.85 211.44,17.88 211.44,18.06 211.51,18.14 211.97,18.14
+3V on TOP (solid shape): 204.59,15.47 204.61,15.47 204.63,15.45 204.71,15.38 204.8,15.33 204.81,15.32 204.94,15.19 204.94,14.41 204.92,14.38 204.91,14.38 204.78,14.28 204.72,14.13 204.71,14.02 204.74,13.92 204.74,13.9 204.74,13.88 204.73,13.85 204.72,13.85 204.57,13.66 204.52,13.42 204.52,13.21 204.49,13.18 204.45,13.17 204.01,13.14 203.93,12.71 203.94,12.63 203.89,12.57 203.7,12.31 203.79,12.01 203.93,11.88 204.13,11.85 204.15,11.84 205.34,10.65 205.34,8.16 205.3,8.08 205.21,8.07 205.12,8.08 205.04,8.08 204.95,8.05 204.87,8 204.73,7.59 205.09,7.34 205.12,7.34 205.14,7.32 205.15,7.26 205.12,7.2 204.68,6.76 203.56,6.76 203.23,7.09 203.23,10.88 203.11,11.01 203.11,12.41 203.34,12.64 203.34,12.73 203.39,12.78 203.39,13.57 203.74,13.92 203.85,13.92 203.85,13.92 203.96,13.92 204.08,14.05 204.08,15.26 204.3,15.47
+3V on TOP (solid shape): outline of 214 points within 55.85,23.6 68.46,34.73
+3V on BOTTOM (solid shape): 45.58,27.36 45.58,26.09 45.45,25.96 44.81,25.96 44.69,26.09 44.69,27.36 44.81,27.49 45.45,27.49
+3V on BOTTOM (solid shape): 135.34,68.82 135.34,67.4 135.11,67.17 134.64,67.17 134.44,67.37 134.44,68.56 134.86,68.99 135.18,68.99
+3V on BOTTOM (solid shape): 138.74,68.81 140.91,68.81 141.33,68.39 141.33,68 140.99,67.66 137.47,67.66 136.72,68.41 136.72,68.69 137.08,69.05 138.5,69.05
+3V on BOTTOM (solid shape): 162.59,51.77 162.59,50.65 159.29,47.35 146.77,47.35 146.26,47.86 146.26,49.26 146.87,49.87 158.05,49.87 159.9,51.72 159.9,52.15 159.98,52.23 162.14,52.23
+3V on BOTTOM (solid shape): 167.89,99.58 167.89,98.27 167.51,97.88 167.51,95.75 167.13,95.37 165.95,95.37 165.25,96.07 165.25,99.84 165.79,100.39 167.09,100.39
+3V on BOTTOM (solid shape): 157.13,97.59 157.13,96.04 156.98,95.89 156.49,95.89 156.47,95.89 156.46,95.91 156.3,96.06 156.3,97.18 155.42,98.06 155.42,98.48 155.53,98.58 156.14,98.58
+3V on BOTTOM (solid shape): 66.25,127.23 66.25,125.31 66.2,125.26 65.12,125.26 64.93,125.46 63.4,125.46 62.34,125.46 62.19,125.61 62.19,126.6 62.34,126.75 63.41,126.75 63.6,126.94 63.6,127.3 63.71,127.41 66.07,127.41
+3V on BOTTOM (solid shape): 79.56,83.11 79.56,82.65 79.54,82.52 79.53,82.4 79.53,80.95 79.32,80.74 77.36,80.74 76.03,82.07 76.03,82.23 76.53,82.73 76.53,83.62 77.5,84.59 78.09,84.59
+3V on BOTTOM (solid shape): 203.8,11.83 204.37,11.83 205.4,10.8 205.4,9.94 205.21,9.76 204.78,9.76 204.63,9.61 204.4,9.61 204.24,9.77 203.02,9.77 202.8,9.99 202.8,10.7 203.06,10.95 203.06,11.66 203.13,11.74 203.26,11.74 203.39,11.88 203.75,11.88
+3V on BOTTOM (solid shape): 213.51,94.94 213.72,94.84 213.95,94.89 214.05,94.9 214.1,94.81 214.1,94.46 213.63,93.99 211.51,93.99 211.08,94.42 211.08,95.33 211.21,95.46 212.99,95.46
+3V on BOTTOM (solid shape): 162.09,100.23 162.11,100.12 162.02,100.06 161.66,99.75 161.92,99.36 161.95,99.34 161.96,99.31 162.1,99.03 162.41,98.98 162.44,98.97 163.01,98.4 163.01,95.51 162.64,95.14 162.62,95.13 162.6,95.13 162.31,95.13 161.96,95.48 161.96,96.97 161.77,97.16 160.47,97.16 160.42,97.11 159.63,97.11 159.6,97.13 159.59,97.15 159.48,97.38 159.24,97.47 159.22,97.49 159.22,98.41 160.35,99.53 161.5,100.69 161.63,100.69
+3V on BOTTOM (solid shape): 66.68,29.95 66.68,28.6 65.85,27.77 65.85,26.7 66.35,26.2 66.35,25.94 66.2,25.79 64.5,25.79 63.95,25.24 63.33,25.24 63.03,25.04 63.06,24.68 63.07,24.57 62.98,24.52 62.1,24.52 62,24.57 62.02,24.68 61.89,25.24 61.39,24.97 61.35,24.91 61.28,24.89 61.01,24.81 60.88,24.56 60.86,24.53 60.83,24.52 59.75,24.52 59.6,24.67 59.6,26.47 59.85,26.73 61.65,26.73 61.68,26.75 63.71,26.75 63.86,26.9 63.86,28.27 63.88,28.31 63.91,28.33 64.33,28.33 64.41,28.4 64.85,28.4 65.19,28.74 65.21,28.75 65.36,28.84 65.45,28.99 65.45,29 65.51,29.06 65.51,29.9 65.79,30.18 66.45,30.18
+3V on BOTTOM (solid shape): outline of 240 points within 159.6,6.12 173.1,22.71
+3V on BOTTOM (solid shape): outline of 1518 points within 26.59,88.58 47.13,124.12
+3V on SVCC (solid shape): 185.69,12.16 185.73,12.13 185.77,12.12 189.39,8.49 189.43,8.47 189.47,8.46 198.48,8.46 198.52,8.47 198.56,8.49 199.95,9.89 199.98,9.93 199.98,9.97 199.98,11.57 201.19,12.78 203.01,12.78 203.76,12.03 203.81,11.98 203.86,11.94 203.87,11.92 203.9,11.9 203.94,11.89 204.01,11.87 204.08,11.87 205.24,10.71 205.24,6.51 205.2,6.49 205.16,6.46 204.82,6.12 187.22,6.12 185.73,7.18 185.73,7.99 184.84,10.13 182.7,11.02 177.11,11.02 175.97,10.8 174.99,10.16 170.84,6.12 146.22,6.12 144.73,7.18 144.73,7.99 144.72,8.3 144.67,8.62 144.78,8.73 149.99,8.73 150.2,8.67 150.42,8.73 150.58,8.73 150.84,8.63 151.1,8.73 159.3,8.73 159.72,8.31 159.93,8.24 160.12,8.36 166.38,8.36 166.64,8.1 166.68,8.07 166.73,8.06 168.89,8.06 168.94,8.07 168.99,8.1 171.43,10.54 171.66,10.57 171.83,10.72 172.6,10.72 172.65,10.73 172.69,10.76 175.02,13.09 184.77,13.09
+3V on SVCC (solid shape): 156.98,52.28 157.08,52.16 157.22,52.13 176.58,52.13 176.84,52.02 177.1,52.13 181.61,52.13 181.87,51.87 181.96,51.48 182.35,51.39 182.56,51.18 182.67,51.12 182.8,51.12 188.96,44.96 188.96,44.18 188.75,43.87 188.92,43.53 188.75,43.24 188.87,42.92 188.66,42.53 188.96,42.21 188.96,41.89 188.11,41.04 188.08,41 188.07,40.95 188.07,39.99 187.42,39.34 187.24,39.23 187.14,39.05 181.89,33.8 181.86,33.76 181.85,33.71 181.85,33.33 181.85,32.44 181.85,31.08 181.78,31.02 181.59,31.02 180.11,31.02 179.95,31.18 180.04,31.48 179.87,31.74 180.03,32.17 179.66,32.44 179.66,34.94 184.46,39.73 184.48,39.77 184.49,39.81 184.49,41.54 184.79,41.84 185.04,41.84 186.01,42.81 186.01,43.87 186.01,43.91 185.98,43.94 180.52,49.4 180.49,49.43 180.44,49.43 156.24,49.43 155.41,50.26 155.41,51.45 156.24,52.28
+3V on IN1 (solid shape): 37.96,123.37 37.96,122.79 37.54,122.38 37.5,122.34 37.46,122.3 36.84,121.67 34.4,121.67 34.06,122.01 34.06,123.83 34.16,123.93 37.4,123.93
+3V on IN1 (solid shape): 176.32,100.44 177.88,100.44 178.14,100.18 178.14,99.73 178.12,99.7 178.09,99.68 175.95,99.68 175.87,99.72 175.85,99.81 175.8,100.11 175.54,100.26 175.48,100.3 175.45,100.36 175.18,100.72 174.76,100.55 174.67,100.5 174.59,100.55 173.9,100.36 174.59,100.18 174.67,100.23 174.76,100.18 174.88,100.05 175.04,100 175.1,99.96 175.13,99.9 175.13,99.85 175.14,99.81 175.12,99.72 175.04,99.68 171.35,99.68 171,100.03 171,100.74 171.27,101.01 175.75,101.01
+3V on IN1 (solid shape): outline of 198 points within 211.27,83.6 214.13,95.05
+3V on IN1 (solid shape): outline of 244 points within 144.16,93.91 157.49,97.24
+3V on IN1 (solid shape): outline of 472 points within 47.81,72.45 78.62,85.43
+3V on IN1 (solid shape): outline of 628 points within 203.08,9.1 215.48,17.61
+3V on IN2 (solid shape): 166.99,95.86 166.99,95.56 166.51,95.08 162.4,95.08 162.11,95.37 162.11,95.66 162.57,96.12 166.73,96.12
+3V on IN2 (solid shape): 203.65,12.17 203.68,12.16 203.7,12.14 203.78,11.99 203.92,11.9 203.94,11.91 203.95,11.9 204.23,11.92 204.42,12.12 204.43,12.14 204.46,12.16 204.61,12.16 204.69,12.12 204.71,12.05 205.08,11.64 205.45,12.05 205.47,12.12 205.55,12.16 205.61,12.16 205.65,12.17 205.85,12.17 206.82,11.2 206.85,11.11 206.88,11.05 206.88,9.46 206.25,8.83 205.12,8.83 204.89,9.05 204.52,9.05 202.85,10.73 202.82,10.81 202.86,10.88 203.02,11.16 202.89,11.46 202.86,11.54 202.89,11.61 202.93,11.65 202.96,11.7 202.98,11.72 203.01,11.73 203.26,11.83 203.41,12.14 203.47,12.17
+3V on IN2 (solid shape): outline of 325 points within 44.31,23.06 60.69,33.9
+3V on IN2 (solid shape): outline of 849 points within 168.92,21.28 181.62,33.76
+3V_+1.8V_CR on TOP (solid shape): 40.11,33.33 40.11,33.15 41.82,31.45 41.82,31.3 41.79,31.27 40.91,31.27 40.65,31.53 40.65,31.79 40.29,32.16 38.9,32.16 38.79,32.26 38.79,32.99 38.75,33.04 38.02,33.04 37.89,33.17 37.89,33.58 38.03,33.72 38.62,33.72 38.67,33.76 38.67,34.13 38.83,34.29 39.16,34.29
+3V_+1.8V_CR on TOP (solid shape): 42.32,28.51 42.32,27.56 42.32,27.56 42.32,27.37 42.02,27.06 42.01,27.05 41.89,26.97 41.82,26.86 41.8,26.84 41.28,26.84 41.28,27.51 41.18,27.62 40.19,27.62 40.14,27.67 40.14,28.3 40.33,28.49 42.06,28.49 42.17,28.61 42.22,28.61
+3V_+1.8V_CR on TOP (solid shape): 47.91,33.91 47.91,33.05 47.66,32.8 47.66,32.34 47.46,32.14 47,32.14 46.13,31.27 45.09,31.27 45.06,31.29 45.04,31.32 45.04,32.42 45.38,32.76 45.74,32.76 46.22,32.85 46.16,33.33 46.16,33.53 46.49,33.87 46.51,33.87 46.63,33.93 46.69,34.05 46.69,34.06 47.1,34.47 47.35,34.47
+3V_+1.8V_CR on TOP (solid shape): 45.06,28.61 45.08,28.6 45.29,28.45 45.52,28.4 45.65,28.4 45.69,28.38 45.7,28.35 45.7,28.22 46.33,27.6 46.33,27.56 46.37,27.36 46.49,27.17 46.49,27.15 46.49,26.01 46.59,25.69 46.86,25.49 46.88,25.48 46.9,25.46 46.9,24.72 46.77,24.59 46.3,24.59 46.09,24.8 46.09,25.41 45.91,25.6 45.91,26.19 45.65,26.45 45.65,26.47 45.65,26.48 45.64,26.65 45.55,26.79 45.52,26.86 45.55,26.93 45.5,27.47 44.97,27.32 44.9,27.26 44.81,27.29 44.53,27.56 44.53,28.55 44.59,28.61
+3V_+1.8V_CR on IN2 (solid shape): 41.26,32.44 41.26,31.81 40.59,31.81 40.48,31.92 40.33,31.97 39.35,32.95 39.35,33.46 39.48,33.58 40.11,33.58
+3V_ALW on TOP (solid shape): 11.12,104.97 11.13,104.93 11.12,104.92 11.09,104.86 11.08,104.8 11.08,104.5 11.14,104.36 11.28,104.3 11.56,104.3 11.61,104.31 11.66,104.33 11.7,104.35 11.74,104.35 12.43,103.66 13.65,103.66 14.21,103.1 14.21,101.69 14.05,101.53 13.22,101.53 13.19,101.54 13.17,101.56 13.12,101.66 13.07,101.75 10.65,103.83 7.47,103.8 7.46,103.8 6.94,103.8 6.61,104.13 6.61,104.89 6.72,104.99 7.69,104.99 7.7,105 7.78,105.08 11.01,105.09
+3V_ALW on TOP (solid shape): outline of 88 points within 49.5,55.78 56.17,61.19
+3V_ALW on BOTTOM (solid shape): 178.49,25.08 178.49,23.68 178.44,23.63 178.34,23.63 178.27,23.7 178.27,24.27 178.25,24.29 178.25,24.35 178.16,24.44 177.77,24.44 177.69,24.49 177.68,24.58 177.68,24.85 177.49,25.05 177.49,25.05 177.41,25.12 177.41,25.41 177.58,25.58 177.99,25.58
+3V_ALW on IN1 (solid shape): 195.68,47.31 195.69,47.27 195.68,47.23 195.61,46.72 196.12,46.65 196.23,46.66 196.29,46.57 196.29,46.52 196.59,46.22 196.62,46.13 196.55,46.05 196.42,45.44 197.02,45.58 197.1,45.65 197.19,45.62 197.29,45.53 197.29,44.1 197.01,43.82 196.83,43.82 195.96,44.69 195.13,45.52 195.13,45.77 195.16,45.82 195.21,45.81 195.23,45.79 195.24,45.78 195.94,45.72 195.4,46.17 195.37,46.16 195.34,46.17 195.16,46.35 195.16,46.82 195.13,46.85 195.13,47.27 195.14,47.31 195.18,47.32 195.66,47.32
+3V_ALW on IN2 (solid shape): 178.29,24.82 178.29,23.93 177.66,23.3 177.53,23.3 177.15,23.68 177.15,23.81 177.53,24.19 177.53,24.37 177.54,24.39 177.55,24.41 177.7,24.59 177.71,24.82 177.72,24.91 177.8,24.95 178.16,24.95
+3V_CAM on TOP (solid shape): 43.16,132.26 43.16,131.74 43.45,131.46 43.46,131.45 43.56,131.31 43.71,131.24 43.72,131.24 43.82,131.13 43.82,130.38 44.37,129.83 44.48,129.78 44.79,129.47 44.79,127.33 43.69,126.24 43.61,126.1 43.6,125.94 43.6,125.94 43.6,124.71 43.39,124.5 42.6,124.5 42.41,124.69 42.41,125.44 42.41,125.75 42.48,125.81 42.48,126.65 43.18,127.35 43.18,127.47 43.3,127.59 43.32,127.6 43.45,127.66 43.5,127.79 43.51,127.9 43.51,127.95 43.51,128.96 43.51,129.01 43.5,129.11 43.44,129.25 43.29,129.31 43.19,129.32 43.16,129.33 43.15,129.37 43.15,129.47 42.65,129.96 42.65,132.26 42.78,132.39 43.04,132.39
+3V_CAM on IN2 (solid shape): outline of 96 points within 25.64,130.1 43.8,132.64
+3V_DEEP_SUS on TOP (solid shape): 171.99,35.26 171.99,34.37 171.92,34.3 170.29,34.3 170.14,34.45 170.14,35.01 170.52,35.39 171.87,35.39
+3V_DEEP_SUS on TOP (solid shape): 200.73,60.11 200.73,59.86 200.62,59.75 200.62,59.49 200.41,59.29 199.91,59.29 199.83,59.37 199.83,59.59 199.7,59.72 198.66,59.72 198.59,59.8 198.59,60.03 198.69,60.13 199.73,60.13 200,60.4 200.45,60.4
+3V_DEEP_SUS on TOP (solid shape): 166.1,84.36 166.1,83.98 165.92,83.8 165.92,83.14 165.9,83.12 165.9,82.95 165.59,82.95 165.59,82.78 165.57,82.75 165.57,82.37 165.18,81.98 164.43,81.98 164.3,82.1 164.3,82.63 164.45,82.78 164.81,82.78 164.95,82.92 164.95,83.73 164.6,84.08 164.6,84.3 164.72,84.42 166.04,84.42
+3V_DEEP_SUS on TOP (solid shape): 129.75,61.24 129.75,59.16 130.18,58.73 131.91,58.73 132.04,58.86 132.49,58.86 132.55,58.81 132.55,58.32 132.53,58.31 132.53,57.22 132.37,57.05 129.09,57.05 128.79,57.36 128.79,57.56 128.79,57.59 128.81,57.6 128.98,57.83 128.92,58.11 128.92,59.53 128.99,59.6 128.99,61.27 129.07,61.35 129.65,61.35
+3V_DEEP_SUS on TOP (solid shape): 133.54,88.75 133.54,88.47 133.13,88.06 133.13,87.27 133.16,87.24 133.17,87.18 133.12,87.15 131.44,87.15 131.4,87.17 131.39,87.25 131.39,87.53 131.33,87.67 131.19,87.73 130.93,87.73 130.81,87.85 130.8,87.88 130.8,87.9 130.65,88.28 130.25,88.23 130.17,88.2 130.1,88.24 129.62,88.28 129.6,87.8 129.61,87.79 129.61,87.73 129.6,87.7 129.5,87.61 129.48,87.5 129.42,87.41 129.32,87.42 129.25,87.45 129.17,87.47 129.15,87.47 129.03,87.6 128.9,87.6 128.88,87.61 128.87,87.62 128.8,87.68 128.71,87.71 128.43,87.71 128.3,87.85 128.3,88.05 128.49,88.24 129.42,88.24 129.5,88.32 129.5,88.75 129.65,88.91 133.38,88.91
+3V_DEEP_SUS on TOP (solid shape): outline of 181 points within 171.81,76.94 176.27,79.74
+3V_DEEP_SUS on BOTTOM (solid shape): 161.86,96.93 161.86,94.62 161.32,94.09 160.74,94.09 160.54,94.29 160.54,94.86 160.16,95.24 160.16,96.7 160.51,97.06 161.73,97.06
+3V_DEEP_SUS on BOTTOM (solid shape): 156.29,93.02 156.29,92.47 156.8,91.96 156.8,91.43 155.91,90.54 155.91,87.88 155.49,87.46 155.1,87.46 154.8,87.76 154.8,88.49 154.95,88.64 154.95,90.54 155.16,90.75 155.16,92.2 154.8,92.56 154.8,92.79 155.25,93.25 156.07,93.25
+3V_DEEP_SUS on BOTTOM (solid shape): 166.28,84.84 166.3,84.84 166.31,84.83 167.61,83.53 167.82,83.53 168.05,83.29 168.05,81.18 167.9,81.03 167.24,81.03 166.78,81.49 166.78,83.52 166.45,83.85 165,83.85 164.89,83.96 164.89,84.14 165.59,84.84
+3V_DEEP_SUS on BOTTOM (solid shape): 140.42,72.16 140.49,72.16 140.83,72.16 141.15,71.84 141.15,71.31 141.8,70.66 141.81,70.64 141.82,70.62 141.82,70.54 142.95,69.41 142.96,69.38 142.95,69.36 142.93,69.25 142.95,69.13 142.98,69.06 143.03,69.01 143.03,68.82 142.88,68.67 142.61,68.67 141.72,69.56 141.65,69.56 141.33,69.88 140.24,69.88 140.17,69.91 140.14,69.97 139.97,70.25 139.65,70.27 139.62,70.27 139.59,70.28 139.46,70.42 139.46,70.83 139.6,70.98 139.81,70.98 140.27,71.43 140.27,71.63 140.27,71.68 140.27,71.98 140.27,72.09 140.33,72.15 140.35,72.16 140.37,72.17
+3V_DEEP_SUS on BOTTOM (solid shape): outline of 95 points within 126,87.72 132.98,89.5
+3V_DEEP_SUS on IN1 (solid shape): 73.41,122.68 73.41,122.39 73.4,122.35 73.36,122.34 72.21,122.34 72.08,122.47 72.08,122.88 72.09,122.9 72.1,122.92 72.23,123.11 72.22,123.33 72.24,123.42 72.32,123.47 72.63,123.47
+3V_DEEP_SUS on IN1 (solid shape): outline of 134 points within 144.03,92.18 161.18,95.48
+3V_DEEP_SUS on IN1 (solid shape): outline of 3009 points within 127.97,81.06 166.3,92.72
+3V_DEEP_SUS on IN2 (solid shape): 152.04,96.6 152.04,95.8 152.56,95.28 152.56,94.93 152.33,94.7 151.88,94.7 150.76,95.82 150.76,96.7 150.83,96.78 151.86,96.78
+3V_DEEP_SUS on IN2 (solid shape): 175.74,79.16 175.83,79.11 175.83,79.01 176.15,78.47 176.48,79.01 176.48,79.11 176.57,79.16 177.14,79.16 177.28,79.02 177.28,78.45 177.26,78.43 177.25,78.42 177.07,78.29 177.01,78.07 177.01,77.92 176.93,77.85 176.46,77.85 176.44,77.85 176.42,77.86 176.23,77.96 176.01,77.94 175.94,77.94 175.88,77.99 175.65,78.17 175.36,78.13 175.33,78.13 175.3,78.14 175.07,78.37 175.07,78.74 175.49,79.16
+3V_DEEP_SUS on IN2 (solid shape): outline of 240 points within 184.95,55.84 192.54,59.37
+3V_RTC on IN1 (solid shape): outline of 1010 points within 124.67,80.17 132.39,88.42
+3V_SENSOR on BOTTOM (solid shape): 70.45,127.43 70.45,125.04 70.34,124.92 70.03,124.92 69.88,125.08 69.88,126.22 69.58,126.78 69.29,126.22 69.29,125.57 69.18,125.46 67.5,125.46 67.32,125.64 67.32,127.46 67.43,127.58 70.31,127.58
+3V_SSD on TOP (solid shape): 202.67,15.5 202.67,14.18 202.52,14.03 202.32,14.03 201.84,13.54 201.84,11.94 201.1,11.21 201.1,8.01 200.79,7.7 200.78,7.7 200.59,7.6 200.5,7.42 200.49,7.4 200.44,7.35 199.27,7.35 198.86,7.75 198.86,14.92 199.86,15.91 202.27,15.91
+3V_SSD on BOTTOM (solid shape): 205.62,24.19 206.56,24.19 206.92,23.83 206.92,23.5 206.9,23.46 206.87,23.45 205.5,23.45 205.5,23.23 206.84,23.23 206.88,23.21 206.89,23.18 206.89,23 206.88,22.96 206.84,22.95 205.5,22.95 205.5,22.73 206.84,22.73 206.88,22.71 206.89,22.68 206.89,22.56 206.78,22.45 205.5,22.45 205.46,22.37 205.38,22.35 205.05,22.24 204.97,21.91 204.97,21.88 204.96,21.86 204.86,21.76 204.86,21.67 204.85,21.66 204.82,21.54 204.83,21.41 204.83,21.38 204.81,21.36 204.57,21.11 204.57,19.31 201.77,16.51 201.77,15.04 201.23,14.51 200.77,14.04 199.86,14.04 199.45,14.45 199.45,17.46 202.17,20.17 202.17,24.15 202.5,24.48 205.33,24.48
+3V_SSD on BOTTOM (solid shape): outline of 105 points within 197.72,5.62 207.63,9.87
