# Allegro board dax8jmb16e0-e-www.DeviceDB.xyz_.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SATA_RXP7_C: length 2.4
  BOTTOM w0.097: CN4400.5 221.3,23.21 221.15,23.37 221.15,23.52 220.58,24.09 220.58,24.33 220.74,24.5 C4404.2
SATA_TXN7: length 175.3
  IN2 w0.114: v2(224.79,25.64) 224.79,25.82 224.65,25.96 224.27,25.96 223.71,26.52 223.71,39.1 222.61,40.19 222.61,44.68 222,45.29 222,47.48 220.76,48.72 220.76,53.78 220.33,54.21 220.33,57.89 218.42,59.8 218.42,60.71 212.07,67.06 209.48,67.06 208.64,67.9 208.64,69.5 205.19,72.95 205.19,74.82 204.33,75.67 204.33,78.55 203.95,80.76 203.95,81.79 203.53,82.22 203.53,83.01 202.94,85.31 201.98,86.27 201.98,87.78 200.92,88.84 199.4,88.84 188.03,100.21 184.73,100.21 183.19,101.76 177.15,101.76 174.21,104.7 167.81,104.7 167.17,105.34 164.99,105.34 163.72,106.61 162.8,106.61 161.96,107.45 160.93,108.49 145.47,108.49 145.25,108.27 144.37,108.27 141.63,105.53 132.73,105.53 131.78,106.48 131.16,106.48 130.01,105.34 126.98,105.34 126.91,105.26 v2(126.91,105.06)
  BOTTOM w0.079: v2(126.91,105.06) 126.8,105.06 126.67,104.93 126.67,103.78 125.8,102.91 125.8,102.59 125.99,102.41 125.99,102.1 125.95,102.01 125.95,101.75 125.97,101.71 126.01,101.5 125.97,101.37 125.93,101.29 125.81,100.62 U400.BN4
  BOTTOM w0.097: C4406.1 218.69,25.26 218.62,25.33 218.62,25.78 218.97,26.13 218.97,27.4 219.15,27.58 219.15,27.99 220.2,29.03 220.61,29.03 223.42,26.22 224.03,26.22 224.25,26 224.43,26 v2(224.79,25.64)
SATA_TXN7_C: length 3
  BOTTOM w0.097: CN4400.8 219.8,23.35 219.65,23.5 219.65,23.69 219.46,23.88 218.68,23.88 218.6,23.96 218.6,24.1 C4406.2
SATA_TXP7: length 175.3
  IN2 w0.114: v2(126.27,105.09) 126.33,105.09 126.81,105.57 129.92,105.57 131.06,106.71 131.87,106.71 132.82,105.76 141.54,105.76 144.28,108.5 145.15,108.5 145.37,108.71 161.02,108.71 162.19,107.55 162.19,107.55 162.9,106.84 163.81,106.84 165.08,105.57 167.27,105.57 167.9,104.93 174.3,104.93 177.25,101.99 183.28,101.99 184.83,100.44 188.13,100.44 199.5,89.07 201.01,89.07 202.21,87.87 202.21,86.37 203.15,85.43 203.75,83.04 203.75,82.31 204.18,81.89 204.18,80.78 204.56,78.57 204.56,75.77 205.42,74.91 205.42,73.05 208.87,69.59 208.87,68 209.58,67.29 212.16,67.29 218.65,60.8 218.65,59.89 220.56,57.99 220.56,54.3 220.99,53.87 220.99,48.82 222.23,47.57 222.23,45.39 222.84,44.78 222.84,40.29 223.94,39.19 223.94,26.62 224.37,26.19 224.55,26.19 v2(224.79,26.44)
  BOTTOM w0.079: U400.BN3 125.81,101.43 125.84,101.51 125.81,101.66 125.79,101.71 125.79,102.04 125.82,102.13 125.82,102.34 125.64,102.52 125.64,102.98 126.5,103.85 126.5,104.86 v2(126.27,105.09)
  BOTTOM w0.097: C4407.1 218.3,25.26 218.42,25.38 218.42,25.86 218.77,26.21 218.77,27.48 218.95,27.66 218.95,28.07 220.12,29.23 220.69,29.23 223.5,26.42 224.11,26.42 224.33,26.2 224.56,26.2 v2(224.79,26.44)
SATA_TXP7_C: length 3
  BOTTOM w0.097: C4407.2 218.4,24.1 218.4,23.88 218.6,23.68 219.38,23.68 219.45,23.61 219.45,23.5 219.3,23.35 CN4400.9
SCL_BAT_CHG: length 173.8
  TOP w0.102: R4724.2 198.41,56.12 198.66,56.36 v2(198.66,56.64) 198.86,56.83 201.68,56.83 U4701.C12 ; v2(86.4,35.49) 86.6,35.29 PD8500.3 87.36,31.43 PR8516.2
  IN2 w0.127: v2(86.4,35.49) 87.32,36.42 107.17,36.42 107.73,35.85 114.91,35.85 115.99,34.78 118.98,34.78 121.44,32.32 125.95,32.32 127.61,30.66 128.29,30.66 129.55,29.41 130.08,29.41 132.38,27.1 133.3,27.1 133.68,26.73 133.68,24.13 133.45,23.9 v2(133.45,23.53) 133.47,23.51 135.18,23.51 137.38,21.31 140.41,21.31 143.53,18.19 148.66,18.19 149.2,17.65 156.76,17.65 157.09,17.98 168.56,17.98 169.1,18.51 176.7,18.51 176.9,18.31 181.81,18.31 182.51,19.01 183.01,19.01 183.45,19.45 184.03,19.45 184.44,19.03 187.62,19.03 188.27,19.68 191.78,19.68 193.57,21.47 193.57,23.92 195.38,25.73 195.38,35.83 195.79,36.23 195.79,38.29 196.42,38.93 196.42,40.04 196.11,40.35 196.11,42.53 194.73,43.9 194.73,44.58 192.82,46.49 192.82,53.19 196.23,56.6 197.93,56.6 197.95,56.58 198.61,56.58 v2(198.66,56.64)
  BOTTOM w0.102: PR8220.2 132.2,23.4 133.31,23.4 v2(133.45,23.53)
SD_CD#_BH: length 11.9
  TOP w0.102: v2(43.04,24.64) 43.04,25.8 43.25,26.01 43.25,26.35 v2(43.47,26.57) 43.47,26.75 43.07,27.15 43.07,27.15 43.02,27.2 U7600.24
  BOTTOM w0.102: D7601.1 47.2,26.83 46.59,26.22 46.59,25.08 45.96,24.44 44.43,24.44 44.05,24.06 43.29,24.06 43.04,24.31 v2(43.04,24.64)
SD_CD#_PCH: length 172.4
  IN2 w0.127: v2(41.64,36.76) 41.13,37.27 41.13,38.81 41.47,39.15 41.47,40.99 40.78,41.69 40.78,43.54 42.15,44.91 42.15,47.43 41.95,47.63 41.95,49.21 42.2,49.45 42.2,49.94 43.85,51.59 43.85,52.99 44.51,53.65 46.76,53.65 51.14,58.03 51.14,59.96 65.54,74.36 67.53,74.36 68.36,73.54 68.36,71.35 67.55,70.54 67.55,69.87 68.22,69.19 69.76,69.19 70.58,70.02 70.58,73.3 70.95,73.67 70.95,75.11 71.76,75.93 71.76,82.64 81.81,92.68 89.8,92.68 90.31,92.18 92.26,92.18 92.92,91.52 99.07,91.52 99.93,90.66 99.93,89.46 101.94,87.45 108.33,87.45 109.06,86.72 122.41,86.72 122.66,86.47 125.76,86.47 125.96,86.28 131.8,86.28 132.2,85.88 132.41,85.88 132.95,85.34 132.95,84.43 133.12,84.26 133.59,84.26 133.84,84 133.84,83.88 134,83.72 134.58,83.72 134.93,83.36 135.29,83.36 135.61,83.68 136.89,83.68 137.12,83.44 137.12,81.67 136.56,81.11 136.56,80.75 137.4,79.91 137.4,79.57 v2(139.28,77.69)
  BOTTOM w0.079: v2(139.28,77.69) 139.04,77.92 135.6,77.92 134.46,79.05 134.46,79.7 134.55,79.79 134.55,80.01 134.46,80.09 134.46,80.62 U400.CH35
  BOTTOM w0.102: D7601.2 45.75,30.8 43.49,33.05 43.49,34.02 41.64,35.87 v2(41.64,36.76)
SD_CLK: length 6
  TOP w0.102: U7600.4 46.19,30.16 46.49,30.46 C7621.1 47.35,30.02 48.02,30.02 48.17,29.88 48.81,29.88 R623.2 49.29,29.39 v2(50.91,29.39)
SD_CLK_R: length 184.3
  TOP w0.102: v2(49.22,28.25) 49,28.47 R623.1
  IN2 w0.127: v2(49.22,28.25) 49.22,28.59 49.77,29.14 49.77,33.63 46.44,36.96 43.04,36.96 42.96,36.89 42.27,36.89 41.64,37.52 41.64,38.59 41.99,38.94 41.99,41.28 41.28,41.99 41.28,43.32 42.71,44.75 42.71,47.1 43.38,47.78 43.38,50.32 44.53,51.46 44.91,51.46 46.34,52.89 46.71,52.89 51.65,57.82 51.65,59.75 65.75,73.86 66.98,73.86 67.24,73.59 67.24,71.18 67.06,71 66.71,71 66.58,70.87 66.58,68.81 66.71,68.69 67.24,68.69 67.78,68.15 67.78,67.59 67.9,67.47 70.47,67.47 70.59,67.59 70.59,69.07 70.8,69.27 71.79,69.27 72.14,69.63 72.14,71.91 71.97,72.09 71.23,72.09 71.09,72.23 71.09,73.09 71.59,73.59 71.59,74.99 72.27,75.67 72.27,82.43 82.02,92.18 89.58,92.18 90.08,91.67 92.03,91.67 92.69,91.01 98.74,91.01 99.4,90.35 99.4,89.26 101.71,86.95 108.12,86.95 108.85,86.21 122.18,86.21 122.43,85.97 131.68,85.97 131.94,85.7 131.94,84.69 132.2,84.42 132.65,84.42 132.88,84.19 132.88,83.56 133.16,83.29 133.66,83.29 134,82.96 134.54,82.96 134.82,82.67 134.94,82.67 135.44,82.17 135.44,81.96 135.72,81.68 135.72,80.83 136.89,79.66 136.89,79.33 139.53,76.69 141.97,76.69 v2(142.1,76.82)
  BOTTOM w0.079: U400.CK36 136.02,80.17 136.02,79.85 136.13,79.58 136.22,79.48 136.22,79.25 136.71,78.76 138.64,78.76 138.96,79.08 140.43,79.08 140.51,79 140.9,79 141.28,78.62 141.28,77.84 142.1,77.02 v2(142.1,76.82)
SD_CMD: length 187.6
  TOP w0.102: R7624.2 48.22,29.49 v2(48.29,29.42)
  IN2 w0.127: v2(139.83,78.36) 139.69,78.5 139.3,78.5 137.9,79.9 137.9,84.26 136.58,85.58 133.66,85.58 132.15,87.09 131.1,87.09 130.63,87.57 126.41,87.57 126.1,87.26 125.18,87.26 125,87.44 125,87.79 124.76,88.03 122.69,88.03 122.32,88.4 110.42,88.4 109.89,88.93 107.07,88.93 106.94,89.06 106.94,89.39 106.82,89.51 106.56,89.51 106.43,89.39 106.43,89.06 106.31,88.93 106.05,88.93 105.93,89.06 105.93,89.39 105.8,89.51 105.55,89.51 105.42,89.39 105.42,89.06 105.29,88.93 105.06,88.93 104.83,89.16 104.83,89.77 103.82,90.78 102.6,90.78 102.13,91.26 102.13,91.64 101.46,92.31 100.13,92.31 99.39,93.05 90.99,93.05 90.58,93.45 90.58,94.04 90.28,94.34 86.6,94.34 86.22,93.96 82.01,93.96 72.96,84.92 72.78,84.92 72.35,85.35 72.17,85.35 71.99,85.17 71.99,84.99 72.42,84.56 72.42,84.38 72.24,84.2 72.06,84.2 71.63,84.63 71.45,84.63 71.27,84.45 71.27,84.27 71.7,83.84 71.7,83.66 71.52,83.48 71.34,83.48 70.91,83.91 70.73,83.91 70.55,83.73 70.55,83.55 70.98,83.12 70.98,82.94 70.8,82.76 70.8,81.8 70.68,81.67 69.1,81.67 68.97,81.54 68.97,81.29 69.1,81.16 70.68,81.16 70.8,81.03 70.8,80.78 70.68,80.65 69.1,80.65 68.97,80.53 68.97,80.27 69.1,80.15 70.68,80.15 70.8,80.02 70.8,79.76 70.68,79.64 69.1,79.64 68.97,79.51 68.97,79.26 69.1,79.13 70.68,79.13 70.8,79 70.8,78.47 70.68,78.34 69.1,78.34 68.91,78.16 68.91,76.13 67.92,75.14 65.24,75.14 50.3,60.21 50.3,59.36 47.04,56.1 41.83,56.1 41.19,55.46 41.19,45.83 40.62,45.27 40.62,44.46 40.01,43.85 40.01,41.37 40.61,40.78 40.61,39.56 39.86,38.82 39.86,37.01 41.13,35.74 44.31,35.74 44.94,35.11 45.94,35.11 48.9,32.15 48.9,31.8 48.78,31.67 48.29,31.67 48.17,31.54 48.17,31.29 48.29,31.16 48.78,31.16 48.9,31.03 48.9,30.03 v2(48.29,29.42)
  BOTTOM w0.079: U400.CH36 134.72,80.2 134.89,80.04 134.89,79.84 134.92,79.77 134.96,79.73 134.97,79.71 135.13,79.56 135.13,78.87 135.73,78.26 138.93,78.26 139.17,78.5 139.69,78.5 v2(139.83,78.36)
SD_CMD_C: length 1.5
  TOP w0.102: U7600.3 46.13,29.76 46.4,29.49 R7624.1
SD_DATA0: length 187
  TOP w0.102: R7626.2 49.52,30.65 50.02,30.16 50.88,30.16 51.54,29.49 51.54,28.3 50.72,27.47 50.39,27.47 49.39,26.47 48.88,26.47 48.62,26.73 48.62,27.08 v2(48.5,27.21) 48.47,27.21 47.99,26.73 v2(47.71,26.73)
  IN2 w0.127: v2(141.69,78.03) 141.11,78.03 140.28,78.86 139.31,78.86 138.16,80.01 138.16,84.51 136.84,85.83 133.76,85.83 132.27,87.32 131.36,87.32 130.87,87.81 130.87,88.16 130.43,88.6 122.59,88.6 122.43,88.76 117.54,88.76 117.02,89.29 111.69,89.29 110.75,90.23 105.34,90.23 103.51,92.05 102.83,92.05 102.22,92.66 100.31,92.66 99.56,93.41 91.11,93.41 90.88,93.64 90.88,94.07 90.35,94.59 82.12,94.59 73.33,85.81 71.69,85.81 68.33,82.45 68.33,81.87 68.53,81.68 68.53,80.89 67.81,80.18 67.81,79.16 68.33,78.64 68.33,75.91 67.81,75.39 65.13,75.39 50.05,60.31 50.05,59.47 47.03,56.44 43.54,56.44 42.53,57.46 40.64,57.46 39.73,56.54 39.73,48.71 40.24,48.19 40.24,44.74 39.6,44.1 39.6,36.89 41.2,35.29 43.87,35.29 44.31,34.85 45.84,34.85 47.86,32.83 47.86,27.28 47.71,27.13 v2(47.71,26.73)
  BOTTOM w0.079: U400.CL35 136.34,80.81 136.34,80.26 136.19,80.1 136.19,79.88 136.27,79.67 136.39,79.55 136.39,79.32 136.77,78.93 138.57,78.93 138.89,79.25 140.5,79.25 140.58,79.17 141.04,79.17 141.69,78.52 v2(141.69,78.03)
SD_DATA0_C: length 3.4
  TOP w0.102: U7600.5 45.98,30.56 46.34,30.92 R7626.1
SD_DATA1: length 189.1
  TOP w0.102: R7627.2 49.64,31.45 50.01,31.08 50.01,30.69 50.29,30.41 50.94,30.41 51.8,29.55 51.8,28.25 50.66,27.11 50.4,27.11 49.26,25.96 v2(49,25.96) v2(47.76,25.96)
  IN2 w0.102: 133.35,86.63 132.42,87.55
  IN2 w0.127: v2(47.76,25.96) 47.28,26.45 47.28,27.09 47.53,27.34 47.53,32.8 45.73,34.6 43.67,34.6 43.24,35.03 40.99,35.03 39.35,36.68 39.35,44.2 39.9,44.75 39.9,48.18 39.39,48.69 39.39,56.56 40.54,57.71 42.78,57.71 43.54,56.95 46.18,56.95 46.94,57.72 46.94,58.27 49.02,60.35 49.73,60.35 65.03,75.65 65.84,75.65 67.39,77.2 67.39,81.98 72.14,86.72 73.89,86.72 82.01,94.85 91,94.85 91.64,94.2 99.23,94.2 99.94,93.49 101.8,93.49 102.88,92.41 103.59,92.41 105.37,90.63 111.08,90.63 112.07,89.64 117.29,89.64 117.33,89.6 121.91,89.6 122.69,88.83 130.53,88.83 131.1,88.25 131.1,87.91 131.46,87.55 132.42,87.55 ; 133.35,86.63 133.35,86.61 133.86,86.09 137.01,86.09 138.41,84.69 138.41,80.11 139.41,79.11 140.39,79.11 141.03,78.47 141.94,78.47 142.12,78.29 142.12,77.57 v2(142.11,77.56)
  BOTTOM w0.079: 141.59,78.9 141.15,79.34 140.65,79.34 140.57,79.41 138.82,79.41 138.5,79.1 136.84,79.1 136.56,79.39 136.56,79.85 U400.CL36
  BOTTOM w0.112: v2(142.11,77.56) 142.11,78.38 141.59,78.9
SD_DATA1_C: length 1.6
  TOP w0.102: R7627.1 46.59,31.45 46.1,30.96 U7600.6
SD_DATA2: length 188.4
  TOP w0.102: R7622.2 47.67,27.37 47.05,26.75 v2(47.05,26.01)
  IN2 w0.102: 137.24,86.42 136.98,86.69 136.89,86.69 136.55,87.03 133.42,87.03 132.93,87.52 132.93,87.92 132.17,88.68 131.04,88.68 130.6,89.13 123.31,89.13 122.47,89.97 120.68,89.97
  IN2 w0.127: 120.68,89.97 113.06,89.97 112,91.03 112,91.19 111.65,91.53 105.05,91.53 103.79,92.79 103.04,92.79 102.11,93.72 100.04,93.72 99.33,94.43 91.74,94.43 91.06,95.1 81.91,95.1 73.78,86.97 72.03,86.97 69.16,84.1 66.28,84.1 66.15,83.98 66.15,83.11 66.02,82.99 65.77,82.99 65.64,83.11 65.64,83.98 65.52,84.1 64.58,84.1 63.43,82.96 63.43,82.28 67.14,78.57 67.14,77.3 65.74,75.9 64.92,75.9 49.62,60.6 48.91,60.6 46.69,58.37 46.69,57.82 46.07,57.21 43.8,57.21 42.91,58.1 40.56,58.1 39.08,56.62 39.08,48.64 39.59,48.12 39.59,44.81 39.09,44.31 39.09,36.57 40.99,34.68 43.09,34.68 43.42,34.35 45.63,34.35 47.23,32.75 47.23,27.54 46.87,27.18 46.87,26.19 v2(47.05,26.01) ; 137.24,86.42 138.67,84.99 138.67,80.22 139.15,79.73 139.52,79.37 140.49,79.37 141.13,78.73 142.07,78.73 142.42,78.38 142.42,78.14 v2(142.61,77.95)
  BOTTOM w0.079: U400.CM35 136.88,79.92 136.72,79.77 136.72,79.46 136.91,79.27 138.43,79.27 138.75,79.58 140.64,79.58 140.72,79.51 141.46,79.51 142.24,78.73
  BOTTOM w0.112: 142.24,78.73 142.49,78.48 142.49,78.06 v2(142.61,77.95)
SD_DATA2_C: length 2.3
  TOP w0.102: R7622.1 46.89,27.84 46.26,28.47 46.26,28.78 46.09,28.96 U7600.1
SD_DATA3: length 186.5
  TOP w0.102: R7623.2 47.96,28.53 48.5,28 48.5,27.79 49.16,27.13 v2(49.16,26.98)
  IN2 w0.127: v1(137.03,80.96) 137.4,81.33 137.4,83.63 137.06,83.97 135.44,83.97 135.04,84.37 134.81,84.37 134.67,84.51 133.86,84.51 133.73,84.64 133.73,84.87 132.06,86.53 126.28,86.53 126.04,86.78 122.79,86.78 122.49,87.08 109.06,87.08 108.43,87.71 103.11,87.71 101.51,89.31 101.51,90.05 101.23,90.33 100.94,90.33 100.02,91.24 100.02,91.47 99.03,92.46 90.53,92.46 90.06,92.94 81.7,92.94 71.31,82.55 71.31,76.64 71.15,76.48 71,76.48 70.87,76.36 70.87,76.03 70.75,75.9 70.49,75.9 70.37,76.03 70.37,76.36 70.24,76.48 69.98,76.48 69.4,75.9 69.4,74.27 69.93,73.74 69.93,70.19 69.76,70.01 68.72,70.01 68.61,70.11 68.61,70.65 68.74,70.77 69.55,70.77 69.68,70.9 69.68,71.16 69.55,71.28 68.74,71.28 68.61,71.41 68.61,71.66 68.74,71.79 69.55,71.79 69.68,71.92 69.68,72.17 69.55,72.3 68.74,72.3 68.61,72.43 68.61,72.68 68.74,72.81 69.55,72.81 69.68,72.93 69.68,73.19 69.55,73.31 68.74,73.31 68.61,73.44 68.61,73.64 67.64,74.62 65.43,74.62 50.81,60 50.81,59.15 47.19,55.53 46.86,55.53 46.73,55.4 46.73,54.97 46.6,54.84 46.35,54.84 46.22,54.97 46.22,55.4 46.09,55.53 45.84,55.53 45.71,55.4 45.71,54.97 45.59,54.84 45.33,54.84 45.2,54.97 45.2,55.4 45.08,55.53 44.82,55.53 44.7,55.4 44.7,54.97 44.57,54.84 44.32,54.84 44.19,54.97 44.19,55.4 44.06,55.53 43.81,55.53 43.68,55.4 43.68,54.97 43.55,54.84 43.3,54.84 43.17,54.97 43.17,55.4 43.05,55.53 42.76,55.53 41.87,54.64 41.87,54.08 41.99,53.95 42.7,53.95 42.83,53.83 42.83,53.57 42.7,53.45 41.99,53.45 41.87,53.32 41.87,53.07 41.99,52.94 42.7,52.94 42.83,52.81 42.83,52.56 42.7,52.43 41.99,52.43 41.87,52.3 41.87,52.05 41.99,51.92 42.7,51.92 42.83,51.8 42.83,51.54 42.7,51.41 41.99,51.41 41.87,51.29 41.87,49.5 41.69,49.33 41.69,47.5 41.84,47.36 41.84,44.95 40.52,43.64 40.52,41.58 41.12,40.99 41.12,39.35 40.83,39.07 40.83,36.81 41.35,36.28 45.7,36.28 49.23,32.75 49.23,29.62 48.37,28.76 48.37,27.74 49.11,27.01 49.13,27.01 v2(49.16,26.98)
  BOTTOM w0.079: U400.CN35 137.14,80.85 v1(137.03,80.96)
SD_DATA3_C: length 1.7
  TOP w0.102: U7600.2 46.06,29.35 R7623.1
SD_PWR_EN#: length 199.2
  TOP w0.102: D7600.1 39.04,36.28 37.79,37.53 37.79,65.51 38.67,66.39 41.18,66.39 41.69,66.9 41.69,73.1 42,73.41 44.69,73.41 47.07,71.04 49.31,71.04 49.44,70.91 49.44,69.81 51,68.25 51,66.9 51.82,66.07 53.87,66.07 59.3,60.64 59.3,60.01 60.26,59.05 60.99,59.05 63.94,56.1 106.76,56.1 108.27,54.6 140.58,54.6 141.23,55.25 144.65,55.25 151.64,62.24 v2(151.64,62.68)
  IN1 w0.114: v2(151.64,62.68) 151.64,62.83 148.73,65.74 148.73,65.82 147.56,66.98 v2(147.56,68.07)
  BOTTOM w0.079: U400.BW36 129.95,79.96 129.95,78.74 131.62,77.06 133.55,77.06 134.78,75.82 135.76,75.82 136.63,74.95 136.75,74.95
  BOTTOM w0.102: 136.75,74.95 137.35,74.95 R574.1 137.42,74.6 137.3,74.48 137.3,73.38 137.64,73.03 138.24,73.03 138.44,72.83 138.82,72.83 139.48,72.17 139.48,71.07 139.3,70.89 139.3,69.7 139.59,69.41 141.66,69.41 142.88,68.18 144.84,68.18 145.09,68.43 146.14,68.43 146.36,68.21 146.36,68 146.56,67.81 147.29,67.81 v2(147.56,68.07)
SD_PWR_EN#_R: length 7.7
  TOP w0.102: R7610.1 v2(46.14,36.15) R7611.1 44.65,36.08 44.65,35.11 44.4,34.86 44.07,34.86 43.87,34.66 43.87,33.74 43.42,33.28 U7600.11
SD_PWR_POL: length 3.6
  TOP w0.102: U7600.9 44.22,32.73 44.39,32.91 45.78,32.91 v2(45.93,33.06) 46,33.13 46,33.88 R7621.1
SD_WP_BH: length 11.8
  TOP w0.102: v2(43.62,25.25) 43.62,25.7 44.03,26.1 44.03,26.63 43.42,27.23 U7600.25
  BOTTOM w0.102: v2(43.62,25.25) 44.17,24.69 45.7,24.69 46.34,25.33 46.34,26.35 46.64,26.65 46.64,28.83 D7602.1
SD_WP_PCH: length 165.8
  IN2 w0.127: v2(140.91,77.53) 140.04,77.53 139.46,78.12 139.2,78.12 137.65,79.67 137.65,83.83 137.25,84.23 135.74,84.23 135.52,84.45 135.52,84.93 135.18,85.27 133.64,85.27 132.16,86.76 126.41,86.76 126.14,87.03 122.94,87.03 122.56,87.41 122.56,87.66 122.11,88.12 110.19,88.12 109.66,88.65 102.69,88.65 101.86,89.48 101.86,90.63 101.61,90.89 101.61,91.6 101.25,91.95 100.03,91.95 99.22,92.77 90.69,92.77 90.26,93.19 81.6,93.19 71.06,82.65 71.06,77.92 68.02,74.88 65.34,74.88 50.56,60.1 50.56,59.26 47.14,55.84 42.18,55.84 41.44,55.1 41.44,45.07 40.88,44.51 40.88,44.35 40.27,43.75 40.27,41.48 40.86,40.88 40.86,39.46 40.37,38.97 v2(40.37,37.14)
  BOTTOM w0.079: v2(140.91,77.53) 141.11,77.74 141.11,78.33 140.61,78.84 140.44,78.84 140.36,78.91 139.03,78.91 138.71,78.6 135.87,78.6 135.46,79.01 135.46,79.39 135.46,79.39 135.46,79.67 135.46,79.67 135.46,79.73 135.61,79.88 135.61,80.5 135.78,80.67 U400.CK34
  BOTTOM w0.102: D7602.2 44.58,32.32 43.7,33.2 43.7,34.19 42.4,35.49 42.4,36.76 41.77,37.39 40.62,37.39 v2(40.37,37.14)
SDA_BAT_CHG: length 177.5
  TOP w0.076: v2(199.27,56.45) 199.27,56.47 199.47,56.67 201.48,56.67 201.65,56.5 U4701.B12
  TOP w0.102: v2(85.1,35.24) 84.18,34.32 83.01,34.32 PD8501.3 81.77,31.55 82.91,31.55 PR8517.2 ; R4725.2 197.54,56.12 197.8,55.86 198.67,55.86 v2(199.27,56.45)
  IN2 w0.127: v2(85.1,35.24) 85.32,35.01 87.67,35.01 88.64,35.98 106.99,35.98 107.55,35.42 114.74,35.42 115.81,34.35 118.8,34.35 121.26,31.89 125.77,31.89 128.01,29.65 128.7,29.65 129.37,28.98 129.9,28.98 132.2,26.67 133.12,26.67 133.24,26.55 133.24,24.3 132.82,23.89 v2(132.82,23.81) 132.82,23.52 133.27,23.07 135,23.07 137.2,20.88 140.23,20.88 143.35,17.76 148.48,17.76 149.02,17.21 156.95,17.21 157.29,17.54 168.92,17.54 169.45,18.08 176.52,18.08 176.73,17.87 182.01,17.87 182.71,18.57 187.77,18.57 188.45,19.25 191.96,19.25 194,21.29 194,23.74 195.81,25.55 195.81,26.24 195.81,26.24 195.81,35.65 196.22,36.05 196.22,38.12 196.85,38.75 196.85,40.22 196.54,40.53 196.54,42.7 195.16,44.08 195.16,44.76 193.25,46.67 193.25,53.01 196.41,56.16 198.98,56.16 v2(199.27,56.45)
  BOTTOM w0.102: PR8219.2 132.34,24.29 v2(132.82,23.81)
SG_IN: length 15.8
  BOTTOM w0.079: 142.5,90.33 139.25,90.33 139.05,90.53 138.01,90.53 137.97,90.49 137.97,90.49 137.82,90.34 137.82,90.34 137.8,90.32 U400.CN20
  BOTTOM w0.102: R521.2 151.27,88.83 v2(151.37,88.7) 151.11,88.7 150.35,89.46 R522.1 149.9,89.49 149.33,90.06 145.97,90.06 145.88,89.97 145.02,89.97 144.93,90.06 144.27,90.06 144,90.33 142.5,90.33
SHD_DIO2: length 11.6
  TOP w0.102: R4773.1 196,60.59 196,59.22 196.49,58.73 199.02,58.73 v2(199.39,58.35) 200.07,57.68 202.42,57.68 202.83,57.27 202.83,56.78 203.28,56.33 203.28,55.88 U4701.E11
SHD_DIO2_E1: length 44.2
  TOP w0.102: v2(193.18,59.58) 193.18,59.66 194.48,60.97 R4773.2 ; v2(167.24,75.42) v2(167.24,76.14) 167.4,76.3 R5612.1
  IN2 w0.114: v2(167.24,76.14) 167.59,76.14 v2(168.99,74.73)
  BOTTOM w0.102: v2(193.18,59.58) 192.12,59.58 191.43,58.9 188.53,58.9 187.61,57.98 187.61,57.48 186.89,56.76 186.31,56.76 186.02,56.48 184.93,56.48 183.41,57.99 177.73,57.99 172.36,63.37 172.36,65.14 170.28,67.22 170.28,69.31 170.44,69.47 170.44,73.28 v2(168.99,74.73)
SHD_DIO3: length 9.1
  TOP w0.102: U4701.J11 205.87,55.89 205.87,56.48 205.49,56.86 205.49,57.32 205.69,57.52 207.91,57.52 208.49,58.1 v2(210.25,58.1) 210.66,58.1 211.17,58.62 211.45,58.62 211.72,58.88 R4774.1
SHD_DIO3_E1: length 66.8
  TOP w0.102: R4774.2 211.72,60.3 v2(211.95,60.52) ; v2(191.58,71.48) 190.58,70.49 v2(190.58,70.06) ; R5613.1 175.92,80.58 177.56,80.58 177.95,80.96 177.95,81.64 178.12,81.82 179.68,81.82 179.91,81.58 179.91,80.06 178.88,79.03 178.88,77.34 v2(179.15,77.06) ; v2(180.63,77.41) 180.83,77.61 182.08,77.61 184.46,75.23 184.46,71.71 185.18,70.99 185.18,69.76 186.31,68.63 v2(186.75,68.63)
  IN1 w0.114: v2(201.89,76.39) 201.66,76.17 201.66,76.04 201.86,75.84 201.86,75.39 201.96,75.29 201.96,72.62 203.26,71.32 203.26,70.24 205.21,68.29 206.15,68.29 206.62,67.82 206.62,66.5 207.76,65.35 207.76,64.4 207.92,64.24 207.92,63.12 209.77,61.27 210.93,61.27 211.68,60.52 v2(211.95,60.52)
  IN2 w0.114: v2(180.63,77.41) 179.5,77.41 v2(179.15,77.06)
  BOTTOM w0.102: v2(201.89,76.39) 201.8,76.39 201.79,76.38 201.02,76.38 200.92,76.49 197.58,76.49 195.34,74.25 192.7,74.25 191.91,73.46 191.91,72.82 191.58,72.49 v2(191.58,71.48) ; v2(190.58,70.06) 189.96,69.43 189.27,69.43 188.93,69.08 187.2,69.08 v2(186.75,68.63)
SLEEVE_C: length 7.9
  IN1 w1.016: 228.02,21.9 234.02,21.9 CN3601.3
  vias: v2(226.69,21.8)
SLEEVE_L: length 17.3
  TOP w0.203: v2(218.58,8.9) 218.59,8.9 U3600.14
  IN1 w1.016: 219.77,9.53 221.17,9.53 222.59,10.95 223.43,10.95 224.06,11.59 v2(224.52,11.59) 225.04,12.11 225.16,12.11 226.94,13.89 226.94,14.62 226.71,14.86 226.71,15.53 226.35,15.89 226.35,18.09 225.81,18.63 v2(225.81,20.68)
SLP_LAN#: length 129.9
  TOP w0.102: R4767.1 189.5,50.25 189.21,50.54 183.44,50.54 v2(182.23,51.75) ; v2(166.33,65.8) 166.33,65.8 165.59,65.06 155.9,65.06 155.62,64.78 149.47,64.78 148.8,64.11 134.17,64.11 130.1,68.17 R648.2 ; PR9508.2 165.01,30.99 164.57,31.43 164.57,31.93 162.97,33.53 v2(162.97,35.36)
  IN2 w0.114: v2(166.33,65.8) 166.37,65.8 168.49,63.67 170.46,63.67 171.74,62.39 174.57,62.39 178.34,58.63 178.34,56.17 182.23,52.28 v2(182.23,51.75) 182.77,51.75 185.08,49.43 187.73,49.43 189.77,47.39 189.77,45.4 190.76,44.42 191.06,44.12 191.06,40.61 190.73,40.29 190.73,38.41 190.21,37.88 189.23,37.88 188.58,38.54 182.94,38.54 182.02,37.63 172.43,37.63 171.15,36.35 168.15,36.35 167.6,35.79 167.6,35.18 167.11,34.7 163.64,34.7 v2(162.97,35.36)
SLP_LAN#_C: length 16
  TOP w0.079: v1(127.86,82.96) 128.16,82.66 128.16,81.11 127.86,80.81
  TOP w0.102: 127.86,80.81 127.34,80.29 127.34,77.77 128.62,76.5 128.62,75.61 128.89,75.34 128.89,69.94 v2(128.77,69.82) 128.77,69.6 R648.1
  BOTTOM w0.079: v1(127.86,82.96) 127.64,82.96 U400.BT31
SLP_S3#_3R: length 641.6
  TOP w0.102: v2(161.6,35.16) 161.6,34.42 164.37,31.66 164.37,29.22 165.23,28.35 v2(165.41,28.35) ; v2(182.53,33.09) 182.58,33.14 PR9510.2 PR9509.2 ; PU9601.2 134.88,115.85 134.86,115.88 ; PR9610.2 114.44,60.93 115.07,61.56 115.07,62.25 113.92,63.4 109.08,63.4 105.72,60.05 67.63,60.05 66.19,61.49 66.19,65.89 63.7,68.38 63.22,68.38 62.22,69.37 53.2,69.37 v2(52.41,70.16) ; 134.86,115.88 134.22,115.88 v2(133.46,115.12) 132.8,114.46 PR9617.2 ; 134.86,115.88 v2(136,115.88) ; v2(187.02,47.55) 187.14,47.67 188,47.67 188.4,47.27 191.16,47.27 191.55,46.89 194.49,46.89 194.74,46.64 194.74,45.7 195.37,45.06 196.91,45.06 197.52,45.67 198.65,45.67 198.75,45.78 R4741.1 ; v2(118.25,112.42) 118.25,115.93 117.94,116.24 PU9600.2 116.39,116.24 116.24,116.39 116.24,116.72 116.41,116.89 PU9600.1
  IN1 w0.114: v2(182.53,33.09) 185.82,36.38 190.44,36.38 191.51,36.38 193.35,38.22 193.35,38.51 194.39,39.55 194.39,40.23 194.82,40.66 194.82,42.44 190.93,46.32 187.58,46.32 187.02,46.89 v2(187.02,47.55) 186.81,47.76 186.81,47.88 186.16,48.52 185.49,48.52 182.92,51.09 180.95,51.09 180.75,51.28 180.27,51.28 178.72,52.83 174.63,52.83 174.16,52.35 169.65,52.35 169.17,52.83 164.64,52.83 163.88,53.59 163.88,54.28 162.02,56.14 157.78,56.14 156.77,57.15 156.77,62.77 v2(152.68,66.86) ; v2(144.64,117.76) 144.54,117.86 138.39,117.86 v2(138.29,117.76) 138.09,117.56 138.09,117.01 136.97,115.88 v2(136,115.88) 135.1,114.98 133.45,114.98 132.19,113.72 126.35,113.72 125.08,112.45 123.05,112.45 122.67,112.07 120.13,112.07 120.02,112.18 118.48,112.18 v2(118.25,112.42) 118.01,112.18 115.71,112.18 114.23,113.66 102.14,113.66 101.9,113.42 90.58,113.42 90.03,113.98 90.03,117.86 89.05,118.84 83.32,118.84 80.28,121.88 76.91,121.88 76.31,122.48 73.9,122.48 72.74,123.64 70.6,123.64 69.94,124.29 63.99,124.29 63.9,124.2 59.25,124.2 58.66,123.62 53.08,123.62 52.64,123.17 49.78,123.17 44.07,117.47 34.01,117.47 30.37,113.82 26.59,113.82 20.66,107.89 v2(20.66,106.94) ; v2(51.11,48.77) 50.86,48.77 47.68,45.59 47.68,43.81 46.34,42.47 46.34,39.86 49.51,36.69 69.58,36.69 70.82,35.44 82.99,35.44 84.23,36.69 92.26,36.69 92.46,36.88 111.41,36.88 112.11,37.58 118.29,37.58 119.21,36.65 123.47,36.65 124.84,35.28 152.14,35.28 152.49,34.93 161.37,34.93 v2(161.6,35.16)
  IN2 w0.114: v2(153.17,20.63) 154.16,21.62 154.16,24.82 154.69,25.35 160.62,25.35 161.58,26.31 164.52,26.31 165.41,27.2 v2(165.41,28.35) ; v2(161.6,35.16) 161.6,34.83 163.38,33.05 171.03,33.05 173.57,35.59 178.49,35.59 178.88,35.21 180.42,35.21 v2(182.53,33.09)
  BOTTOM w0.102: R655.1 133.09,75.43 133.99,74.54 133.99,74.21 134.97,73.23 134.97,72.89 135.96,71.9 135.97,71.9 135.97,71.43 135.73,71.2 135.73,67.79 137.41,66.11 144.26,66.11 144.57,65.81 150.45,65.81 150.96,66.32 152.14,66.32 v2(152.68,66.86) 153.22,66.32 154.92,66.32 156.24,67.65 156.98,67.65 157.84,68.51 158.6,68.51 159.74,69.66 159.74,71.39 160.53,72.18 CN7701.11 ; v2(51.11,48.77) 51.75,48.14 52.18,48.14 52.43,48.39 52.43,49.56 53.15,50.27 54.01,50.27 55.61,51.87 55.61,53.02 55.35,53.27 55.35,55.71 54.14,56.92 54.14,60.45 53.54,61.05 53.54,61.61 54.08,62.16 54.08,66.99 53.54,67.53 53.54,69.03 v2(52.41,70.16) 52.41,76.15 51.8,76.76 51.8,79.05 50.44,80.41 43.76,80.41 42.99,81.18 42.99,85.07 40.11,87.94 36.81,87.94 36.18,88.58 26.09,88.58 21.21,93.46 21.21,106.39 v2(20.66,106.94) 20.66,108.04 PR8113.2 ; PU9202.1 145.03,116.91 145.12,117 145.12,117.27 v2(144.64,117.76) ; v2(153.17,20.63) 152.76,21.04 152.37,21.04 151.67,20.34 151.67,18.93 151.8,18.8 152.56,18.8 152.76,18.6 PQ8703.2 ; PR9215.2 140.07,117.76 139.77,117.76 139.04,118.48 138.45,118.48 138.29,118.33 v2(138.29,117.76)
SLP_S3#_3R_3: length 3.3
  TOP w0.102: PR9505.1 182.8,35.09 183.39,34.51 PR9509.1 PC9524.1 185.27,34.51 v2(185.4,34.64)
SLP_S3#_3R_5: length 12.3
  TOP w0.102: PR9506.2 189.47,35.2 189.47,35.58 v2(189.4,35.65) 188.97,36.07 182.61,36.07 182.17,35.63 182.17,34.92 PR9510.1 182.28,34.51 181.92,34.15 PC9525.1
SLP_S3#_3R_KBC: length 9.3
  TOP w0.076: v2(202.46,47.13) v2(201.74,47.13) 200.5,47.13 199.6,46.23 R4741.2
  TOP w0.102: v3(202.63,50.68) 202.61,50.7 202.61,51.97 U4701.D6
  IN2 w0.076: v2(202.46,47.13) 203.01,47.67 203.01,49.86 203,49.88 203,50.15 202.63,50.51 v3(202.63,50.68)
SLP_S3#_3R_PCH: length 7
  BOTTOM w0.079: R655.2 131.11,75.43 128.31,78.23 128.31,79.25 128.12,79.44 128.12,79.64 128.2,79.84 128.2,80.04 U400.BU36
SLP_S3_5R: length 152.8
  TOP w0.102: v2(164.24,87.5) 163.95,87.8 162.73,87.8 162.4,87.47 R4145.1
  IN1 w0.114: v2(164.24,87.5) 164.24,86.97 164.85,86.36 165.46,86.36 166.37,85.45 167.32,85.45 167.78,85.91 168.6,85.91 168.97,86.28 169.67,86.28 169.82,86.43 169.82,86.84 170.16,87.18 170.57,87.18 172.47,85.29 172.47,82.06 173.97,80.56 176.83,80.56 178.6,78.79 178.6,77.46 178.09,76.95 178.09,72.75 177.27,71.94 176.39,71.94 175.83,71.38 175.83,70.19 176.13,69.9 176.13,67.41 173.89,65.17 173.89,63.4 186.54,50.75 187.29,50.75 188.37,49.66 188.53,49.66 189.64,48.55 191.86,48.55 193.26,47.15 194.26,47.15 194.74,46.66 194.74,45.67 195.79,44.62 197.05,43.36 197.05,40.87 197.28,40.63 197.28,38.68 196.71,38.11 196.71,36.96 197.82,35.84 197.82,25.56 197.09,24.82 197.09,23.42 195.82,22.15 195.82,21.9 194.67,20.76 194.67,19.76 194.01,19.1 193.27,19.1 192.43,18.26 186.13,18.26 184.89,19.49 183.45,19.49 182.56,18.6 175.68,18.6 174.72,19.56 174.72,20.13 174.28,20.56 174.28,22.12 174.08,22.33 173.54,22.33 173.25,22.04 172.95,22.04 172.73,21.81 172.73,21.51 168,16.78 v2(153.82,16.78)
  BOTTOM w0.102: v2(153.82,16.78) 154.49,17.46 PR8718.1 154.03,18.21 154.03,18.47 153.41,19.09 PQ8703.6 153.41,20.03 153.3,20.15 152.92,20.15 152.76,20 PQ8703.5
SLP_S4#_3R: length 610.1
  TOP w0.102: v2(199.42,101.07) 199.07,101.43 U5801.4 ; v2(201.08,60.14) 201.08,59.61 200.95,59.48 R4739.1 ; PR9608.2 109.69,59.49 66.85,59.49 65.98,60.35 65.98,65.81 63.61,68.18 63.13,68.18 62.17,69.14 52.69,69.14 51.27,70.57 51.27,71.67 48.88,74.06 47.66,74.06 45.99,75.74 44.93,75.74 44.47,76.2 42.77,76.2 v2(42.72,76.15) 42.58,76 36.94,76 36.05,76.89 33,76.89 30.37,79.53 30.37,81.89 18.35,93.91 18.35,102.42 17,103.76 17,106.23 16.06,107.17 15.07,107.17 14.47,106.56 13.1,106.56 12.76,106.9 12.76,107.6 12.57,107.79 12.21,107.79 11.93,108.08 11.06,108.08 10.85,108.29 9.43,108.29 8.66,107.52 8.66,106.96 8.29,106.58 7.91,106.58 7.65,106.84 CN7600.16 ; PR8721.1 168.02,57.05 169.17,58.21 169.17,58.58 169.35,58.76 PD8700.2 170.87,58.76 171.41,59.29 171.41,60.01 171.73,60.33 172.18,60.33 172.38,60.12 173.1,60.12 173.89,60.92 174.32,61.34 174.32,62.1 175.47,63.25 175.47,64.93 175.62,65.08 176.88,66.34 177.55,67.02 v2(177.55,67.3) ; Q4110.2 165.43,89.06 v2(165.29,89.06) ; R656.1 149.94,69.53 150.87,70.46 152.82,70.46 v2(153.22,70.06) ; v2(185.25,64.36) 184.75,64.86 184.75,65.61 182.79,67.57 182.79,69.9 v2(182.99,70.11)
  IN1 w0.114: v2(42.72,76.15) 42.69,76.12 42.69,66.45 43.4,65.75 43.4,60.38 42.51,59.49 42.51,55.78 42.03,55.3 42.03,47.68 42,47.66 42,44.8 43.04,43.77 43.04,38.42 43.21,38.25 43.21,36.96 43.83,36.34 45.14,36.34 47.46,34.01 47.46,30.66 48.24,29.87 49.19,29.87 49.84,29.22 52.28,29.22 52.41,29.35 56.37,29.35 56.55,29.17 56.55,28.69 56.88,28.36 66.14,28.36 66.45,28.68 68.23,28.68 69.03,29.48 77.2,29.48 78.14,30.42 81.46,30.42 81.86,30.02 92.78,30.02 93,29.8 94.91,29.8 95.14,30.02 97.53,30.02 98.09,29.46 102.49,29.46 104.13,27.83 110.86,27.83 112.1,26.59 115.72,26.59 118.34,23.97 121.56,23.97 122.69,22.85 122.69,22.62 127.6,17.71 130.81,17.71 131.36,18.25 131.36,19.06 131.47,19.17 131.96,19.17 133.57,17.56 133.57,16.78 135.76,14.58 135.76,14.19 138.11,11.84 143.3,11.84 147.34,7.8 v2(147.49,7.8) 149.8,7.8 150.57,7.03 155.79,7.03 158.6,9.84 162.67,9.84 164.32,11.49 173.72,11.49 174.35,12.12 185.29,12.12 187.43,9.98 191.1,9.98 191.92,10.8 194.46,10.8 196.18,12.52 197.54,12.52 198.97,13.95 198.97,15.99 204.16,21.18 204.16,32.62 208.35,36.81 208.35,40.61 210.19,42.45 210.19,44.88 210.66,45.35 211.68,45.35 v2(212.66,44.36)
  IN2 w0.114: v2(185.25,64.36) 185.84,63.77 186.95,63.77 187.27,63.45 187.88,63.45 187.97,63.37 189.84,63.37 192.43,60.77 196.34,60.77 196.43,60.68 197.15,60.68 198.39,59.44 200.91,59.44 201.05,59.59 201.05,60.12 v2(201.08,60.14) 202.89,58.33 205.49,58.33 205.71,58.11 206.32,58.11 209.06,55.37 209.43,55.37 210.07,54.73 210.07,53.14 210.58,52.63 210.58,45.91 212.13,44.36 v2(212.66,44.36) ; v2(165.29,89.06) 166.09,89.86 169.46,89.86 169.71,90.11 173.85,90.11 174.53,90.78 177.11,90.78 178.76,92.44 180.09,92.44 182.71,89.82 185.07,89.82 186.15,88.73 186.15,86.63 187.21,85.57 v2(187.24,85.57) ; v2(153.22,70.06) 153.83,69.45 156.29,69.45 157.08,68.66 159.69,68.66 159.76,68.6 165.04,68.6 166.14,69.7 167.3,69.7 168.08,68.92 172.71,68.92 173.49,68.14 174.36,68.14 175.21,67.29 177.56,67.29 v2(177.55,67.3)
  BOTTOM w0.102: CN7701.13 159.53,69.74 158.51,68.72 157.02,68.72 156.37,69.37 153.91,69.37 v2(153.22,70.06) ; v2(212.66,44.36) 212.7,44.4 215.62,44.4 217.69,42.34 217.69,38.64 218.03,38.3 U5701.4 ; v2(147.49,7.8) 148.21,7.8 148.73,8.32 149.44,8.32 149.61,8.5 149.61,8.87 149.54,8.95 D3300.1 148.22,8.95 147.25,9.91 146.63,9.91 R3301.1 ; v2(177.55,67.3) 177.55,67.04 178.7,65.89 179.02,65.89 179.08,65.83 182.16,65.83 183.35,67.01 183.35,69.75 v2(182.99,70.11) 181.7,71.4 181.7,73.34 184.88,76.53 184.88,78.02 185.84,78.99 185.99,79.14 185.99,82.27 187.09,83.36 187.09,84.96 187.24,85.11 v2(187.24,85.57) 187.24,86.13 187.75,86.63 187.75,88.03 188.76,89.04 188.76,93.73 189.62,94.6 189.62,96.48 191.12,97.97 193.15,97.97 196.13,94.99 196.9,94.99 198.8,96.89 198.8,100.45 v2(199.42,101.07)
SLP_S4#_3R_PCH: length 31.2
  TOP w0.102: R656.2 148.32,69.53 147.32,70.52 v2(147,70.52)
  IN2 w0.079: v1(127.85,85.53) 128.28,85.1 128.28,84.56 129.09,83.75 129.09,82.1 129.61,81.57 130.29,81.57 130.81,81.06
  IN2 w0.114: v2(147,70.52) 146.22,69.74 144.7,69.74 143.71,70.74 143.71,71.68 141.32,74.06 138.44,74.06 133.82,78.69 133.82,79.34 133.17,79.99 132.01,79.99 131.05,80.96 130.91,80.96 130.81,81.06
  BOTTOM w0.102: U400.BU27 128.14,85.82 v1(127.85,85.53)
SLP_S4#_KBC: length 5.5
  TOP w0.102: U4701.F11 203.93,55.89 203.93,57.1 203.74,57.28 203.74,57.44 203.42,57.75 202.98,57.75 202.29,58.44 201.5,58.44 R4739.2
SLP_S4_5R: length 5.4
  TOP w0.102: Q4110.3 164.32,86.93 v2(164,86.93) 163.83,87.09 163.61,87.32 R4145.2 163.18,87.15 162.91,86.88 162.91,86.37 R4146.1 163.53,86.08 163.97,85.64 Q4102.2
SLP_S5#_3R: length 37.6
  TOP w0.102: v2(152.59,69.99) 152.59,69.87 v2(153.03,69.43)
  IN2 w0.079: v1(127.85,84.21) 128.25,83.8 128.25,82.53
  IN2 w0.114: v2(152.59,69.99) 152.39,70.19 150.79,70.19 150.12,69.51 144.61,69.51 143.48,70.64 143.48,71.58 141.27,73.79 138.39,73.79 133.59,78.6 133.59,79.25 133.15,79.69 131.94,79.69 130.97,80.65 129.93,80.65 128.94,81.64 128.61,81.64 128.25,82 128.25,82.53
  BOTTOM w0.102: U400.BT29 127.53,84.52 v1(127.85,84.21) ; v2(152.59,69.99) 152.59,69.98 150.76,71.81 R7700.1
SLP_WLAN_PCH#: length 8.8
  TOP w0.079: v1(127.86,83.55) 128.33,83.08 128.33,80.95 128.2,80.83 128.2,80.5
  TOP w0.102: TP406.1 129.14,76.36 128.2,77.3 128.2,80.5
  BOTTOM w0.079: v1(127.86,83.55) 127.54,83.87 U400.BT30
SM_INTRUDER#: length 9.1
  BOTTOM w0.079: v2(130.83,73.61) R461.1 130.01,74.86 126.82,78.04 126.82,79.06 126.73,79.15 126.73,79.69 126.77,79.78 126.77,80.48 U400.BR35
SM_RCOMP_0: length 12.2
  TOP w0.305: R545.1 124.44,74.84 124.01,75.27 124.01,77.68 124.44,78.11 124.52,78.11 125.19,78.77 125.19,79.35 124.6,79.94 124.6,81.51 125.07,81.98 125.07,84.09 125.84,84.87 v1(125.97,84.87)
  BOTTOM w0.305: v1(125.97,84.87) 125.94,84.84 125.89,84.84 U400.BN28
SM_RCOMP_1: length 12.4
  TOP w0.305: R546.1 123.43,75.11 123.29,75.24 v2(123.29,76.03) 123.29,77.67 124.11,78.49 124.11,82 124.67,82.56 124.67,84.28 125.89,85.5 v1(125.97,85.5)
  BOTTOM w0.079: v1(125.97,85.5) 125.65,85.82 U400.BN27
SM_RCOMP_2: length 9.6
  TOP w0.305: R547.1 126.43,76.45 125.58,77.3 125.58,79.86 125.6,79.88 125.6,81.55 125.46,81.68 125.46,83.9 125.73,84.17 v1(125.93,84.17)
  BOTTOM w0.254: v1(125.93,84.17) 125.59,84.52 U400.BN29
SM_VREF: length 96.2
  TOP w0.508: R2813.1 119.52,42.45 119.65,42.58 C2828.1 119.66,43.21 v2(120.22,43.77) ; v2(69.88,65.51) 74.19,65.51 80.36,71.68 90.13,71.68 92.96,74.52 92.96,75.28 95.46,77.78 v1(95.46,78.54)
  IN1 w0.508: v2(113.8,46.77) 117.22,46.77 v2(120.22,43.77)
  BOTTOM w0.203: v1(95.46,78.54) 95.97,78.54 96.31,78.88 96.31,79.01 96.6,79.3 96.6,79.61 96.99,80 U400.F36
  BOTTOM w0.508: v2(69.88,65.51) 70.77,65.51 83.12,53.17 103.59,53.17 110.22,46.54 113.57,46.54 v2(113.8,46.77)
SMB_ME0_CLK: length 28.5
  TOP w0.079: 137.9,94.29 137.68,94.06 135.48,94.06 v1(135.16,93.74)
  TOP w0.102: 137.9,94.29 137.98,94.37 139.89,94.37 140.32,94.8 141.71,94.8 v2(142.7,95.79) 143.17,96.26 144.97,96.26 145.54,95.69 146.89,95.69 147.1,95.89 148.39,95.89 149.1,95.18 149.81,95.18 150.12,95.49 152.21,95.49 152.73,94.96 153.89,94.96 154.37,94.48 157.4,94.48 158.98,96.07 R419.2
  BOTTOM w0.079: U400.CH14 135.16,93.93 v1(135.16,93.74)
SMB_ME0_DAT: length 31
  TOP w0.079: v1(133.76,92.71) 134.25,93.2 134.58,93.2 134.78,93.4 134.78,93.87 135.14,94.23 137.21,94.23 137.4,94.42
  TOP w0.102: 137.4,94.42 138.01,95.03 138.77,95.03 140.08,96.34 140.86,96.34 140.96,96.44 141.67,96.44 142.06,96.83 v2(143.93,96.83) 145.2,96.83 145.53,96.5 148.46,96.5 149.3,95.66 149.61,95.66 149.92,95.97 152.42,95.97 152.94,95.46 154.08,95.46 154.58,94.97 157.2,94.97 158.55,96.32 158.78,96.55 159.51,96.55 R420.2
  BOTTOM w0.079: U400.CF15 133.56,92.91 v1(133.76,92.71)
SMB_PCH_CLK: length 91.3
  TOP w0.102: Q4700.1 188.08,54.06 v2(187.85,53.83)
  IN2 w0.127: v2(187.85,53.83) 187.51,53.83 187.39,53.71 186.06,53.71 181.85,57.91 181.85,62 180.1,63.75 180.1,66.84 179.62,67.32 179.62,68.6 179.42,68.8 178.72,68.8 178.08,69.43 174.96,69.43 174,70.39 173.03,70.39 172.42,71 167.78,71 166.38,72.4 164.83,72.4 163.81,73.41 163.81,74.07 163.66,74.23 162.03,74.23 160.99,73.19 152.25,73.19 150.85,74.59 150.85,75.87 v2(151.12,76.14)
  BOTTOM w0.079: U400.CN15 138.15,93.63 138.27,93.63 138.32,93.67 138.56,93.67 138.6,93.65 138.66,93.63 139.01,93.63 139.22,93.83 139.58,93.83 139.76,93.65 139.76,93.27 140.03,93 140.28,92.75 141.45,92.75 142.41,93.71 143.27,93.71 R417.2
  BOTTOM w0.102: v2(151.12,76.14) 151.11,76.14 150.33,76.92 150.33,82.52 153.65,85.84 153.65,88.83 153.91,89.08 153.91,90.48 153.78,90.61 153.78,91.62 152.76,92.64 152.59,92.64 152.05,93.17 149.6,93.17 149.51,93.09 147.2,93.09 146.55,93.75 143.86,93.75 143.7,93.58 R417.2
SMB_PCH_DAT: length 92
  TOP w0.102: v2(189.96,55.57) 189.96,56.46 Q4700.4
  IN2 w0.127: v2(189.96,55.57) 189.92,55.53 184.78,55.53 182.23,58.07 182.23,62.16 180.48,63.91 180.48,68.28 179.19,69.57 179.19,70.08 178.95,70.32 178.09,70.32 177.58,69.81 175.12,69.81 174.16,70.77 173.19,70.77 171.8,72.15 167.23,72.15 166.61,72.78 165.46,72.78 164.96,73.28 164.96,73.59 163.94,74.61 161.87,74.61 160.84,73.57 152.48,73.57 v2(151.32,74.73)
  BOTTOM w0.079: 145.91,93.3 R418.2 145.67,93.04 145.45,92.82 142.25,92.82 142.01,92.58 140.15,92.58 139.66,93.07 139.22,93.07 139.13,93.15 137.65,93.15 137.39,93.41 U400.CM15
  BOTTOM w0.102: v2(151.32,74.73) 150.88,75.17 150.88,75.19 150.87,75.2 150.87,75.63 150.76,75.75 150.76,75.94 150.71,75.99 150.71,76 149.92,76.79 149.92,82.62 153.29,85.99 153.29,88.55 153.02,88.83 153.02,89.72 153.4,90.1 153.4,91.47 151.9,92.97 149.85,92.97 149.62,92.73 146.77,92.73 146.2,93.3 145.91,93.3
SMC: length 7.9
  TOP w0.102: PCN8500.5 89.64,26.78 89.64,29.66 PC8507.2 91.28,31.29 v2(91.28,31.58) 91.06,31.81 90.16,31.81 PR8516.1
SMD: length 6
  TOP w0.102: PCN8500.6 85.12,28.41 v2(85.12,28.94) 84.19,29.87 PC8508.2 PR8517.1
SMDDR_VREF_DQ0_M3: length 8.3
  BOTTOM w0.079: 94.98,78.92 95.17,79.11 95.32,79.11 95.59,79.38 95.59,79.71 96.02,80.14 U400.D35
  BOTTOM w0.508: 94.98,78.92 94.52,78.47 94.52,77.15 TP418.1
SMDDR_VREF_DQ1_M1: length 3.5
  TOP w0.508: R2822.2 125.3,36.63 123.3,36.63 122.7,37.23 C2856.1
  vias: v2(122.02,40.4)
SMDDR_VREF_DQ1_M3: length 97.2
  TOP w0.508: v2(120.94,42.98) 121.19,43.24 C2857.1 121.56,42.48 R2841.1 ; v2(70.16,66.53) 70.19,66.55 73.8,66.55 v2(78.11,70.87) 79.94,72.7 89.71,72.7 91.94,74.94 91.94,75.7 93.65,77.4 93.65,77.89 95.06,79.3 95.64,79.3 v1(95.87,79.08)
  IN1 w0.508: v2(120.94,42.98) 121.32,43.36 121.32,44.28 117.81,47.78 113.2,47.78 v2(112.97,47.55)
  BOTTOM w0.254: v1(95.87,79.08) 95.92,79.08 96.27,79.43 96.27,79.78 U400.E36
  BOTTOM w0.508: v2(112.97,47.55) 110.64,47.55 104.01,54.18 83.54,54.18 71.19,66.53 v2(70.16,66.53)
SN3V: length 2.1
  TOP w0.102: 176.96,22.91 176.96,22.19 176.65,21.88 v2(176.65,20.92)
SP_CLK: length 13
  TOP w0.076: U4701.H2 205.88,49.39 205.88,48.97 206.48,48.37 206.48,48.07 206.93,47.62
  TOP w0.102: 206.93,47.62 207.74,47.62 208.83,46.53 208.83,46.16 209.05,45.95 209.35,45.95 209.87,46.47 v2(214.49,46.47) 215.03,46.47 215.74,47.17 R4720.2
SP_DATA: length 11.8
  TOP w0.102: U4701.J2 206.53,49.38 206.53,48.9 206.84,48.6 206.84,48.22 207.06,47.99 207.89,47.99 208.99,46.89 209.56,46.89 209.63,46.96 v2(211.37,46.96) 214.84,46.96 215.79,47.91 R4722.2
SPI_TPM_CS#: length 53.2
  TOP w0.102: TP5100.1 153.78,74.73 153.02,75.49 152.64,75.49 v2(151.95,74.81)
  TOP w0.114: U5100.20 173.62,71.23 v2(173.62,71.23) 173.87,71.23 173.88,71.22 173.89,71.22 174.36,70.75 R5101.2
  IN2 w0.114: v2(173.62,71.23) 173.28,71.23 171.99,72.53 167.38,72.53 167.02,72.89 167.02,73.76 166.76,74.02 165.06,74.02 164.09,74.98 161.72,74.98 160.68,73.94 152.64,73.94 151.95,74.63 v2(151.95,74.81)
  BOTTOM w0.079: 141.83,76.42 141.66,76.59 141.17,76.59 140.47,77.29 140.47,77.63 140.83,77.99 140.83,78.38 140.54,78.67 140.34,78.67 140.27,78.74 139.17,78.74 138.86,78.43 135.8,78.43 135.3,78.94 135.3,79.63 135.11,79.81 135.07,79.89 135.07,80.48 134.97,80.57 134.97,81.14 134.97,81.14 134.97,81.27 U400.CH34
  BOTTOM w0.102: v2(151.95,74.81) 151.95,74.35 151.6,74 v2(149.73,74) 145.4,74 143.57,75.82 142.63,75.82 142.03,76.42 141.83,76.42
SRTC_RST#: length 142.3
  TOP w0.102: Q7500A.3 52.21,55.29 52.41,55.08 56.93,55.08 v2(57.01,55.17) ; v2(61.99,58.73) 64.13,56.58 106.96,56.58 108.47,55.08 140.38,55.08 141.03,55.73 144.45,55.73 150.87,62.15 v2(150.87,62.75)
  BOTTOM w0.079: 130.26,75.31 130.09,75.31 127.17,78.23 U400.BR37
  BOTTOM w0.102: v2(61.99,58.73) 61.99,58.34 58.83,55.17 57.02,55.17 v2(57.01,55.17) ; v2(150.87,62.75) 150.22,63.4 143.57,63.4 143.29,63.68 135.29,63.68 132.89,66.09 132.89,67.5 131.66,68.73 131.66,70.54 131.66,70.55 131.66,71.07 131.27,71.47 C430.1
  BOTTOM w0.112: C430.1 131.27,72.19 131.6,72.53 131.6,73.9 R601.1 131.79,74.63 130.93,74.63 130.26,75.31
SUSCLK32_KBC: length 211.7
  TOP w0.079: v2(209.33,52.14) 209.19,52 208.68,52 208.68,52 207.85,52 U4701.L5
  IN2 w0.127: v2(217.33,54.22) 217.33,54.65 217.34,54.65 217.34,57.1 216.47,57.97 215.16,57.97 211.79,61.34 209.88,61.34 207.95,63.27 206.27,63.27 205.89,63.65 204.93,63.65 202.68,65.9 202.68,67.81 199.96,70.52 199.62,70.52 197.18,72.95 193.84,72.95 193.62,73.17 193.62,77.78 193.32,78.08 193.32,78.88 191.96,80.24 191.96,84.93 192.35,85.33 192.35,89.17 190.71,90.81 190.07,90.81 185.43,95.45 176.97,95.45 176.9,95.52 173.62,95.52 v2(173.44,95.34)
  BOTTOM w0.079: U400.BT32 127.31,82.49 127.31,82.06 127.27,82.02 126.85,81.6 126.85,81.13 126.63,80.92 126.49,80.92 126.26,80.69 126.26,80.44 126.29,80.39 126.29,80.05 126.22,79.92 126.22,79.53 125.95,79.25 125.95,78.6 126.27,78.27 126.34,78.27
  BOTTOM w0.102: 213.27,50.55 213.45,50.73 213.84,50.73 214.75,51.63 214.75,51.93 217.04,54.22 v2(217.33,54.22) ; 213.27,50.55 213.27,48.54 212.61,47.87 212.61,45.36 211.3,44.05 209.69,44.05 208.05,42.41 203.63,42.41 200.43,39.2 199.44,39.2 198.78,39.87 198.78,41.16 196.19,43.74 196.19,46.01 195.48,46.72 195.48,47.12 193.75,48.86 190.08,48.86 188.26,50.68 173.73,50.68 170.17,54.24 170.17,55.25 167.04,58.38 167.04,58.65 164.69,60.99 163.31,60.99 161.45,62.84 159.69,62.84 159.34,63.2 154.36,63.2 152.82,61.66 149.52,61.66 148.74,62.44 143.17,62.44 142.89,62.72 134.89,62.72 131.92,65.69 131.92,67.1 130.69,68.33 130.69,70.31 130.38,70.62 130.38,70.75 129.52,71.61 129.52,75.09 126.34,78.27 ; 213.27,50.55 213.14,50.68 211.95,50.68 210.48,52.14 v2(209.33,52.14) ; v2(173.44,95.34) 172.97,94.87 172.97,93.7 R4120.1
SUSCLK32_KBC_WLAN: length 4.4
  BOTTOM w0.102: v2(174.15,93.94) 173.84,93.62 173.84,93.06 R4120.2 172.97,92.55 172.78,92.36 172.78,92.11 172.63,91.95 172.63,91.57 172.95,91.25 CN4100.50
SY8270C_LX:
  vias: v2(190.36,19.87)
SY8270CBST:
  vias: v2(189.09,19.61)
SY8270CEN: length 5.1
  BOTTOM w0.102: PR8616.1 196.25,21.11 v2(196.4,21.11)
  BOTTOM w0.254: PU8601.6 193.78,22.9 194.23,22.45 PC8637.1 194.72,22.45 195.23,21.94 PR8616.1 195.43,21.94 195.43,22.95 PR8628.2
SY8270CFB: length 2.7
  BOTTOM w0.254: PR8619.1 194.8,21.56 v2(194.57,21.78) 194.39,21.97 194.12,21.97 193.64,22.45 PU8601.7
SY8270CFB_S: length 2
  BOTTOM w0.102: PR8619.2 195.57,20.96 PC8641.1 195.57,19.99 v2(196.33,19.23)
SY8270CLDOEN: length 3.5
  BOTTOM w0.254: PR8625.1 PR8626.2 v2(194.42,23.69) 194.07,23.35 PU8601.5
SY8270CPG: length 16.8
  TOP w0.102: PR8627.2 191.94,19.61 195.09,22.76 195.09,23.97 195.3,24.18 v2(196.39,24.18)
  BOTTOM w0.102: v2(196.39,24.18) 196.51,24.18 196.86,24.53 196.86,25.35 196.24,25.98 195.55,25.98 195.16,26.37 194.57,26.37 193.94,25.74 193.94,25.23 v2(193.46,24.75) 193.1,24.39 192.36,24.39 192.27,24.3 PU8601.4
SY8270CVOUT: length 20.1
  TOP w0.305: v2(199.42,26.09) v2(199.42,29.45)
  BOTTOM w0.254: PU8601.8 193.54,22 194,21.54 194,20.79 PC8641.2 194.79,18.99 v2(194.93,18.85) 195.13,18.65 196.5,18.65 196.83,18.98 196.83,20.63 198.61,22.41 198.61,23.3 198.36,23.55 198.36,25.84 198.61,26.09 v2(199.42,26.09)
  BOTTOM w0.305: v2(199.42,29.45) 199.3,29.32 PR8617.2
SY8286BBST:
  vias: v2(181.23,23.78)
SY8286BBST_S: length 1.5
  BOTTOM w0.508: PC8608.1 180.86,25.95 PR8601.2
SY8286BBSW: length 5.6
  IN2 w0.508: v2(180.29,20.68) 180.01,20.96 180.01,23.61 v2(178.88,24.74)
  BOTTOM w0.229: PU8600.6 179.75,20.8 179.87,20.68 v2(180.29,20.68)
SY8286BEN: length 3.4
  BOTTOM w0.203: PU8600.12 176.9,22.11
  BOTTOM w0.254: PR8602.2 175.37,23.09 PR8604.1 175.43,22.38 PC8609.1 176.63,22.38 176.9,22.11
SY8286BFB: length 2.8
  BOTTOM w0.203: 176.95,22.56 PU8600.13
  BOTTOM w0.254: 176.95,22.56 176.45,23.06 176.45,23.91 PR8608.1
SY8286BFB_S: length 1
  BOTTOM w0.254: PC8620.1 PR8608.2
SY8286BLDOEN: length 3
  BOTTOM w0.203: PR8609.1 176.69,20.79 176.69,21.44 176.91,21.66 PU8600.11
  BOTTOM w0.254: PR8610.2 176.33,20.66 PR8609.1
SY8286BPG: length 2.6
  BOTTOM w0.102: v2(179.37,19.08) 179.37,19.17 178.66,19.88 PR8603.2 178.4,20.02 178.4,20.57
  BOTTOM w0.112: 178.4,20.57 PU8600.9
SY8286BVOUT: length 11.4
  TOP w0.254: PR8606.1 v2(175.6,32.75)
  BOTTOM w0.203: PU8600.14 177.03,23.01
  BOTTOM w0.254: 177.03,23.01 176.92,23.12 176.92,24.32 v2(176.78,24.46) 175.96,25.27 PC8620.2 175.96,26.23 175.6,26.6 v2(175.6,32.75)
TACH_FAN_IN: length 255.2
  TOP w0.102: U4701.E10 v3(203.93,55.23) ; R5402.2 46.87,65.59 C5403.1 46.45,66.16 46.95,66.66 v2(47.73,66.66)
  IN2 w0.076: 200.56,47.58 200.56,48.41 201.09,48.93 201.09,49.52 200.85,49.76 200.85,52 201.07,52.23 201.07,53.48 202.3,54.7 202.3,55.45 202.44,55.6 202.76,55.6 202.95,55.4 202.95,55.05 203.08,54.92 203.46,54.92 203.78,55.23 v3(203.93,55.23)
  IN2 w0.114: v2(50.33,34.27) 50.33,33.97 50.68,33.61 51.11,33.61 52.69,32.03 52.69,31.24 55.79,28.13 57.33,28.13 57.58,28.39 65.02,28.39 65.93,29.3 68.36,29.3 71.48,32.42 81.56,32.42 82.59,31.39 91.5,31.39 91.67,31.22 95.94,31.22 96.24,31.52 97.84,31.52 98.03,31.71 102.08,31.71 102.18,31.61 108.43,31.61 112.65,27.39 115.42,27.39 117.34,25.47 121.76,25.47 123.81,23.42 124.83,23.42 127.13,21.13 127.13,20.19 129.47,17.85 131.65,17.85 133.9,15.59 136.82,15.59 137.7,14.71 137.7,13.22 138.51,12.41 144.65,12.41 145.02,12.04 147.02,12.04 147.66,12.68 153.42,12.68 153.79,12.32 162.2,12.32 163.46,13.58 184.32,13.58 185.68,14.94 193.94,14.94 194.56,15.57 195,15.57 199.93,20.5 199.93,22.44 200.55,23.06 200.55,33.25 202.2,34.9 202.2,43.8 200.56,45.44 200.56,47.58
  BOTTOM w0.102: v2(50.33,34.27) 49.61,34.98 48.71,34.98 47.67,36.03 47.67,38.71 46.44,39.93 46.44,42.09 47.6,43.25 47.6,46.22 49.47,48.09 49.47,49.03 50.02,49.59 50.78,49.59 51.54,50.35 51.54,50.73 51.71,50.89 53.37,50.89 53.7,51.22 53.7,51.46 53.42,51.75 53.42,53.05 52.39,54.07 52.01,54.07 51.2,54.88 51.2,57.92 49.92,59.2 49.92,60.25 48.92,61.25 48.92,65.75 48.01,66.66 v2(47.73,66.66) CN5400.2
THERM_SCI#: length 37.8
  TOP w0.079: 136.81,99.9 136.05,99.9 135.94,99.79 135.94,96.49 135.42,95.97 135.42,95.61 135.1,95.3 134.9,95.3 133.54,96.66 v1(133.54,96.73)
  TOP w0.102: U5400.6 161.8,101.73 161.29,101.22 R414.2 v2(159.48,101.22) 156.36,101.22 154.15,103.43 150.06,103.43 148.81,102.18 148.81,101.39 148.45,101.02 147.65,101.02 147.28,100.65 145.11,100.65 144.71,101.05 138.99,101.05 137.84,99.9 136.81,99.9
  BOTTOM w0.079: U400.CE9 133.31,96.91 133.49,96.73 v1(133.54,96.73)
THERM_SCL: length 302.2
  TOP w0.102: U5400.8 163.31,100.43 163.38,100.36 163.38,99.17 164.33,98.22 165.84,98.22 166.2,98.58 R5408.2 166.2,99.53 165.77,99.95 165.77,101.35 164.97,102.15 v2(164.86,102.15) ; v2(65.22,65.42) 65.22,65.44 63.19,67.47 62.75,67.47 61.81,68.41 52.42,68.41 50.55,70.27 50.55,71.37 48.58,73.35 47.37,73.35 45.8,74.92 42.13,74.92 40.83,73.61 39.07,73.61 38.76,73.31 38.76,72.46 v2(39.87,71.36) ; Q5402.1 62.28,27 61.75,26.46 v2(61.75,24.91) 62.47,24.19 65.77,24.19 66.29,24.71 67.13,24.71 67.4,24.43 C5303.1 67.4,24.05 68.05,23.41 68.05,23.25 68.32,22.98 U5300.1
  IN1 w0.127: v2(61.75,24.91) 61.73,24.93 61.22,24.93 60.63,24.34 58.56,24.34 58.14,24.76 50.8,24.76 48.01,21.98 41.51,21.98 40.28,23.2 40.28,25.67 39.91,26.03 39.91,28.85 41.07,30.01 41.07,32.32 40.57,32.82 40.57,33.76 37.92,36.41 37.92,48.21 38.75,49.04 38.75,57.24 40.19,58.68 40.19,59.84 41.51,61.16 41.51,64.87 40.76,65.62 40.76,66.53 39.5,67.79 39.5,70.99 v2(39.87,71.36) ; v2(86.14,111.45) 86.14,110.63 81.7,106.2 81.7,104.45 72.1,94.85 65.16,94.85 63.17,92.87 57.67,92.87 57.41,93.12 56.77,93.12 56.34,92.69 v2(55.91,92.69)
  IN2 w0.127: v2(86.14,111.45) 86.14,112.11 87.49,113.46 90.16,113.46 90.44,113.17 107.91,113.17 110.76,116.02 115.83,116.02 116.12,116.3 118.48,116.3 119.77,117.59 121.95,117.59 124.27,119.91 126.41,119.91 126.98,120.48 127.41,120.48 128.02,119.88 131.55,119.88 131.71,119.72 140.74,119.72 141.2,119.26 143.12,119.26 144.09,120.23 152.25,120.23 152.76,120.73 154.12,120.73 v2(154.26,120.87)
  BOTTOM w0.102: v2(154.26,120.87) 154.26,120.74 154.49,120.51 154.49,119.43 154.31,119.26 154.31,118.98 154.06,118.72 154.06,118.27 154.57,117.76 154.57,115.52 161.2,108.89 161.2,108.03 163.19,106.03 164.12,106.03 165,105.15 165,102.29 v2(164.86,102.15) ; v2(55.91,92.69) 55.91,92.69 56.07,92.54 56.07,89.03 56.74,88.35 56.74,75.94 58.97,73.71 62.06,73.71 65.55,70.22 65.55,65.75 v2(65.22,65.42)
THERM_SDA: length 312.4
  TOP w0.102: v2(63.35,24.89) 64.16,25.7 Q5402.4 ; v2(40.07,70.62) 39.88,70.62 38.41,72.09 38.41,73.48 38.9,73.97 40.68,73.97 41.99,75.27 45.95,75.27 47.52,73.7 48.73,73.7 50.91,71.52 50.91,70.42 52.57,68.76 61.96,68.76 62.9,67.82 63.39,67.82 65.63,65.59 65.63,65.15 v2(65.22,64.74) ; v2(164.16,102.15) 164.6,101.71 164.83,101.71 165.41,101.12 165.41,100.39 164.6,99.57 164.6,99.39 R5407.2 164.22,99.58 164.22,99.73 165.06,100.56 165.06,100.94 164.7,101.3 163.66,101.3 163.44,101.08 U5400.7 ; v2(71.71,24.19) 71.71,23.74 C5302.1 71.29,23.53 70.53,22.78 70.32,22.78 70.23,22.86 U5300.4
  IN1 w0.127: v2(85.69,111.89) 85.69,110.72 81.32,106.35 81.32,104.6 71.95,95.23 65,95.23 63.27,93.5 56.03,93.5 v2(55.94,93.41) ; v2(71.71,24.19) 72,23.89 72,21.73 71.56,21.29 69.07,21.29 68.16,22.2 68.16,23.25 67.42,23.98 64.25,23.98 v2(63.35,24.89) 62.71,25.52 61.24,25.52 60.44,24.73 58.81,24.73 58.37,25.17 50.67,25.17 47.86,22.36 41.66,22.36 40.66,23.36 40.66,25.83 40.29,26.19 40.29,28.7 41.46,29.86 41.46,32.47 40.95,32.98 40.95,33.94 38.31,36.59 38.31,48.06 39.22,48.97 39.22,57.08 40.57,58.42 40.57,59.68 41.89,61.01 41.89,65.03 41.14,65.78 41.14,66.69 39.93,67.89 39.93,70.48 v2(40.07,70.62)
  IN2 w0.127: v2(85.69,111.89) 85.69,112.19 87.33,113.84 90.32,113.84 90.6,113.55 107.75,113.55 110.6,116.4 115.68,116.4 115.96,116.68 118.32,116.68 119.61,117.98 121.79,117.98 124.11,120.29 126.25,120.29 126.82,120.86 131.1,120.86 131.87,120.1 140.9,120.1 141.35,119.64 142.96,119.64 143.93,120.61 152.1,120.61 152.65,121.16 v2(153.59,121.16)
  BOTTOM w0.102: v2(153.59,121.16) 153.59,120.91 154.14,120.37 154.14,119.58 153.96,119.4 153.96,119.13 153.7,118.87 153.7,118.12 154.21,117.61 154.21,115.37 160.84,108.74 160.84,107.88 163.05,105.67 163.98,105.67 164.65,105 164.65,102.64 v2(164.16,102.15) ; v2(65.22,64.74) 65.96,65.48 65.96,70.31 62.21,74.06 59.12,74.06 57.1,76.09 57.1,88.5 56.42,89.18 56.42,93.25 56.26,93.41 v2(55.94,93.41)
