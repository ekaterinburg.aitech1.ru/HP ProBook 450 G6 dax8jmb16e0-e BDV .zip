# Allegro board dax8jmb16e0-e-www.DeviceDB.xyz_.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND0: length 9.1
  TOP w0.102: R7726.2 39,122.69 39.27,122.96 40.2,122.96 v2(40.44,122.71) 41.38,122.71 41.89,122.2 41.89,121.7 41.25,121.05 R7722.2 39.98,121.05 39.91,120.99 39.91,120.75 40.76,119.9 CN7700.1
VCC1_RST#: length 80.4
  TOP w0.102: v2(212.55,50.19) 212.8,50.19 R4743.1 213.02,50.48 212.41,51.08 211.95,51.08 211.62,51.41 R4748.1 211.62,51.92 211.37,52.17 210.9,52.17 v2(210.24,52.83) 210.05,53.03 208.76,53.03 208.36,52.63 207.18,52.63 U4701.K6
  BOTTOM w0.102: CN7701.3 164.54,71.98 164.75,71.77 164.75,68.24 167.34,65.65 167.34,64.5 171.26,60.58 172.13,60.58 173.68,59.04 173.68,57.89 177.01,54.55 179.11,54.55 180.11,55.55 182.5,55.55 184.02,54.02 185.03,54.02 186.05,53.01 187.94,53.01 188.39,53.47 189.56,53.47 190.44,54.34 190.44,54.9 191.31,55.78 191.73,55.78 192.35,56.41 193.16,56.41 193.78,55.78 195.17,55.78 195.37,55.58 195.37,51.15 198.38,48.14 198.38,47.18 199.58,45.99 201.62,45.99 201.87,45.74 203.11,45.74 203.43,46.05 205.32,46.05 207.09,47.82 207.49,47.82 209.65,49.98 210.65,49.98 210.86,50.19 v2(212.55,50.19)
VCCGT_CS1: length 16.6
  TOP w0.178: PR8817.2 46.08,104.81 44.98,103.71 43.92,103.71 43.66,103.45 PU8800.1
  TOP w0.254: v2(49.84,108.46) 49.23,108.46 47.4,106.63 46.85,106.63 46.56,106.35 46.56,105.68 PR8817.2
  BOTTOM w0.254: PR9002.1 50.57,102.64 49.83,103.38 49.83,106.41 50.42,107 50.42,107.89 v2(49.84,108.46)
VCCGT_CS_SUM: length 26.2
  TOP w0.102: PR8817.1 PR8856.1 PR8853.2 47.32,107.36 47.81,107.85 47.81,109.02 47.23,109.61 46.82,109.61 46.24,110.19 45.17,110.19 v2(44.2,111.16)
  TOP w0.203: v2(37.67,100.12) 37.82,100.12 37.93,100.23 PU8800.18
  IN1 w0.114: v2(37.67,100.12) 37.49,100.12 37.17,100.44 37.17,105.55 37.62,105.99 37.62,106.84 40.23,109.45 41.89,109.45 43.67,111.23 44.13,111.23 v2(44.2,111.16)
  BOTTOM w0.102: v2(37.67,100.12) v2(37.67,99.4)
VCCGT_PWM1: length 12.8
  TOP w0.203: v2(50.58,101.12) 50.73,100.97 50.73,100.21 50.45,99.93 50.45,97.06 50.22,96.83 49.64,96.83 49.03,97.44 46.36,97.44 45.84,97.96 45.84,98.31 45.12,99.03 PU8800.36
  BOTTOM w0.102: v2(49.98,101.37) 50.23,101.12 v2(50.58,101.12)
  BOTTOM w0.254: v2(50.58,101.12) 51.16,101.12 PR9000.1
VCCGT_VDIFF: length 4
  TOP w0.102: PR8832.1 PC8816.2
  TOP w0.203: PR8832.1 38.98,105.17 v2(39.78,104.38) 39.78,104.21 40.46,103.53 PU8800.9
VCCGT_VFB: length 8.4
  TOP w0.102: PR8832.2 PC8816.1 PR8861.2 PR8860.2 38.62,108.63 38.62,108.84 PR8834.1 v2(39.8,109.2)
  TOP w0.203: PR8832.2 38.2,104.92 38.73,104.39 39.08,104.39 40.06,103.4 PU8800.10
VCCGT_VORTN: length 4.3
  TOP w0.178: PU8800.12 39.26,103.12 38.99,103.4 37.98,103.4 v2(37.09,104.29) 36.96,104.29 PR8839.1
VCCGT_VOSEN: length 3.8
  TOP w0.203: PU8800.11 39.66,103.35 39.05,103.96 v2(38.39,103.96) 37.15,105.2 PR8837.1
VCCIO_EN: length 4
  BOTTOM w0.102: PC9222.1 139.27,117.65 v2(138.87,118.05)
  BOTTOM w0.254: PU9201.4 140.2,115.51 140.11,115.61 PR9211.1 140.11,116.39 140.18,116.47 140.18,116.97 139.99,117.17 139.38,117.17 PC9222.1
VCCIO_PG: length 172
  TOP w0.102: v2(54.01,67.65) 61.68,67.65 62.42,66.91 62.91,66.91 64.29,65.54 64.29,63.9 63.64,63.25 63.64,60.8 65.48,58.96 65.59,58.84 109.07,58.84 110.48,57.43 125.99,57.43 126.81,58.25 126.81,59.97 127.19,60.36 127.19,60.95 126.75,61.39 126.49,61.39 126.11,61.76 126.11,63.17 126.74,63.79 127.34,63.79 127.75,64.2 R449.2 127.75,64.91 127.8,64.95 U401.2 127.8,66.27 127.66,66.41 127.51,66.41 126.83,67.08 126.83,69.21 126.04,70 R452.2
  BOTTOM w0.102: v2(54.01,67.65) 54.01,69.09 53.2,69.91 53.2,75.88 52.05,77.02 52.05,79.3 47.1,84.26 44.56,84.26 40.37,88.45 37.07,88.45 36.43,89.08 26.85,89.08 23.61,92.32 23.61,111.11 22.24,112.49 19,112.49 18.02,113.47 17.51,113.47 14.97,116.01 PR8100.1
VCCIO_VCCSENSE: length 31.7
  TOP w0.254: v2(142.65,76.51) 140.44,74.3 140.44,72.53 v2(140.43,72.52)
  IN2 w0.254: v1(126.85,84.87) 126.4,84.42 126.4,81.95 127.77,80.57 128.86,80.57 129.7,79.74 130.67,79.74 131.25,79.15 131.25,79.03 131.79,78.49 132.8,78.49 136.97,74.33 136.97,73.28 137.73,72.52 v2(140.43,72.52)
  BOTTOM w0.254: U400.BP28 126.55,85.17 v1(126.85,84.87) ; TP421.1 143.95,79.35 143.95,78.26 143.48,77.79 143.48,77.34 v2(142.65,76.51)
VCCIO_VSSSENSE: length 11.2
  TOP w0.079: 127.15,81.55 127.44,81.84 127.44,83.23 127.26,83.4 127.26,83.93 v1(126.98,84.21)
  TOP w0.102: 127.15,81.55 126.83,81.23 126.83,80.22 126.94,80.1 126.94,77.26 127.4,76.8 127.4,76.29 128,75.69 128,74.84 TP422.1
  BOTTOM w0.254: U400.BP29 126.78,84.21 v1(126.98,84.21)
VCCSA_CS: length 86.3
  TOP w0.178: PR8819.2 47.01,105.2 45.09,103.28 45.09,102.55 44.78,102.23 PU8800.44
  TOP w0.254: PR8819.2 47.35,105.2 49.44,107.3 v2(49.89,107.3) ; PR9017.1 109.32,117.6 108.28,117.6 107.51,116.83 88.36,116.83 v2(87.56,116.03)
  IN1 w0.254: v2(49.89,107.3) 49.08,108.11 49.08,119.23 50.19,120.35 52.02,120.35 52.93,121.25 54.19,121.25 54.38,121.44 54.38,121.81 54.81,122.24 56.86,122.24 57.07,122.03 62.32,122.03 63.06,122.78 64.43,122.78 64.49,122.85 69.44,122.85 70.05,122.24 70.59,122.24 71.74,121.09 76.08,121.09 76.54,120.63 79.52,120.63 82.79,117.36 86.46,117.36 87.56,116.26 v2(87.56,116.03)
VCCSA_CS_SUM: length 42.9
  TOP w0.102: v2(44.16,111.82) 45.58,110.39 46.32,110.39 46.9,109.81 47.74,109.81 48.68,108.87 50.07,108.87 50.28,108.67 50.28,108.21 50.12,108.06 49.56,108.06 47.49,105.98 PR8819.1 ; v2(31.2,99.24) 31.2,99.37 31.96,100.13 32.27,100.13 32.98,99.42 33.88,99.42 PR8854.2 34.87,100.41 35.78,100.41 PR8857.1
  TOP w0.203: PU8800.19 38.06,99.83 37.67,99.45 37.35,99.45 36.91,99.88 PR8857.1
  IN1 w0.114: v2(31.2,99.24) 31.2,103.56 32.19,104.55 32.19,106.61 34.88,109.3 39.76,109.3 40.13,109.68 41.79,109.68 43.94,111.82 v2(44.16,111.82)
VCCSA_PWM: length 89.4
  TOP w0.178: PU8800.35 45.07,98.63
  TOP w0.203: v2(50.92,99.37) 50.92,97.09 50.35,96.53 49.51,96.53 48.9,97.14 46.19,97.14 45.45,97.87 45.45,98.25 45.07,98.63
  TOP w0.254: PR9016.1 106.95,117.76 87.71,117.76 86.37,116.41 86.37,116.21 86.01,115.85 v2(85.86,115.85)
  IN1 w0.254: v2(50.92,99.37) 50.92,97.71 54.44,94.19 62.9,94.19 64.68,95.97 71.62,95.97 79.56,103.91 79.56,110.19 77.53,112.22 77.53,115.3 78.44,116.21 84.79,116.21 85.15,115.85 v2(85.86,115.85)
VCCSA_VCCSENSE: length 111.1
  TOP w0.102: v2(34.96,102.37) 34.79,102.37 PR8842.1 PR8843.2
  IN1 w0.127: v2(34.96,102.37) 34.55,101.96 34.55,100.53 34.75,100.33 35.31,100.33 35.4,100.23 35.4,99.71 39.37,95.74 46.71,95.74 47.96,94.49 50.4,94.49 51.34,93.55 51.34,89.92 53.13,88.13 64.59,88.13 67.25,90.8 73.78,90.8 81.54,98.56 83.44,98.56 85.57,100.69 92.28,100.69 92.76,101.17 100.45,101.17 100.91,100.72 100.91,99.21 102.26,97.87 102.26,97.25 102.76,96.75 103.8,96.75 104.09,96.46 104.09,95.85 105.2,94.75 114.56,94.75 114.88,95.06 120.32,95.06 120.8,95.55 120.8,96.12 121.07,96.39 121.07,96.96 121.52,97.41 v1(121.52,97.99)
  BOTTOM w0.079: v1(121.52,97.99) 121.74,98.21 U400.BG7
VCCSA_VDIFF: length 4.8
  TOP w0.102: PC8817.2 PR8848.1 35.16,104.58 v2(35.21,104.63)
  TOP w0.178: PU8800.13 38.37,102.23 36.78,103.82 PC8817.2
VCCSA_VFB: length 8.5
  TOP w0.102: v2(33.18,103.65) 33.36,103.82 PR8866.1 ; PR8849.1 34.48,105 PR8867.2 34.39,104.42 34.02,104.05 PR8866.1 ; PR8866.1 34.38,103.82 PR8848.2 PC8817.1
  TOP w0.203: PC8817.1 36.9,103.04 38.11,101.83 PU8800.14
VCCSA_VORTN: length 3.5
  TOP w0.102: PR8844.1 36.81,100.39 v2(37.12,100.39)
  TOP w0.203: PR8844.1 36.69,101.28 37.8,101.28 38.05,101.03 PU8800.16
VCCSA_VOSEN: length 2.4
  TOP w0.203: PU8800.15 38.08,101.43 37.6,101.91 v2(37.22,101.91) PR8843.1
VCCSA_VSSSENSE: length 109.7
  TOP w0.102: PR8844.2 PR8845.1 34.74,101.3 v2(34.98,101.3)
  IN1 w0.127: v1(120.65,98.54) 121.09,98.11 121.09,97.55 120.69,97.16 120.69,96.55 120.42,96.28 120.42,95.71 120.16,95.45 114.72,95.45 114.4,95.13 105.36,95.13 104.47,96.01 104.47,96.63 103.96,97.13 102.93,97.13 102.64,97.43 102.64,98.02 101.34,99.33 101.34,100.83 100.61,101.55 92.61,101.55 92.12,101.07 85.41,101.07 83.28,98.94 81.39,98.94 73.62,91.18 67.1,91.18 64.43,88.51 53.29,88.51 51.72,90.08 51.72,93.71 50.56,94.87 48.12,94.87 46.87,96.12 39.53,96.12 35.78,99.87 35.78,100.57 35.05,101.3 v2(34.98,101.3)
  BOTTOM w0.079: U400.BE7 120.99,98.21 v1(120.65,98.54)
  BOTTOM w0.102: v2(34.98,101.3) v2(34.53,100.84)
VCCSENSE: length 117.6
  TOP w0.102: v2(41.28,106.61) 41.05,106.38 PR8828.2
  IN1 w0.127: v2(41.28,106.61) 40.95,106.28 40.95,104.27 39.05,102.37 39.05,98.76 40.1,97.71 48.51,97.71 49.45,96.78 50.81,96.78 53.25,94.34 53.25,90.71 53.69,90.26 64.03,90.26 66.46,92.7 72.99,92.7 82.89,102.6 90.91,102.6 92.85,104.54 92.85,110.52 94.01,111.68 105.36,111.68 105.87,112.18 112.29,112.18 113.14,111.33 v2(113.29,111.33)
  BOTTOM w0.079: U400.AN6 113.68,99.11 113.32,99.47 113.32,99.89 113.07,100.14 113.07,100.39 113.09,100.41 113.09,100.71
  BOTTOM w0.102: 113.09,100.71 113.07,100.73 113.07,104.52 112.64,104.95 112.64,107.83 113.01,108.2 113.01,108.68 R609.1 113.9,109.57 113.9,110.27 113.72,110.44 113.57,110.44 112.69,111.32 PR8826.1 112.81,111.82 v2(113.29,111.33)
VSSSENSE: length 117.6
  TOP w0.102: v2(40.19,106.63) 40.06,106.51 PR8829.2
  IN1 w0.127: v2(113.75,110.86) 113.03,110.86 112.09,111.8 106.03,111.8 105.52,111.3 94.17,111.3 93.23,110.36 93.23,104.38 91.07,102.21 83.04,102.21 73.15,92.32 66.62,92.32 64.18,89.88 53.53,89.88 52.87,90.55 52.87,94.18 50.65,96.4 49.29,96.4 48.36,97.33 39.94,97.33 38.67,98.6 38.67,102.53 40.57,104.43 40.57,106.25 v2(40.19,106.63)
  BOTTOM w0.102: v2(113.75,110.86) 113.75,111.27 PR8833.1 114.26,111.33 114.26,109.02 113.94,108.7 113.58,108.7 113.5,108.62 R610.1 113.01,107.68 113.01,105.12 113.37,104.75 113.37,103.44 113.68,103.13 113.68,100.13 113.93,99.88 113.93,99.75 U400.AN5
681_3V3_1.8V: length 2.5
  BOTTOM w0.254: PR9300.2 162.83,24.64 PC9301.1 162.44,25.04 PU9300.10
681_AGND_1.8V: length 2.7
  BOTTOM w0.254: PR9302.2 163.04,23.65 PC9301.2 162.78,23.87 162.14,24.52 162.14,24.54 PU9300.11
681_C0_1.8V: length 4.2
  BOTTOM w0.203: PU9300.4 158.14,24.04 158.04,23.94 158.04,23.82 157.67,23.45 v2(157.67,22.64) 157.67,21.13 PR9310.1
681_C1_1.8V: length 5.6
  BOTTOM w0.102: PR9309.1 v2(157.65,18.74)
  BOTTOM w0.203: PU9300.3 158.19,23.54 157.97,23.32 157.97,23.05 158.22,22.81 158.22,22.39 157.97,22.14 157.97,20.01 PR9309.1
681_EN_1.8V: length 4.5
  BOTTOM w0.203: PU9300.5 158.06,24.54 v2(157.54,24.02) 157.35,23.83 PR9304.1 156.71,23.44 156.81,23.34 PC9310.1 156.81,22.38 157.19,22 PR9305.2
681_LP#_1.8V: length 1.9
  BOTTOM w0.203: PR9306.1 157.17,24.8 157.41,25.04 PU9300.6
681_MODE_1.8V: length 3.8
  BOTTOM w0.254: PR9311.2 156.13,25.74 v2(157.12,25.74) 159.34,25.74 159.53,25.55 PU9300.7
681_SW_1.8V:
  vias: v2(160,25.99)
681_VOUT_1.8V: length 5.3
  BOTTOM w0.102: v2(164.57,20.71) PR9312.1
  BOTTOM w0.254: PR9312.1 163.91,22.17 163.34,22.17 162.97,22.54 PR9313.2 162.97,22.87 162.26,23.58 162.26,23.78 162.01,24.04 PU9300.12
681_VOUT_1.8V_S: length 10.5
  BOTTOM w0.254: PR9308.1 163.45,30.54 164.44,29.56 164.44,27.91 165.01,27.34 165.01,26.11 165.67,25.44 165.67,23.93 165.5,23.76 v2(165.5,23.49) 165.5,23.13 165.63,23 165.63,21.8 PR9312.2
2260_BST_1.0V: length 1.1
  BOTTOM w0.102: PR9202.2 131.97,121.42 v2(131.75,121.2)
2260_EN_1.0V: length 6
  BOTTOM w0.102: PC9214.2 126.26,124.79 v2(125.99,125.05) ; PC9214.2 PR9208.1 127.92,124.5 128.46,123.96 128.98,123.96 129.67,124.66 PU9200.2 ; PC9214.2 126.91,124.11 126.85,124.05 PR9207.1
2260_FB_1.0V: length 5
  BOTTOM w0.102: v2(125.33,127.25) 126.17,127.25 PR9209.1
  BOTTOM w0.254: PR9209.1 126.2,127.25 127.13,127.25 PR9210.1 127.66,126.72 128.97,126.72 129.53,126.16 PU9200.5
2260_FB_1.0V_S: length 27.7
  TOP w0.127: v2(126.18,128.83) 127.3,129.95 142.2,129.95 143.34,128.8 143.34,123.37 142.07,122.1 v2(141.05,122.1)
  BOTTOM w0.127: PR9209.2 126.18,128.02 v2(126.18,128.83) ; v2(141.05,122.1) 141.16,122 PR9206.1
2260_LX_1.0V: length 1.3
  TOP w0.508: v2(137.83,125.89) 138.35,126.41 PR9204.2
2260_PFM_1.0V: length 1.8
  BOTTOM w0.102: PR9205.1 128.73,124.99 v2(128.73,124.42)
  BOTTOM w0.254: PR9205.1 129.22,125.08 129.29,125.16 PU9200.3
2260_PG_1.0V: length 2.5
  BOTTOM w0.102: v2(129.6,122.83) 129.04,123.39 PR9203.1 129.49,124.16 PU9200.1
2260_SS_1.0V: length 3.7
  BOTTOM w0.254: PU9200.23 130.43,122.51 129.47,121.55 v2(129.39,121.55) 129.38,121.54 128.25,121.54 PC9216.1
2260_TON_1.0V: length 2.1
  BOTTOM w0.254: PU9200.6 129.64,126.66 v2(128.97,127.32) 128.2,127.32 PR9200.2
2260_VCC_1.0V: length 6.5
  BOTTOM w0.102: v2(133.33,118.98) 133.33,119.34 132.47,120.21 PR9201.2
  BOTTOM w0.254: PR9201.2 131.69,120.23 131.18,120.74 131.18,121.34 PC9206.2 130.95,122.15 130.95,122.59 131.43,123.07 PU9200.21
8051_RX_CAPS_LED#: length 74.4
  TOP w0.076: U4701.J7 v3(206.53,53.28)
  TOP w0.102: v2(185.07,59.82) 185.07,59.8 185.46,60.2 R4733.1 185.63,60.8 v2(185.53,60.9) U4700.3 183.19,60.9 183.02,61.08 183.02,61.62 R4737.1
  IN1 w0.076: v3(206.53,53.28) 206.2,53.62 206.2,54.75 206.03,54.92 205.68,54.92 205.37,55.22 205.37,55.32 204.76,55.94 204.5,55.94 204.45,55.99
  IN1 w0.114: v2(185.07,59.82) 185.56,59.82 185.76,59.62 185.76,58.84 186.08,58.52 186.57,58.52 187.85,59.8 191.37,59.8 192.8,58.37 194.36,58.37 195.1,59.11 197.88,59.11 199.17,57.82 200.65,57.82 201.59,58.76 202.05,58.76 202.92,57.89 202.92,57.17 203.56,56.52 203.92,56.52 204.45,55.99
  BOTTOM w0.102: v2(185.07,59.82) 184.31,59.82 183.37,58.88 179.14,58.88 177.74,60.28 176.46,60.28 173.59,63.15 173.59,64.38 173.68,64.47 173.68,65.17 173.24,65.61 172.76,65.61 172.14,66.23 172.14,73.31 171.46,74 171.46,75.27 170.98,75.75 169.05,75.75 168.95,75.85 168.95,76.85 166.9,78.9 162.66,78.9 161.03,77.28 CN7701.21
8051_TX_LED_PWRSTBY#: length 72
  TOP w0.076: U4701.H8 205.23,53.94 v3(204.58,53.94)
  TOP w0.102: R4732.1 185.25,58.4 184.62,59.03 v2(184.62,59.03) 184.62,59.03 184.16,59.03 183.73,58.6 R4738.1 183.17,58.74 183.17,59.52 183.25,59.6 U4700.1
  BOTTOM w0.076: v3(204.58,53.94) 204.58,53.78 204.25,53.44 204.25,53.15 204.06,52.97 203.8,52.97 203.61,53.15 203.61,53.42 203.61,54.12 203.46,54.27 203.12,54.27 202.96,54.42 202.96,54.95 202.96,54.95 202.96,56.85
  BOTTOM w0.102: 202.96,56.85 202.96,58.03 201.69,59.3 194.32,59.3 193.43,60.19 191.87,60.19 190.99,59.31 188.36,59.31 187.07,58.03 185.63,58.03 184.62,59.03 v2(184.62,59.03) 184.62,59.03 184.27,58.68 179.05,58.68 177.65,60.07 176.24,60.07 172.77,63.54 172.77,65.31 171.83,66.25 171.83,73.26 171.25,73.84 171.25,75.18 170.89,75.54 168.97,75.54 168.75,75.77 168.75,76.77 166.82,78.69 162.91,78.69 161.53,77.31 CN7701.22
8097_EN_2.5V: length 1
  TOP w0.102: v2(167.01,55.2) 166.85,55.36 PR8719.1
8097_LX_2.5V: length 3.6
  TOP w0.102: PL8702.1 168.93,59.01 169.48,59.56 169.48,61.04 v2(169.66,61.23)
8097_PG_2.5V: length 5.6
  TOP w0.102: v2(158.65,59.04) 159.02,59.42 160.23,59.42 160.6,59.05 PR8716.2
  TOP w0.508: PU8701.5 161.78,57.18 161.56,57.4 161.56,58.21 161.1,58.68 160.85,58.68 PR8716.2
8097_VFB_2.5V: length 1
  TOP w0.102: PC8728.2 159.2,56.63 v2(159.06,56.49)
8097_VFB_2.5V_S: length 8.3
  TOP w0.508: PR8723.1 PC8728.1 159.53,55.81 158.77,55.81 158.13,56.45 v2(158.13,57.36)
  IN1 w0.508: v2(159.75,60.94) 159.7,60.89 159.7,59.62 158.13,58.05 v2(158.13,57.36)
8097_VIN_2.5V: length 4.5
  TOP w0.102: v2(160.85,61.12) 160.69,60.96 160.69,60.14 PR8715.2
  TOP w0.508: PR8715.2 161.47,60.13 PC8723.1 162.16,59.43 162.16,58.32 162.37,58.12 PU8701.4
8231_BT: length 3.3
  BOTTOM w0.203: PR8705.2 144.88,21.14 145.52,20.5 145.52,19.78 v2(145.24,19.49) 145.14,19.4 PU8700.18
8231_BT_S: length 2.7
  BOTTOM w0.102: PC8711.1 143.28,19.03 v2(143.58,18.73)
  BOTTOM w0.508: PR8705.1 143.68,20.85 143.28,20.45 PC8711.1
8231_CS: length 2.4
  BOTTOM w0.203: PR8702.2 141.85,16.88 v2(142.28,16.88) 142.61,16.88 142.82,16.67 PU8700.13
8231_LG: length 5
  BOTTOM w0.203: PU8700.15 143.1,17.47 142.99,17.58 142.99,18.16 142.81,18.34
  BOTTOM w0.762: 142.78,21.47 142.78,20.99 142.23,20.44 v2(142.23,19.69) 142.23,18.91 142.81,18.34 142.81,18.34
8231_PG: length 2.5
  BOTTOM w0.102: v2(143.49,14.64) PR8700.2
  BOTTOM w0.203: PR8700.2 144.34,14.63 PU8700.10
8231_PH: length 8.8
  IN2 w0.508: v4(146.19,26.04) 144.22,24.07 v4(144.22,20.29)
  BOTTOM w0.203: PC8711.2 144.34,19.28 PU8700.16
  BOTTOM w0.381: v4(144.22,20.29) 144.22,19.91 144.06,19.75 PC8711.2
  vias: v2(147.54,23.83)
8231_S3: length 3.4
  BOTTOM w0.203: PR8703.2 146.89,12.76 PC8701.2 146.41,13.24 v2(146.41,13.94) 146.05,14.3 145.78,14.3 145.54,14.53 PU8700.7
8231_S5: length 3.7
  BOTTOM w0.203: PR8701.2 145.88,11.9 145.88,12.65 145.55,12.98 145.47,12.98 v2(145.31,13.14) 145.31,13.86 PC8700.1 145.14,14.03 PU8700.8
8231_TON: length 3.4
  BOTTOM w0.102: v2(144.31,12.11) 144.04,12.38 144.04,13.34 PR8704.1
  BOTTOM w0.203: PU8700.9 144.74,14.53 144.48,14.27 PR8704.1
8231_UG: length 9
  IN2 w0.508: v4(144.95,20.3) 144.95,23.64 146.87,25.56 v4(147.71,25.56)
  BOTTOM w0.203: v4(144.95,20.3) 144.95,19.88 144.74,19.67 PU8700.17
8231_VDDQ: length 32.3
  IN1 w0.127: v2(140.22,17.48) 140.8,16.9 143.02,16.9 144.5,15.41 149.38,15.41 v2(150.53,16.57)
  BOTTOM w0.127: v2(150.53,16.57) 151.33,15.76 151.33,14.44 150.47,13.58 148.17,13.58 PR8713.2 148,14.13 147.4,14.72 147.4,15.63 147.16,15.87 PU8700.5 ; v2(140.22,17.48) 140.22,17.66 141.1,18.54 141.1,21.69 141.42,22.02 141.42,25.12 141.58,25.29 PR8710.1
8231_VID: length 1.3
  BOTTOM w0.203: PR8711.1 142.8,15.67 143,15.87 PU8700.11
8231_VLDOIN: length 0.8
  BOTTOM w0.102: 146.16,19.78 v2(146.16,20.62)
8231_VTTREF: length 4.5
  BOTTOM w0.102: v2(149.74,14.15) 148.69,14.15 PR8706.2
  BOTTOM w0.203: PU8700.4 147.53,16.27 148.06,15.73 PC8713.1 PR8706.2
8693_VCCGT_BST1: length 2.4
  BOTTOM w0.102: v2(52.13,98.07) 52.6,98.07 53.04,98.52 53.04,99.14 53.28,99.38 PC9008.1
8693_VCCGT_CS1: length 2.6
  BOTTOM w0.102: v2(50.57,103.34) 50.86,103.05 51.45,103.05 51.62,102.89 PR9002.2
  BOTTOM w0.254: PR9002.2 51.75,102.51 PU9000.5
8693_VCCGT_HG1:
  vias: v2(55.5,100.71)
8693_VCCGT_HG1_R: length 5.7
  IN2 w1.016: v4(56.04,99.14) 61.3,99.14 v4(61.58,98.86)
  vias: v2(61.08,99.34)
8693_VCCGT_ISENN1: length 2.9
  BOTTOM w0.102: v2(50.57,104.65) 50.57,104.47 PR9014.1
  BOTTOM w0.254: PU9000.6 52.03,103.01 PR9014.1
8693_VCCGT_ISENP1: length 3.3
  BOTTOM w0.102: v2(53.57,106.74) 53.76,106.55 53.76,105.51 PR9011.1
  BOTTOM w0.254: PR9011.1 53.32,104.55 53.43,104.45 PU9000.7
8693_VCCGT_LG1: length 7.9
  IN2 w1.016: v4(55.86,102.93) 59.39,102.93 62.27,105.8 v4(62.54,105.8)
8693_VCCGT_PWM1: length 2.1
  BOTTOM w0.102: PR9000.2 51.62,100.66 v2(51.29,100.33)
  BOTTOM w0.254: PR9000.2 52.01,101.51 PU9000.3
8693_VCCGT_SW1: length 6.7
  IN2 w0.762: v4(54.19,98.1) 54.67,98.58 54.67,100.74 v4(55.76,101.83)
  BOTTOM w0.508: PR9004.1 62.59,107.24 63.57,106.26 63.57,105.54
  vias: v2(53.49,97.8)
8693_VCCGT_SYNC1: length 3.7
  BOTTOM w0.102: PU9000.4 52.04,102.01 51.91,101.88 PR9007.2 51.62,102.09 51.41,102.3 50.33,102.3 50.01,102.61 v2(49.5,102.61)
8693_VCCGT_VTEMP1: length 2.2
  BOTTOM w0.102: PR9003.2 52.58,99.32 v2(52.58,99.96) 52.83,100.2 53.31,100.2 53.43,100.32 PU9000.2
8693_VCCSA_BST1: length 1.1
  TOP w0.102: PC9026.1 107.57,121.23 106.92,121.88 v2(106.89,121.88)
8693_VCCSA_CS1: length 2.3
  TOP w0.254: PR9017.2 110.2,118.26 v2(110.33,118.39) 110.7,118.76 PU9001.5
8693_VCCSA_HG1:
  vias: v2(108.72,122.37)
8693_VCCSA_HG1_R:
  vias: v2(110.2,125.09) v4(111.67,124.57)
8693_VCCSA_ISENN1: length 3.5
  TOP w0.102: PR9029.1 110.56,117.35 v2(110.56,116.5)
  TOP w0.254: PR9029.1 111.2,118.12 PU9001.6
8693_VCCSA_ISENP1: length 3.1
  TOP w0.102: PU9001.7 111.95,119.22 v2(112.13,119.03)
  TOP w0.254: PU9001.7 113.38,120.43 PR9026.1
8693_VCCSA_PWM1: length 3.2
  TOP w0.254: 107.92,119.17 107.23,118.47 PR9016.2 ; 107.92,119.17 108.03,119.27 109.57,119.27 109.7,119.39 PU9001.3 ; 107.92,119.17 v2(107.92,119.15)
8693_VCCSA_SW1: length 2.4
  TOP w0.508: PC9026.2 107.7,122.54 107.98,122.81 v2(107.98,124.26)
  vias: v4(112.81,123.25)
8693_VCCSA_SYNC1: length 3.2
  TOP w0.254: PU9001.4 110.2,119.22 109.88,118.91 109.51,118.91 v2(108.77,118.17) 108.66,118.17 108.35,118.47 PR9022.2
8693_VCCSA_VTEMP1: length 1.8
  TOP w0.254: PU9001.2 v2(107.92,120.43) 107.44,120.43 107.3,120.29 PR9018.2
8693_VCORE_BST1: length 2.2
  BOTTOM w0.102: v2(52.25,106.6) 52.67,106.6 PC8909.1
8693_VCORE_BST2: length 1.5
  BOTTOM w0.102: PC8922.1 55.03,114.8 v2(55.31,114.8)
8693_VCORE_CS1: length 3.2
  BOTTOM w0.102: PR8903.2 51.21,111.93 50.99,112.15 v2(50.07,112.15)
  BOTTOM w0.254: PR8903.2 51.37,111.66 52.16,110.87 PU8900.5
8693_VCORE_CS2: length 3.3
  BOTTOM w0.102: v2(49.9,118.2) 50.22,118.52 51.39,118.52 51.52,118.65 PR8920.2
  BOTTOM w0.254: PR8920.2 51.8,118.93 51.98,118.75 PU8901.5
8693_VCORE_HG1: length 1.9
  BOTTOM w0.102: PR8900.1 56.57,109.94 v2(56.57,111.21)
8693_VCORE_HG1_R: length 9.2
  IN2 w1.016: v4(56.95,108.4) 57.69,109.14 60.6,109.14 62.27,107.46 64.03,107.46 v2(64.8,106.69)
8693_VCORE_HG2: length 1
  BOTTOM w0.102: PR8915.1 v2(56.24,118.26)
8693_VCORE_HG2_R: length 6.4
  IN2 w1.016: v4(57.39,116.08) 57.44,116.03 v4(62.62,116.03)
  BOTTOM w0.102: PR8915.2 56.24,115.39 v2(56.57,115.07)
8693_VCORE_ISENN1: length 2.9
  BOTTOM w0.102: v2(52.51,112.96) 52.51,112.96 PR8914.1
  BOTTOM w0.254: PU8900.6 52.42,111.37 51.68,112.11 PR8914.1
8693_VCORE_ISENN2: length 2
  BOTTOM w0.254: PR8929.1 51.53,120.04 v2(52.1,120.04) 52.27,120.04 52.65,119.67 PU8901.6
8693_VCORE_ISENP1: length 2.5
  BOTTOM w0.102: PR8911.1 53.37,113.46 v2(52.52,114.31)
  BOTTOM w0.254: PU8900.7 53.38,112.75 53.37,112.76 PR8911.1
8693_VCORE_ISENP2: length 2.4
  BOTTOM w0.102: v2(52.28,121.32) 52.37,121.41 PR8926.1
  BOTTOM w0.254: PU8901.7 53.4,120.73 53.15,120.99 PR8926.1
8693_VCORE_LG1: length 26.6
  IN2 w1.016: v4(69.1,106.84) 70.37,106.84 72.26,108.73 72.26,112.81 71.49,113.58 57.47,113.58 v4(55.63,111.74)
  BOTTOM w0.102: v4(55.63,111.74) v2(55.63,112.61)
8693_VCORE_LG2: length 14.7
  IN2 w1.016: v4(57.62,117.51) 57.62,117.84 58.67,118.9 63.56,118.9 65.72,116.74 69.41,116.74 v4(70.32,115.83)
  vias: v2(56.12,119.73)
8693_VCORE_PWM1: length 2.4
  BOTTOM w0.102: v2(51.05,109.29) 51.21,109.46 PR8901.2
  BOTTOM w0.254: PU8900.3 51.7,109.87 51.43,110.14 PR8901.2
8693_VCORE_PWM2: length 2.1
  BOTTOM w0.102: PR8916.2 51.52,116.79 v2(51.34,116.61)
  BOTTOM w0.254: PR8916.2 51.86,117.75 PU8901.3
8693_VCORE_SW1: length 18.2
  IN2 w1.016: v4(70.72,112.07) 70.54,112.25 58.16,112.25 56.41,110.5 v4(55.69,110.5) 54.8,109.61 v2(54.8,108.54)
8693_VCORE_SW2: length 22.6
  IN2 w0.762: v2(55,116.31) 55,117.61 v4(55.53,118.14) 57.42,120.02 64.32,120.02 65.54,121.25 67.99,121.25 71.51,117.73 v4(71.51,115.91)
8693_VCORE_SYNC1: length 2.1
  BOTTOM w0.102: PR8907.2 50.78,110.9 v2(51.42,110.9) 51.95,110.37 PU8900.4
8693_VCORE_SYNC2: length 1.2
  BOTTOM w0.102: PR8922.2 51.92,118.17 52,118.25 PU8901.4
8693_VCORE_VTEMP1: length 2.4
  BOTTOM w0.102: v2(51.86,108.25) 52.13,107.98 PR8906.2 53.38,108.67 PU8900.2
8693_VCORE_VTEMP2: length 2.1
  BOTTOM w0.102: v2(52.54,116.16) 52.86,115.85 PR8921.2 53.32,116.29 53.4,116.37 PU8901.2
8693_VCSA_LG1: length 8.3
  IN1 w1.016: v4(111.64,122.59) 111.13,122.59 109.91,123.81 109.91,126.45 108.03,128.33 v2(107.27,128.33)
+BAT_DIS: length 26.7
  IN1 w0.127: v4(107.37,29.37) 110.9,29.37 112.73,27.54 115.44,27.54 117.32,25.66 121.43,25.66 123.87,23.22 126.06,23.22 126.62,22.66 127.22,22.66 v2(129.24,20.64)
  BOTTOM w0.127: PR8223.2 129.24,20.51 v2(129.24,20.64)
  vias: v4(105.09,30.23) v4(105.09,29.42) v4(105.88,30.21) v4(105.85,29.39) v4(106.64,29.39) v4(106.66,30.18) v4(107.4,30.21)
+BATCHG: length 24.8
  TOP w0.508: v2(97.21,28.63) 97.6,29.01 101.2,29.01 103.94,26.27 106.66,26.27 107.8,25.14 108.87,25.14 109.03,25.3 109.03,25.94 109.7,26.61 115.88,26.61 117.54,24.95 PD8204.2
+G_SEN_PW: length 6.9
  TOP w0.254: U5300.2 69.23,21.78 R5302.2
  TOP w0.508: R5302.2 69.73,21.77 v2(69.83,21.87)
  IN1 w0.508: v2(69.3,26.62) 69.29,26.62 69.2,26.53 69.2,22.51 v2(69.83,21.87)
+G_SEN_PW_S: length 7.8
  TOP w0.381: v2(73.41,129.22) 73.69,128.94 74.85,128.94 R5303.1 75.13,128.27 74.56,127.69 74.56,127.01 R5304.1
  BOTTOM w0.508: v2(73.41,129.22) 73.41,131.37 v2(72.47,132.31)
+SMDDR_VREF_DIMM:
  vias: v2(120.84,37.28)
+SMDDR_VREF_DQ0: length 35.4
  TOP w0.254: R2801.1 118.66,36.08 118.09,35.51 115.6,35.51 115.04,36.07 111.97,36.07 v2(111.29,36.76) 95.08,36.76 93.94,35.62 91.8,35.62 91.38,36.04 91.38,36.55 91.85,37.03 91.85,38.54 v2(92.31,38.99)
  BOTTOM w0.254: v2(92.31,38.99) 91.85,38.54 JDIM2800.164
+SMDDR_VREF_DQ1: length 51.6
  TOP w0.254: v2(126.81,39.93) 126.81,39.02 v2(126.46,38.68) 125.77,37.99 R2822.1
  IN1 w0.254: v2(126.81,39.93) 126.81,38.51 127.06,38.26 147.96,38.26 148.32,38.61 148.32,39.87 149.06,40.61 153.46,40.61 153.9,40.17 164.68,40.17 165.34,40.82 167.84,40.82 168.33,40.33 v2(168.33,38.97)
  BOTTOM w0.254: JDIM2801.164 168.82,38.51 168.36,38.97 v2(168.33,38.97)
+SPI_VCC: length 43.3
  TOP w0.254: v2(175.37,73.61) 175.37,73.05 C5103.2 175.2,72.58 174.85,72.23 U5100.22 ; U5100.1 167.04,73.23 166.84,73.43 166.84,73.82 ; R5101.1 174.53,71.25 v2(175.14,71.25) 175.42,70.96 R5602.2
  TOP w0.381: R5105.2 164.96,72.98 165.88,73.9 C5101.2 166.61,74.05 166.84,73.82
  TOP w0.508: v2(170.04,74.69) 170.04,75.1 R5604.2 v2(168.51,75.49) 167.63,74.61 166.23,74.61 165.88,74.26 C5101.2 ; v2(166.12,73.28) 166.12,72.81 R5104.2 165.56,72.63 165.33,72.86 R5105.2
  IN2 w0.381: v2(170.04,74.69) 170.5,74.22 171.81,74.22 173.21,72.83 175.24,72.83 175.37,72.7
  IN2 w0.508: v2(175.14,71.25) 175.37,71.48 v2(175.37,73.61) 174.33,74.66 174.33,75.17 174.41,75.24 174.41,75.73 ; 175.6,76.93 176.78,76.93 177.37,77.52 v2(177.37,78.07)
  BOTTOM w0.508: U5600.8 177.1,79.29 177.37,79.02 v2(177.37,78.07) ; v2(175.14,71.25) 173.55,69.67 172.6,68.71 v2(172.6,66.38) ; v2(166.12,73.28) 166.12,69.42 165.91,69.2 165.91,68.54 v2(165.91,68.54)
+UIM_PWR: length 30.1
  IN1 w0.114: v2(204.38,66.91) 204.38,68.12 202.49,70 202.49,71.07 200.52,73.05 200.52,73.72 199.58,74.65 199.2,74.65 198.58,75.27 198.58,76.76 197.47,77.88 197.47,79.56 197.72,79.81 v2(197.72,81.16)
  BOTTOM w0.102: CN4200.36 197.2,80.64 v2(197.72,81.16) ; v2(204.38,66.91) 204.89,66.91 205.1,66.7 R4222.2 205.13,66.06 R4225.2 206.85,66.06 C4211.2 207.69,65.64 C4209.1 208.25,64.96 208.96,64.24 C4210.1 209.79,63.67 210.66,63.67 211.37,62.96 211.96,62.96 212.44,62.48 CN4201.1
+VAC: length 1.3
  BOTTOM w0.102: 215.34,105.64 214.11,105.64 v2(214.03,105.56)
+VAC_IN: length 19.7
  TOP w0.127: PR8014.1 200.36,95.41 201.11,96.16 201.11,96.97 PQ8002.1 202.35,98.21 PC8001.1 PR8001.1 204.35,98.3 204.87,98.82 205.04,98.82 205.33,99.1 PC8002.1 PR8000.1 205.33,101.14 v2(205.22,101.25)
  BOTTOM w0.127: v2(205.22,101.25) 207.12,103.15 207.98,103.15 208.26,103.43 v2(214.13,103.43)
  vias: v2(214.1,104.07) v2(216.39,103.79) v2(219.01,103.79) v2(219.06,105.29) v2(219.57,104.37) v2(219.64,103.74) v2(219.67,105.03) v2(219.69,103.1)
+VHIF: length 15
  TOP w0.254: U4701.F1 204.25,48.53 204.38,48.41 204.38,47.39 204.47,47.3 204.47,45.74 203.78,45.04 202.2,45.04 201.24,44.08 201.24,43.04 v2(201,42.8) 199.49,41.3 R4719.2 197.56,41.48 C4703.1 C4700.1
+VSPI: length 14.2
  TOP w0.102: R4723.2 213.9,61.43 C4706.2 C4705.1 212.6,60.75 212.19,61.15 v2(211.86,61.15) 211.83,61.15 211.44,60.76 211.44,60.31 211.31,60.18 211.31,59.11 210.71,58.51 208.43,58.51 207.66,57.75 205.66,57.75 205.24,57.33 205.24,56.83 205.56,56.51 U4701.H12
A_3S_ICHSPKR: length 158.8
  TOP w0.102: R3616.1 207.78,7.31 207.04,8.05 207.04,9.95 205.75,11.24 205.27,11.24 204.54,11.97 204.54,12.37 204.25,12.66 v2(204.25,12.87)
  IN2 w0.114: v2(184.89,24.69) 183.69,25.9 183.69,35.88 184.39,36.58 187.77,36.58 188.32,36.03 188.32,35.48 188.59,35.2 189.6,35.2 189.7,35.11 193.1,35.11 193.3,35.31 193.3,36.84 193.1,37.04 193.1,37.79 194.62,39.3 194.62,40.2 195.05,40.63 195.05,41.95 193.3,43.7 193.3,44.47 191.6,46.16 191.6,48.58 187.66,52.53 186.38,52.53 181.25,57.66 181.25,61.75 179.5,63.5 179.5,66.59 179.02,67.07 178.83,67.07 178.33,67.56 178.33,68.33 177.83,68.83 174.71,68.83 173.93,69.61 168.36,69.61 167.59,70.38 167.14,70.38 166.09,71.43 165.32,71.43 164.5,70.61 164.5,69.58 164.2,69.28 160.04,69.28 159.98,69.35 159.05,69.35 158.38,70.01 155.96,70.01 155.33,70.64 150.62,70.64 150.11,71.15 145.39,71.15 v2(144.95,70.71)
  BOTTOM w0.079: 138.92,76.61 138.43,77.1 135.44,77.1 133.73,78.8 133.73,79.56 133.68,79.68 133.65,79.77 133.65,80.06 133.67,80.12 133.67,80.35 133.65,80.41 133.65,80.65 U400.CF35
  BOTTOM w0.102: v2(144.95,70.71) 145.47,71.22 145.47,71.9 144.13,73.24 143.44,73.24 141.8,74.88 141.11,74.88 140.81,75.18 140.44,75.18 139.85,75.77 139.76,75.77 138.92,76.61 ; v2(204.25,12.87) 204.21,12.84 202.37,12.84 201.26,11.72 198.05,11.72 197.47,12.3 194.29,12.3 192.31,14.28 187.81,14.28 184.77,17.32 184.77,19.74 185.22,20.2 185.22,20.7 184.88,21.04 184.88,22.22 184.54,22.56 184.54,23.24 184.79,23.48 185.09,23.48 185.21,23.6 185.21,24.37 v2(184.89,24.69)
A_SD#: length 79.9
  TOP w0.102: v2(212.48,18.22) 213.04,18.78 D3604.1 214.44,18.78 215.62,17.59 R3621.2 ; v2(209.64,54.27) 209.29,53.92 207.82,53.92 U4701.L8
  IN1 w0.114: v2(194.19,11.51) 194.53,11.51 196,12.98 197.31,12.98 198.51,14.18 198.51,16.18 203.7,21.37 203.7,32.81 207.73,36.84 207.73,41.57 209.53,43.36 209.53,45.29 210.47,46.23 210.47,52.46 209.64,53.29 v2(209.64,54.27) ; v2(212.48,18.22) 211.36,18.22 210.52,17.38 210.52,16.01 210.44,15.92 206.74,15.92 205.34,14.53 204.9,14.53 202.65,12.27 v2(202.65,11.89)
  BOTTOM w0.102: v2(202.65,11.89) 202.64,11.9 202,11.9 201.43,11.32 197.88,11.32 197.3,11.9 194.58,11.9 v2(194.19,11.51)
ACCEL_INT: length 379.5
  TOP w0.102: v2(61.38,24.34) 61.24,24.49 61.24,26.76 62.54,28.07 67.42,28.07 67.67,27.82 67.67,27.31 66.63,26.27 66.63,26.05 C5304.2 67.8,24.89 67.8,24.24 68.51,23.53 U5300.12 ; v2(92.23,130.13) 92.12,130.02 90.27,130.02 89.93,129.68 89.93,128.33 85.7,124.1 80.27,124.1 78.97,122.79 72.29,122.79 v2(71.88,123.21)
  IN1 w0.114: v2(61.38,24.34) 60.96,23.92 57.22,23.92 56.55,23.25 54.52,23.25 53.46,24.31 50.88,24.31 48.17,21.6 41.35,21.6 39.2,23.75 39.2,26.09 39.12,26.16 39.12,26.17 39.12,29.8 38.53,30.39 38.53,33.02 37.55,34 37.55,49.03 37.91,49.39 37.91,58.64 39.19,59.92 39.19,63.52 39.76,64.09 39.76,66.12 38.5,67.37 38.5,72.99 39.73,74.22 39.73,76.51 40.11,76.89 40.11,82.86 30.01,92.97 30.01,93.89 21.55,102.34 19,104.89 19,105.77 19.62,106.38 21.3,106.38 23.21,108.29 23.21,110.07 26.7,113.57 30.43,113.57 34.11,117.24 44.17,117.24 49.87,122.94 52.73,122.94 53.18,123.39 58.86,123.39 59.45,123.98 64,123.98 64.09,124.07 69.85,124.07 70.53,123.39 71.7,123.39 v2(71.88,123.21)
  IN2 w0.114: v2(155.76,124.28) 155.59,124.28 154.97,124.9 147.55,124.9 146.26,123.6 129.32,123.6 128.78,124.14 126.95,124.14 126.52,123.7 120.6,123.7 116.53,119.64 113.85,119.64 113.22,120.27 112.32,120.27 111.41,119.35 107.07,119.35 106.54,119.89 105.07,119.89 98.51,126.44 94.24,126.44 92.48,128.21 92.48,129.89 v2(92.23,130.13) ; v2(169.45,94.16) 169.24,93.95 161.34,93.95 161.24,93.84 159.87,93.84 159.29,94.42 158.48,94.42 158.1,94.8 154.16,94.8 153.16,93.8 151.49,93.8 151.37,93.69 150.77,93.69 149.35,95.11 149.08,95.11 148.47,95.73 147.08,95.73 146.26,96.54 145.37,96.54 144.8,97.11 142.97,97.11 v2(141.96,96.1)
  BOTTOM w0.079: R486.2 141.92,95.09 141.35,95.09 141.27,95 140.55,95 139.78,95.77 139.21,95.77 139.14,95.7 138.63,95.7 138.48,95.64 137.85,95.64 137.78,95.56 137.66,95.56 U400.CN12
  BOTTOM w0.102: v2(155.76,124.28) 156.22,123.82 156.22,122.41 155.77,121.95 155.77,118.6 156.14,118.23 156.14,117.05 155.91,116.82 155.91,116.06 159.39,112.58 162.86,112.58 170.59,104.85 170.59,98.1 169.4,96.92 169.4,94.2 v2(169.45,94.16) ; v2(92.23,130.13) 92.36,130.01 94.7,130.01 95.04,130.35 95.04,133.71 94.93,133.82 94.3,133.82 94.19,133.93 Q7601.3 92.7,133.93 92.35,134.28 92.35,135.05 92.17,135.23 Q7601.6 ; R486.2 142.21,95.88 142.02,96.08 141.99,96.08 141.97,96.1 v2(141.96,96.1)
ACCEL_PANEL_INT1#: length 40
  TOP w0.102: v2(75.93,124.64) 76.53,124.04 78.49,124.04 79.76,125.31 85.17,125.31 88.13,128.28 88.13,128.97 88.67,129.51 88.67,130.78 90,132.11 94.46,132.11 95.32,132.97 95.32,134.29 94.81,134.8 90.85,134.8 90.41,135.24 v2(90.18,135.24)
  BOTTOM w0.102: v2(90.18,135.24) 90.23,135.24 90.89,134.58 Q7601.5 ; CN7602.4 76.31,130.69 76.7,130.29 76.7,128.2 76.03,127.53 76.03,124.74 v2(75.93,124.64)
ACCEL_PANEL_INT2#: length 34.1
  TOP w0.102: v2(76.56,124.64) 76.93,124.28 78.44,124.28 79.68,125.52 85.08,125.52 87.93,128.36 87.93,129.05 88.47,129.59 88.47,130.87 89.91,132.31 94.38,132.31 95.11,133.05 95.11,133.9 v2(94.65,134.36)
  BOTTOM w0.102: Q7601.2 94.43,134.58 v2(94.65,134.36) ; CN7602.5 76.5,131.19 76.91,130.78 76.91,128.12 76.23,127.44 76.23,124.98 v2(76.56,124.64)
ACCEL_SLATE_INT1#: length 4.9
  TOP w0.102: Q5300.2 70.57,126.92 71.29,127.64 71.29,128.78 71.71,129.2 v2(72.25,129.2) 72.29,129.24 72.29,129.95 72.4,130.06 72.4,130.33 72.48,130.41 U5301.12
ACCEL_SLATE_INT2#: length 4.6
  TOP w0.102: U5301.11 72.29,130.91 72.2,130.82 72.2,130.15 72.08,130.04 72.08,129.71 71.97,129.6 71.12,129.6 Q5301.2 v2(69.5,128.93)
ACCEL_SLATE_INT#: length 3.4
  TOP w0.102: Q5301.3 71.8,127.84 72.24,127.4 v2(72.24,127.37) 72.24,126.86 Q5300.3 71.8,126.03 R4769.1
ACZ_BCLK: length 7.2
  BOTTOM w0.079: U400.BN37 125.78,79.49 125.78,78.53 129.12,75.19 v2(129.12,74.61) 129.12,74.15 R570.2
ACZ_RST#: length 7.7
  BOTTOM w0.079: U400.BL35 124.37,80.59 124.37,80.14 124.26,79.79 124.22,79.69 124.22,79.34 124.14,79.26 124.14,78.75 124.58,78.32 124.73,78.32 126.68,76.37 v2(126.68,75.8) 126.68,75.46 126.93,75.21 126.93,74.89 R572.2
ACZ_RST#_AUDIO: length 136.9
  TOP w0.102: R3622.2 215.6,24.08 v2(215.24,23.73)
  BOTTOM w0.079: R572.1 127.89,73.93 127.89,71.19 126.96,70.26
  BOTTOM w0.102: 126.96,70.26 126.96,64.75 133.02,58.69 135.7,58.69 136.78,57.61 155.72,57.61 156.33,58.22 159.24,58.22 159.62,58.6 160.87,58.6 163.85,55.62 165.09,55.62 166.79,53.92 166.79,52.77 172.45,47.11 185.83,47.11 186.68,46.26 192.75,46.26 192.84,46.17 192.84,43.5 196,40.35 196,37.17 196.54,36.62 197.3,36.62 197.56,36.36 198.56,36.36 198.82,36.62 201.52,36.62 204.77,39.87 209.2,39.87 210.81,41.48 214.39,41.48 215.09,40.78 215.09,36.33 216.62,34.81 216.62,29.58 216.36,29.32 216.36,28.74 216.15,28.53 216.15,27.26 215.24,26.35 v2(215.24,23.73)
ACZ_SDIN0: length 159.7
  TOP w0.102: v2(215.17,10.28) 215.17,10.28 215.13,10.28 214.05,9.2 EC3609.2 213.08,9.93 R3611.1
  BOTTOM w0.079: 125.75,77.89 125.44,78.19 125.44,79.73 125.51,79.88 125.51,80.11 125.59,80.18 125.59,80.59 U400.BN35
  BOTTOM w0.102: 125.75,77.89 128.56,75.08 128.56,74.68 128.26,74.38 128.26,71.4 128.79,70.87 128.79,70.34 128.75,70.3 128.75,67.65 130.06,66.33 130.06,64.91 134.1,60.88 136.48,60.88 137.52,59.83 158.56,59.83 159.11,60.38 161.18,60.38 163.33,58.22 164.58,58.22 168.34,54.46 168.34,53.45 173.12,48.67 183.3,48.67 183.47,48.85 187.5,48.85 189.35,47 193.02,47 193.56,46.46 193.56,43.79 196.95,40.4 196.95,38.92 196.71,38.68 196.71,38.08 197.2,37.58 198.48,37.58 198.72,37.34 201.2,37.34 201.4,37.55 204.44,40.58 208.81,40.58 210.43,42.2 215.12,42.2 215.83,41.49 215.83,37.06 218.05,34.84 218.05,32.74 217.96,32.64 217.96,32.09 217.5,31.63 217.5,29.42 217.1,29.02 217.1,28.43 216.89,28.22 216.89,26.95 216.04,26.1 216.04,23.44 215.17,22.57 215.17,20.97 215.2,20.93 215.2,18.17 215.91,17.46 215.91,14.66 215.59,14.35 215.14,14.35 214.97,14.18 214.97,11.28 215.18,11.07 215.18,10.28 v2(215.17,10.28)
ACZ_SDO: length 31.1
  TOP w0.102: v2(136.86,61.07) 136.3,61.07 136.03,61.35 Q408.3
  TOP w0.114: Q406.3 138.76,61.98 138.51,62.23 v2(138.19,62.23) 136.22,62.23 Q408.3
  BOTTOM w0.079: U400.BN36 125.87,80.22 125.68,80.04 125.68,79.84 125.61,79.69 125.61,78.39 128.74,75.27 128.74,74.55 128.45,74.27 128.45,73.97
  BOTTOM w0.102: 128.45,73.97 128.45,71.49 129.11,70.82 129.11,67.8 130.43,66.48 130.43,65.07 134.26,61.24 136.69,61.24 v2(136.86,61.07)
ACZ_SDOUT: length 2.6
  TOP w0.102: R583.2 140.67,58.96 140.75,59.03 Q406.1 v2(142,59.95)
ACZ_SDOUT_AUDIO: length 127.2
  TOP w0.102: R583.1 142.53,58.23 v2(145.25,60.94) ; v2(215.45,13.74) 215.06,13.74 214.42,13.09 EC3611.2 214.77,13.06 215.03,13.33 215.85,13.33 216.05,13.13 U3600.4
  BOTTOM w0.102: v2(215.45,13.74) 215.49,13.74 216.26,14.51 216.26,17.61 215.57,18.3 215.57,21.07 215.53,21.11 215.53,22.42 216.39,23.29 216.39,25.94 217.25,26.8 217.25,28.07 217.46,28.28 217.46,28.88 217.85,29.27 217.85,31.48 218.31,31.94 218.31,32.49 218.41,32.59 218.41,35 216.19,37.22 216.19,41.64 215.27,42.57 210.3,42.57 208.66,40.94 204.27,40.94 201.05,37.71 198.85,37.71 197.3,39.26 197.3,40.55 193.91,43.94 193.91,46.61 193.15,47.37 189.48,47.37 187.65,49.21 183.33,49.21 183.15,49.03 173.27,49.03 168.7,53.6 168.7,54.64 165.08,58.26 165.08,58.52 164.08,59.52 162.7,59.52 160.86,61.35 159.35,61.35 158.18,60.19 146,60.19 v2(145.25,60.94)
ACZ_SDOUT_G: length 2.2
  TOP w0.102: v2(139.66,58.73) R580.1 Q406.2
ACZ_SYNC: length 9.2
  BOTTOM w0.079: U400.BN34 125.28,80.93 125.11,80.93 124.93,80.75 124.93,80.02 124.8,79.89 124.6,79.89 124.44,79.79 124.42,79.74 124.39,79.66 124.39,79.27 124.31,79.19 124.31,78.82 124.59,78.54 124.75,78.54 127.11,76.18 127.11,75.32 127.43,74.99 R569.2
ACZ_SYNC_AUDIO: length 157.9
  TOP w0.102: EC3612.2 215.3,7.64 215.59,7.93 v2(215.59,8.23) 215.59,8.23 215.59,9.53 215.91,9.85 215.91,10.98 216.06,11.13 U3600.9
  BOTTOM w0.102: R569.1 128.07,74.53 128.07,71.09 127.33,70.35 127.33,64.9 133.17,59.06 135.86,59.06 136.94,57.97 155.57,57.97 156.2,58.6 159.11,58.6 159.5,58.98 160.99,58.98 164,55.98 165.24,55.98 167.22,53.99 167.22,52.86 172.6,47.48 185.97,47.48 186.82,46.62 192.9,46.62 193.2,46.32 193.2,43.65 195.19,41.66 196.59,40.25 196.59,39.07 196.35,38.83 196.35,37.34 196.72,36.97 197.45,36.97 197.71,36.72 198.32,36.72 198.58,36.97 201.35,36.97 204.6,40.22 209.05,40.22 210.66,41.83 214.56,41.83 215.46,40.93 215.46,36.7 216.98,35.18 216.98,29.43 216.73,29.17 216.73,28.59 216.52,28.38 216.52,27.11 215.68,26.27 215.68,23.58 214.82,22.72 214.82,20.82 214.84,20.8 214.84,18.03 215.5,17.37 215.5,16.54 215.21,16.25 214.87,16.25 214.75,16.13 214.75,9.57 214.87,9.45 215.31,9.45 215.59,9.18 215.59,8.23 v2(215.59,8.23)
ADDR: length 4
  TOP w0.102: U5800.3 206.96,113.36 207.63,114.03 207.81,114.03 R5805.1 208.5,114.27 209.4,115.17 R5804.1
ADP_DET: length 141.3
  TOP w0.102: U4701.M5 208.18,51.64 209.05,51.64 209.17,51.52 v2(209.46,51.52) ; v2(134.1,11.41) 134.36,11.15 142.9,11.15 147.88,6.17 151.78,6.17 v2(153.3,7.69) ; v2(134.3,17.15) 134.3,18.22 130.01,22.51 130.01,26.23 PR8226.1 128.24,27.6 v2(127.96,27.88)
  IN2 w0.114: v2(153.3,7.69) 153.34,7.73 153.34,8.61 153.82,9.09 159.91,9.09 161.08,10.26 166.78,10.26 167.22,10.7 169.33,10.7 169.77,10.26 171.86,10.26 173.12,11.52 187.52,11.52 189.71,9.33 197.47,9.33 198.54,10.39 199.4,10.39 203.38,14.37 203.38,17.8 204.6,19.02 204.6,31.81 208.95,36.15 208.95,46.12 208.49,46.58 208.49,49.71 208.27,49.93 208.27,51 208.8,51.52 v2(209.46,51.52)
  BOTTOM w0.102: v2(134.3,17.15) 134.63,16.82 134.63,14.07 134.1,13.55 v2(134.1,11.41)
  BOTTOM w0.178: PR8228.1 127.59,28.33 127.96,27.96 v2(127.96,27.88) 127.96,27.38 127.89,27.31 PU8200.5
ADP_ID_ADC_R: length 12.7
  TOP w0.102: R4710.1 198.66,43.25 C4710.2 199.31,43.06 v2(199.52,43.06) 200.14,43.06 200.92,43.85 200.92,44.18 202.07,45.32 203.66,45.32 204.19,45.85 204.19,47.22 204.12,47.28 204.12,48.3 203.93,48.49 203.93,49.39 203.61,49.71 U4701.E2
ADP_PRES_OUT: length 106.7
  TOP w0.102: v3(205.88,50.68) U4701.H3
  IN2 w0.076: v3(203.28,53.93) 203.6,53.62 203.6,53.16 203.81,52.95 204.06,52.95 204.26,52.76 204.26,52.41 204.36,52.3 204.9,52.3 205.56,51.64 205.56,51.21 205.88,50.89 v3(205.88,50.68)
  IN2 w0.114: v2(157.99,68.01) 158.42,68.43 159.6,68.43 159.66,68.37 165.13,68.37 166.23,69.47 167,69.47 167.78,68.69 170.29,68.69 v2(170.69,68.3)
  BOTTOM w0.076: 202.71,57.44 202.71,55.86 202.3,55.45 202.3,54.7 202.56,54.44 202.65,54.44 203.16,53.93 v3(203.28,53.93)
  BOTTOM w0.079: U400.BU35 128.03,80.52 128.03,79.87 127.95,79.67 127.95,79.37 128.15,79.18 128.15,78.14 131.19,75.09 133.15,75.09
  BOTTOM w0.102: 202.71,57.44 202.71,57.93 201.54,59.1 194.23,59.1 193.34,59.99 191.96,59.99 191.07,59.1 188.44,59.1 187.41,58.07 187.41,57.57 187.04,57.2 186.46,57.2 186.18,56.93 184.76,56.93 183.21,58.48 178.47,58.48 178.14,58.81 177.21,58.81 172.56,63.45 172.56,65.22 170.69,67.1 v2(170.69,68.3) ; 133.15,75.09 133.73,74.51 133.73,73.88 v2(134.04,73.57) 134.68,72.92 134.68,72.73 135.56,71.84 R454.1 135.56,71.35 135.51,71.3 135.51,67.7 137.3,65.9 144.17,65.9 144.48,65.59 150.54,65.59 151.05,66.1 155.1,66.1 155.69,66.7 156.13,67.13 157.12,67.13 v2(157.99,68.01)
AMBER_BATLED#: length 89.2
  TOP w0.102: v2(229.95,82.99) 230.08,83.11 C4725.2 ; U4701.L9 207.83,54.59 208.34,54.59 209.13,55.38 210.09,55.38 210.8,54.67 R4744.2 210.96,54.92 211.06,55.02 212,55.02 212.28,55.3 213.92,55.3 214.24,55.62 214.24,55.64 214.53,55.94 215.68,55.94 215.96,55.66 216.7,55.66 217.86,56.83 217.86,61.95 214.3,65.51 211.48,65.51 211.08,65.11 210.28,65.11 209.76,65.62 209.76,67.57 209.28,68.05 209.28,72.35 208.49,73.13 208.49,74.12 210.24,75.87 210.24,77.63 v2(209.88,77.99)
  IN1 w0.114: v2(224.04,82.25) 224.28,82.49 229.46,82.49 v2(229.95,82.99)
  BOTTOM w0.102: v2(229.95,82.99) 228.79,84.16 228.79,87.08 227.14,88.73 227.14,92.5 227.52,92.89 227.52,102.23 226.13,103.62 PR8002.1 ; v2(224.04,82.25) 223.28,82.25 219.13,78.1 210,78.1 v2(209.88,77.99)
AMD_VBIOS_SEL#: length 5.3
  BOTTOM w0.079: R534.1 142.35,90.03 142.21,90.16 140.7,90.16 140.52,89.98 138.66,89.98 138.59,90.01 138.37,90.24 U400.CP20
  BOTTOM w0.102: R532.1 142.91,89.79 R534.1
AMP_BEEP: length 1.5
  TOP w0.102: U3600.11 217.38,8.98 217.22,8.81 C3634.2
AMP_BEEP_L: length 9
  TOP w0.102: R3616.2 209.52,6.86 209.56,6.82 C3639.2 210.53,7.22 211.42,7.22 211.5,7.14 R3617.1 211.85,7.14 212.09,6.9 212.09,6.83 212.36,6.56 214.49,6.56 v2(214.73,6.8) 215.04,6.8 216.2,7.96 216.2,8.31 C3634.1
ANT_TUNE0: length 257
  TOP w0.102: v2(28.46,125.82) 28.5,125.78 C7874.2 ; v2(204.42,74.35) 203.3,74.35 v2(203.27,74.37)
  IN1 w0.114: v2(28.46,125.82) 28.57,125.7 30.49,125.7 31.25,126.47 34.81,126.47 35.31,125.97 42.07,125.97 43.36,127.26 48.35,127.26 48.81,126.8 51.11,126.8 51.8,127.49 56.82,127.49 57.37,128.04 71.4,128.04 72.78,126.65 73.94,126.65 74.14,126.45 77.32,126.45 79.14,124.63 81.63,124.63 84.4,121.85 107.17,121.85 107.82,121.2 112.77,121.2 114.11,122.54 115.35,122.54 116.1,121.79 118.84,121.79 119.48,122.43 121.45,122.43 121.89,122.88 126.19,122.88 127.34,124.02 133.41,124.02 134.55,122.88 145.33,122.88 147.51,125.06 152.19,125.06 153.4,123.85 158.09,123.85 160.71,121.22 160.71,119.85 161.41,119.15 161.41,117.24 161.72,116.93 161.72,113.94 166.54,109.12 169.65,109.12 170.33,108.44 178.23,108.44 178.59,108.79 179.93,108.79 180.31,109.17 182.49,109.17 182.75,109.43 185.87,109.43 187.49,107.81 191.25,107.81 191.8,108.36 195.49,108.36 196.16,107.68 196.16,105.16 198.62,102.7 200.82,102.7 201.61,103.48 206.26,103.48 208.86,100.88 208.86,99.04 208.25,98.43 199.45,98.43 199.22,98.2 199.22,97.62 202.93,93.91 202.93,91.62 201.53,90.23 201.53,89.59 202.1,89.03 202.1,85.52 203.49,84.13 203.49,80.88 204.62,79.75 204.62,79.37 205.21,78.77 205.21,76.89 204.96,76.64 204.96,74.89 v2(204.42,74.35)
  BOTTOM w0.102: v2(204.42,74.35) 204.2,74.35 202.95,73.1 CN4200.59 ; CN3400.30 28.65,131.84 28.86,131.63 28.86,131.26 29.19,130.93 29.19,127.86 28.46,127.12 v2(28.46,125.82)
ANT_TUNE1: length 256
  TOP w0.102: C7873.2 v2(29.19,125.15)
  IN1 w0.114: v2(204.42,74.98) 204.73,75.29 204.73,76.79 204.96,77.02 204.96,78.67 204.39,79.24 204.39,79.66 203.2,80.85 203.2,82.36 202.57,82.99 202.57,84.71 201.87,85.42 201.87,88.87 201.28,89.46 201.28,90.35 202.67,91.75 202.67,93.83 198.99,97.52 198.99,98.35 199.3,98.66 208.15,98.66 208.63,99.14 208.63,100.78 206.16,103.26 201.71,103.26 200.9,102.44 198.5,102.44 195.93,105.02 195.93,107.59 195.44,108.08 191.93,108.08 191.43,107.58 186.8,107.58 185.18,109.2 182.84,109.2 181.78,108.13 180.94,108.13 180.53,108.54 178.66,108.54 178.22,108.11 170.14,108.11 169.36,108.89 166.45,108.89 161.49,113.85 161.49,116.83 161.18,117.14 161.18,119.06 160.49,119.75 160.49,121.13 158,123.62 153.3,123.62 152.19,124.73 147.56,124.73 145.47,122.64 134.46,122.64 133.34,123.77 132.46,123.77 132.18,123.48 129.34,123.48 129.26,123.56 127.2,123.56 126.01,122.37 121.78,122.37 121.62,122.2 119.58,122.2 118.94,121.56 116.01,121.56 115.26,122.31 114.32,122.31 112.96,120.95 111.99,120.95 111.23,120.2 108.46,120.2 107.19,121.47 84.46,121.47 81.53,124.39 79.05,124.39 77.22,126.22 73.67,126.22 73.46,126.42 72.61,126.42 71.23,127.81 57.46,127.81 56.85,127.2 51.83,127.2 51.21,126.57 48.62,126.57 48.25,126.94 43.36,126.94 41.98,125.56 36.33,125.56 36.3,125.53 33.09,125.53 32.41,124.85 29.5,124.85 v2(29.19,125.15)
  BOTTOM w0.102: v2(29.19,125.15) 29.29,125.25 29.29,127.65 29.41,127.77 29.41,131 29.15,131.25 CN3400.29 ; CN4200.61 203.45,73.12 203.93,73.6 204.59,73.6 204.83,73.84 204.83,74.58 v2(204.42,74.98)
B/I: length 4.6
  TOP w0.102: PCN8500.3 93.2,27.93 v2(92.57,28.56) 92.45,28.68 PR8512.1 PR8515.2
BARREL_ADP_DET: length 78.8
  TOP w0.102: PR8022.1 191.6,89.56 PR8020.1 192.62,89.58 192.81,89.39 PQ8011.3 193.96,86.44 194.31,86.09 195.35,86.09 195.64,86.38 195.64,87.2 196.32,87.89 196.32,89.02 196.54,89.24 197.57,89.24 197.94,88.87 v2(197.94,88.68) ; U4701.H5 205.88,51.98 v3(206.53,51.98) ; C4720.1 214.04,51.52 v2(213.71,51.85)
  IN1 w0.114: v2(205.92,67.48) 205.37,67.48 202.78,70.07 202.78,71.1 201.45,72.44 201.45,75.15 201.4,75.2 201.4,75.65 201.07,75.99 201.07,76.32 200.52,76.87 200.52,80.7 200.57,80.75 200.57,81.84 199.5,82.91 199.5,83.11 197.98,84.64 197.98,86.92 197.47,87.43 197.47,88.21 v2(197.94,88.68)
  BOTTOM w0.102: v2(205.92,67.48) 206.01,67.58 208.51,67.58 209.91,66.17 209.91,65.4 210.81,64.49 211.12,64.49 211.73,63.89 212.17,63.89 212.48,64.19 213.97,64.19 215.82,62.34 219.21,62.34 219.77,61.77 219.77,56.43 218.24,54.9 216.73,54.9 214.01,52.19 214.01,52.16 v2(213.71,51.85) 213.14,51.85 212.36,52.63 211.06,52.63 210.64,53.05 208.42,53.05 207.36,51.98 v3(206.53,51.98)
BARREL_ADP_EN: length 73.5
  TOP w0.102: PQ8004.1 205.97,95.49 PR8011.2 205.72,94.39 v2(205.32,94.8) ; U4701.F4 204.25,51 203.94,50.69 v3(203.93,50.69)
  IN1 w0.114: v2(211.98,64.29) 211.98,65.13 210.42,66.69 210.42,68 210.05,68.37 210.05,71.8 208.52,73.34 208.52,76.51 209.02,77.02 209.02,78.16 208.26,78.92 206.99,78.92 206.02,79.9 206.02,81.79 205.54,82.26 205.54,84.19 203.54,86.19 203.54,86.64 204.7,87.81 204.7,94.06 205.32,94.68 v2(205.32,94.8)
  BOTTOM w0.076: v3(203.93,50.69) 204.13,50.69 204.45,51.01 204.81,51.01 204.9,51.1 204.9,51.62 205,51.72 205.43,51.72 205.58,51.86 206.08,51.86 206.28,51.66 206.98,51.66
  BOTTOM w0.102: 206.98,51.66 207.41,51.66 208.6,52.84 210.52,52.84 211.12,52.24 212.46,52.24 213.29,51.42 213.85,51.42 214.27,51.83 214.27,52.13 216.84,54.7 218.33,54.7 219.98,56.35 219.98,61.86 219.29,62.54 215.91,62.54 214,64.45 212.14,64.45 v2(211.98,64.29)
BAT_GRNLED#: length 91
  TOP w0.076: U4701.F7 v3(204.58,52.63)
  TOP w0.102: v2(210.16,64.14) 210.1,64.14 208.95,65.29 208.95,67.23 208.47,67.71 208.47,72.01 207.63,72.85 207.63,74.4 208.39,75.17 208.39,76.21 209.05,76.86 v2(209.58,76.86) ; v2(229.93,83.67) 230.36,84.1 C4724.2
  IN1 w0.114: v2(223.48,81.74) 223.48,82.4 223.83,82.76 229.01,82.76 v2(229.93,83.67)
  BOTTOM w0.076: 204.73,56.85 205.14,56.44 205.14,54.79 204.91,54.56 204.91,52.96 v3(204.58,52.63)
  BOTTOM w0.102: v2(229.93,83.67) 229.89,83.67 228.99,84.57 228.99,87.16 227.35,88.8 227.35,92.41 227.74,92.8 227.74,101.65 229.47,103.38 229.47,105.35 PR8004.2 ; v2(223.48,81.74) 223.07,81.74 219.22,77.89 210.6,77.89 v2(209.58,76.86) ; v2(210.16,64.14) 210.3,63.99 210.75,63.99 211.39,63.35 212.78,63.35 213.85,62.29 213.85,60.64 213.22,60 213.22,58.35 212.58,57.71 211.56,57.71 210.42,58.86 210.42,59.88 210.12,60.19 206.21,60.19 204.33,58.31 204.33,57.24 204.73,56.85
BATLOW#: length 102.9
  TOP w0.076: v3(200.41,54.06) 200.48,54.12 200.87,54.12 U4701.A9
  TOP w0.102: v2(193.19,58.93) 192.36,58.11 190.12,58.11 189.49,58.74 188.37,58.74 188.22,58.59 ; Q4701.3 185.61,55.07 185.91,55.38 186.85,55.38 187.42,55.95 187.42,57.63 188.22,58.43 188.22,58.59 ; 188.22,58.59 186.84,59.97 186.84,60.48 185.5,61.83 185.04,61.83 183.98,62.9 181.71,62.9 180.82,62.01 v2(180.82,61.57)
  IN2 w0.114: v2(180.82,61.57) 180.78,61.57 179.05,63.31 179.05,64.37 177.85,65.56 177.85,65.88 177.09,66.64 174.66,66.64 174.01,67.29 169.07,67.29 168.85,67.52 157.62,67.52 v2(156.21,68.93)
  BOTTOM w0.076: v3(200.41,54.06) 200.77,54.41 200.77,55.53 201.35,56.11 201.35,56.85
  BOTTOM w0.079: 133.63,75.81 133.13,76.31 131.12,76.31 129.03,78.4 U400.BV36
  BOTTOM w0.102: 133.63,75.81 134.57,74.87 134.98,74.87 135.52,74.33 135.52,73.03 135.97,72.57 135.98,72.57 136.46,72.09 R453.1 136.99,72.09 137.14,71.94 137.14,69.68 136.32,68.86 136.32,68.29 138.07,66.54 144.44,66.54 144.74,66.24 150.27,66.24 152.15,68.12 155.4,68.12 v2(156.21,68.93) ; v2(193.19,58.93) 193.23,58.9 199.49,58.9 199.78,58.61 201.3,58.61 201.35,58.55 201.35,56.85
BATT+:
  vias: v2(84.13,27.77)
BIT_CLK_AUDIO: length 147.5
  TOP w0.102: R3615.1 214.58,11.17 214.89,11.49 214.89,12.27 215.33,12.71 v2(215.57,12.71)
  BOTTOM w0.079: C420.2 R570.1
  BOTTOM w0.102: v2(215.57,12.71) 215.77,12.71 217,13.95 217,17.91 216.32,18.59 216.32,21.36 216.26,21.42 216.26,22.12 217.13,22.98 217.13,25.63 218,26.51 218,27.78 218.21,27.99 218.21,28.58 219.59,29.97 219.59,34.88 216.94,37.53 216.94,42.03 215.67,43.31 209.99,43.31 208.36,41.67 203.95,41.67 200.73,38.46 199.14,38.46 198.04,39.57 198.04,40.85 194.75,44.15 194.75,46.82 193.45,48.12 189.78,48.12 187.95,49.94 173.42,49.94 169.43,53.92 169.43,54.95 165.98,58.4 165.98,58.66 164.39,60.25 163,60.25 161.15,62.1 159.03,62.1 158.29,61.36 153.84,61.36 153.41,60.92 149.21,60.92 148.44,61.7 142.86,61.7 142.58,61.98 134.58,61.98 131.18,65.38 131.18,66.79 129.95,68.03 129.95,70.8 129.24,71.5 129.24,72.23 C420.2
BIT_CLK_AUDIO_L: length 4.9
  TOP w0.102: R3615.2 214.1,11.95 213.95,12.1 C3622.2 213.48,12.31 213.75,12.58 214.82,12.58 215.37,13.13 215.77,13.13 215.96,12.94 215.96,12.88 216.11,12.73 U3600.5
BLON_CON: length 36.4
  TOP w0.102: v2(22.59,123.25) 22.84,122.99 22.84,122.06 R3423.1 22.33,121.55 22.33,118.8 19.83,116.3 Q3401.3
  IN1 w0.114: v2(22.59,123.25) 22.59,124.52 23.34,125.27 23.34,128.88 24.34,129.87 25.59,129.87 25.67,129.79 31.58,129.79 32.12,129.25 33.62,129.25 35.16,130.78 38.46,130.78 38.63,130.95 41.29,130.95 v2(41.46,131.12)
  BOTTOM w0.102: CN3400.5 41.15,131.83 41.33,131.65 41.33,131.25 v2(41.46,131.12)
