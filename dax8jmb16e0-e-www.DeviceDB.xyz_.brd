# Allegro board dax8jmb16e0-e-www.DeviceDB.xyz_.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ25: length 91.7
  IN2 w0.127: v1(114.11,82.92) 114.11,82.82 113.75,82.46 113.75,80.52 115.31,78.96 115.81,78.96 115.93,78.83 115.93,78.34 116.11,78.16 116.34,78.16 116.47,78.29 116.47,78.82 116.59,78.95 116.85,78.95 116.98,78.82 116.98,78.29 117.1,78.16 118.02,78.16 118.4,77.78 118.73,77.78 118.85,77.65 118.85,76.87 119.17,76.55 119.35,76.55 119.45,76.65 119.45,77.55 119.61,77.71 119.79,77.71 120.86,76.64 120.86,71.89 121.06,71.68 123.1,71.68 125.97,68.81 125.97,67.2 132.42,60.75 136.03,60.75 137.36,59.42 139.13,59.42 139.46,59.75 139.73,59.75 139.87,59.62 139.87,59.07 140.05,58.89 140.23,58.89 140.36,59.02 140.36,59.63 140.48,59.75 140.74,59.75 140.86,59.63 140.86,59.02 140.99,58.89 148.38,58.89 150.27,57 154.54,57 155.44,56.09 161.87,56.09 162.37,55.59 164.57,55.59 165.12,55.04 166.13,55.04 175.61,45.56 v2(175.61,43.95)
  BOTTOM w0.079: U400.AR32 114.28,82.92 v1(114.11,82.92)
  BOTTOM w0.102: JDIM2801.191 175.57,44.25 175.61,44.21 v2(175.61,43.95)
M_B_DQ26: length 94.7
  IN2 w0.127: v1(116,83.61) 116.52,83.09 116.52,82.56 117.1,81.97 119.39,81.97 119.62,81.74 120.35,81.74 121.13,80.97 121.13,80.79 122.55,79.37 122.55,78.68 123.36,77.87 124.66,77.87 125.03,77.49 125.03,76.76 127.03,74.76 127.03,74.58 126.93,74.48 125.71,74.48 125.56,74.33 125.56,74.12 125.69,74 127.19,74 127.64,73.54 127.64,72.17 129.01,70.8 129.01,68.73 133.99,63.76 140.99,63.76 141.99,62.76 146.96,62.76 147.31,62.41 149.12,62.41 151.02,60.51 151.72,60.51 151.93,60.71 151.93,60.97 152.06,61.1 153.49,61.1 153.64,60.94 153.64,60.19 153.77,60.06 154.03,60.06 154.15,60.19 154.15,60.94 154.28,61.07 154.52,61.07 154.64,60.94 154.64,60.43 154.75,60.33 154.97,60.33 155.1,60.46 155.1,60.99 155.2,61.09 155.53,61.09 157.17,59.46 164.96,59.46 166.24,58.18 167.27,58.18 170.15,55.3 170.88,55.3 172.28,53.9 172.28,53.17 179.32,46.13 v2(179.32,43.33)
  BOTTOM w0.079: U400.AV30 116.26,83.87 v1(116,83.61)
  BOTTOM w0.102: JDIM2801.207 179.57,44.3 179.32,44.06 v2(179.32,43.33)
M_B_DQ27: length 95.2
  IN2 w0.127: v2(179.1,39.75) 179.79,42.39 179.94,43.26 179.94,46.07 172.67,53.35 172.67,54.06 169.67,57.05 169.67,57.07 168.17,58.56 166.39,58.56 165.09,59.87 157.3,59.87 155.69,61.48 150.59,61.48 149.27,62.79 147.47,62.79 147.12,63.14 142.14,63.14 141.15,64.14 134.4,64.14 130.18,68.36 130.18,69.93 129.65,70.46 129.65,70.77 128.05,72.37 128.05,74.39 127.04,75.4 125.47,77.44 124.77,78.14 124.45,78.14 124.09,78.34 123.78,78.65 123.33,79.31 123.32,79.32 122.74,79.81 120.5,82.04 119.92,82.21 119.66,82.28 117.68,82.47 117.36,82.8 117.36,85.02 117.09,85.29 116.68,85.29 116.49,85.1 116.49,84.36 116.33,84.19 v1(115.99,84.19)
  BOTTOM w0.079: U400.AV29 116.26,84.33 116.13,84.33 v1(115.99,84.19)
  BOTTOM w0.102: v2(179.1,39.75) 179.82,39.04 JDIM2801.208
M_B_DQ28: length 93.6
  IN2 w0.079: 113.34,81.74 113.34,82.35 113.7,82.71 113.7,83.72 v1(114.17,84.19)
  IN2 w0.127: v2(174.4,39.6) 175.04,40.24 175.04,45.59 165.97,54.66 164.96,54.66 164.41,55.21 162.21,55.21 161.71,55.71 155.29,55.71 154.38,56.62 150.11,56.62 148.22,58.51 139.86,58.51 139.33,59.04 137.2,59.04 135.87,60.37 132.26,60.37 125.59,67.04 125.59,68.71 123.05,71.25 120.81,71.25 119.99,72.07 119.99,75.17 118.3,76.87 118.3,77.32 117.84,77.78 117.33,77.78 116.87,77.32 116.25,77.32 113.34,80.22 113.34,81.74
  BOTTOM w0.079: U400.AR30 114.45,84.04 114.32,84.04 v1(114.17,84.19)
  BOTTOM w0.102: JDIM2801.190 175.32,37.91 175.12,38.11 175.12,38.89 v2(174.4,39.6)
M_B_DQ29: length 93.6
  IN2 w0.079: 114.87,82.48 114.87,82.58 114.69,82.76 114.69,84.13 114.64,84.18 114.64,84.38 v1(114.17,84.84)
  IN2 w0.127: v2(176.59,43.94) 176.65,44.01 176.65,45.6 166.41,55.83 165.41,55.83 164.88,56.36 162.68,56.36 162.19,56.85 155.76,56.85 154.85,57.76 150.59,57.76 148.69,59.65 141.91,59.65 140.47,61.1 140.06,61.1 139.94,60.97 139.94,60.67 139.79,60.52 139.61,60.52 139.43,60.69 139.43,61.32 139.25,61.5 139.02,61.5 138.87,61.35 138.87,60.64 138.74,60.51 138.48,60.51 138.34,60.66 138.34,61.37 138.21,61.5 137.96,61.5 137.83,61.37 137.83,60.66 137.7,60.53 137.44,60.53 137.31,60.66 137.31,61.38 137.18,61.51 132.73,61.51 126.75,67.49 126.75,69.09 123.22,72.62 122.21,72.62 121.75,73.08 121.75,76.69 119.31,79.13 119.06,79.13 118.82,78.89 118.64,78.89 118.47,79.05 118.47,79.25 118.73,79.51 118.73,79.63 118.58,79.79 115.83,79.79 115.62,80 115.62,80.18 115.88,80.43 115.88,80.61 115.7,80.79 115.52,80.79 115.26,80.54 115.08,80.54 114.71,80.9 114.71,81.57 114.87,81.72 114.87,82.48
  BOTTOM w0.079: U400.AR29 114.47,84.67 114.34,84.67 v1(114.17,84.84)
  BOTTOM w0.102: v2(176.59,43.94) 176.59,44.3 176.57,44.32 JDIM2801.195
M_B_DQ30: length 93.2
  IN2 w0.127: v1(116,82.32) 116.67,81.64 119.08,81.64 120.23,80.5 120.96,80.5 122.2,79.26 122.2,78.45 124.1,76.55 124.1,75.07 124.98,74.2 124.98,73.34 125.51,72.8 125.51,72.4 126.68,71.23 127.08,71.23 128.43,69.88 128.43,68.78 133.83,63.38 140.83,63.38 141.83,62.38 146.64,62.38 147.14,61.88 149.11,61.88 151.31,59.68 151.51,59.68 151.64,59.8 151.64,60 151.77,60.13 152.02,60.13 152.15,60 152.15,59.8 152.28,59.68 152.53,59.68 152.66,59.8 152.66,60.39 152.81,60.54 153.01,60.54 153.17,60.39 153.17,59.8 153.29,59.68 154.18,59.68 154.45,59.95 156.14,59.95 157.01,59.08 162.6,59.08 163.46,58.22 165.66,58.22 166.08,57.8 167.11,57.8 169.99,54.92 170.72,54.92 171.9,53.74 171.9,53.01 178.9,46.01 178.9,43.54 178.65,43.29 178.65,38.84 v2(179.02,38.46)
  BOTTOM w0.079: U400.AV32 116.25,82.57 v1(116,82.32)
  BOTTOM w0.102: v2(179.02,38.46) 178.82,38.25 JDIM2801.204
M_B_DQ31: length 93.4
  IN2 w0.079: v1(115.97,83) 115.63,82.66 115.63,82.18 116.01,81.79
  IN2 w0.127: v2(178.08,43.31) 178.3,43.53 178.3,43.54 178.52,43.76 178.52,44.35 178.14,44.73 178.14,46.23 167.05,57.33 166.01,57.33 165.5,57.84 163.3,57.84 162.44,58.7 156.85,58.7 155.98,59.57 154.61,59.57 154.34,59.3 151.15,59.3 149.03,61.42 147.06,61.42 146.48,62 146.15,62 146.03,61.87 146.03,61.27 145.9,61.14 145.66,61.14 145.52,61.28 145.52,61.87 145.39,62 145.14,62 145.01,61.87 145.01,61.32 144.88,61.19 144.6,61.19 144.5,61.29 144.5,61.87 144.38,62 144.05,62 143.92,61.87 143.92,61.27 143.78,61.14 143.54,61.14 143.41,61.27 143.41,61.87 143.28,62 143.03,62 142.9,61.87 142.9,61.27 142.78,61.15 142.52,61.15 142.4,61.27 142.4,61.87 142.27,62 141.67,62 140.67,63 133.67,63 128.1,68.57 128.1,69.4 124.35,73.15 124.35,73.52 124.56,73.74 124.56,73.91 124.38,74.09 124.2,74.09 123.99,73.88 123.81,73.88 123.68,74.01 123.68,76.33 121.85,78.16 121.85,79.05 121.32,79.58 120.48,79.58 119.24,80.83 116.98,80.83 116.76,81.05 116.01,81.79
  BOTTOM w0.079: U400.AV31 116.19,83.22 v1(115.97,83)
  BOTTOM w0.102: v2(178.08,43.31) 178.57,43.79 JDIM2801.203
M_B_DQ32: length 54.5
  IN1 w0.127: v1(120.46,72.27) 120.46,71.34 123.71,68.09 123.71,60.43 124.1,60.04 124.1,59.86 123.64,59.39 123.64,59.21 123.81,59.03 123.99,59.03 124.46,59.5 124.64,59.5 124.82,59.32 124.82,59.14 124.35,58.67 124.35,58.49 124.58,58.26 124.76,58.26 125.23,58.73 125.41,58.73 125.92,58.22 125.92,58.02 125.46,57.56 125.46,57.38 128.08,54.77 129.54,54.77 132.93,51.37 132.93,49.91 137.45,45.39 v2(137.45,43.59)
  BOTTOM w0.079: U400.BA35 118,80.56 118,79.98 117.89,79.69 117.89,79.07 118.07,78.89 118.07,77.97 118.6,77.44 118.6,76.15 118.37,75.93 118.37,75.67
  BOTTOM w0.102: 118.37,75.67 118.37,73.25 118.47,73.14 119.16,73.14 119.26,73.04 119.26,72.84 119.16,72.74 118.47,72.74 118.37,72.64 118.37,72.45 118.55,72.27 v1(120.46,72.27) ; JDIM2801.45 137.07,43.98 v2(137.45,43.59)
M_B_DQ33: length 54.4
  IN1 w0.127: v2(141.32,39.02) 141.32,39.48 141.39,40.04 141.47,40.34 142.01,42.34 142.06,42.58 142.06,45.58 139.25,48.39 139.25,49.86 131.03,58.08 129.23,60.93 128.08,62.76 127.79,63.51 127.61,63.99 127.23,64.98 127.23,69.53 124.03,73.74 123.41,74.55 123.33,74.65 122.72,75.35 122.53,75.52 121.33,76.39 120.78,76.8 120.58,76.9 v1(119.85,77.09)
  BOTTOM w0.079: U400.BA34 118.85,81.49 119.09,81.47 119.22,81.34 119.25,81.23 119.25,81.13 119.19,81 119.19,80.75 119.22,80.67 119.22,80.42 119.19,80.36 119.19,80.1 119.22,80.03 119.22,79.82 119.19,79.73 119.19,79.11 119.25,79.03 119.47,78.67 119.47,77.73 v1(119.85,77.09)
  BOTTOM w0.102: v2(141.32,39.02) JDIM2801.62
M_B_DQ34: length 54.2
  IN1 w0.127: v2(140.32,39.01) 139.84,39.49 139.84,40.77 141.67,42.61 141.67,45.43 138.87,48.24 138.87,49.7 127.76,60.8 127.76,61.54 126.85,62.45 126.85,69.23 124.27,71.82 124.27,72.32 124,72.59 123.49,72.59 123.3,72.78 123.3,73.72 122.77,74.25 122.77,74.73 v1(122.3,75.2)
  BOTTOM w0.079: 121.8,76.48 121.8,76.56 120.14,78.22 120.14,79.1 120.04,79.19 120.04,79.68 120,79.79 119.99,79.84 119.95,79.95 119.95,80.05 119.97,80.17 119.97,80.52 U400.BC35
  BOTTOM w0.102: 121.8,76.48 121.8,75.69 v1(122.3,75.2) ; v2(140.32,39.01) JDIM2801.58
M_B_DQ35: length 54.4
  IN1 w0.127: v2(137.32,39.05) 136.91,39.45 136.91,39.98 137.04,40.11 137.39,40.11 137.52,40.24 137.52,40.47 137.37,40.62 137.04,40.62 136.91,40.74 136.91,45.39 132.55,49.75 132.55,51.22 129.38,54.39 127.92,54.39 123.1,59.2 123.1,63.84 123.32,64.06 123.32,67.93 120.15,71.11 120.15,71.71 119.82,72.04 119.82,76.46 v1(119.9,76.54)
  BOTTOM w0.079: U400.BC34 119.53,81.52 119.42,81.41 119.42,81.1 119.36,80.96 119.36,80.79 119.39,80.71 119.39,80.38 119.36,80.32 119.36,80.14 119.39,80.06 119.39,79.79 119.36,79.7 119.36,79.16 119.64,78.89 119.64,77.84 120.25,77.22 120.25,76.89 v1(119.9,76.54)
  BOTTOM w0.102: JDIM2801.46 v2(137.32,39.05)
M_B_DQ36: length 52.8
  IN1 w0.127: v2(138.32,39.02) 138.79,39.5 138.79,45.13 133.7,50.22 133.7,51.69 129.86,55.53 128.57,55.53 126.68,57.41 126.68,58.7 124.47,60.92 124.47,68.43 121.17,71.73 121.17,73.98 121.04,74.11 v1(120.39,74.11)
  BOTTOM w0.079: 119.21,75.07 119.21,75.29 118.94,75.56 118.94,77.58 118.41,78.11 118.41,79.03 118.32,79.12 U400.BA37
  BOTTOM w0.102: 119.21,75.07 119.21,74.55 119.65,74.11 v1(120.39,74.11) ; v2(138.32,39.02) JDIM2801.50
M_B_DQ37: length 53.5
  IN1 w0.127: v1(120.42,73.49) 120.86,73.04 120.86,71.48 124.09,68.25 124.09,60.59 126.3,58.38 126.3,57.26 128.41,55.15 129.7,55.15 133.32,51.53 133.32,50.07 138.08,45.3 138.08,41.79 137.96,41.67 137.78,41.67 137.64,41.81 v2(137.64,42.32)
  BOTTOM w0.079: U400.BA36 118.17,80.07 118.17,79.95 118.06,79.66 118.06,79.14 118.24,78.96 118.24,78.04 118.77,77.51 118.77,75.13
  BOTTOM w0.102: v2(137.64,42.32) 137.64,41.89 137.79,41.74 138.01,41.74 138.24,41.97 138.24,44.12 138.07,44.3 JDIM2801.49 ; 118.77,75.13 118.77,74.44 119.72,73.49 v1(120.42,73.49)
M_B_DQ38: length 53.1
  IN1 w0.127: v2(140.82,42.37) 140.82,42.38 141.29,42.85 141.29,45.27 138.75,47.81 138.48,48.08 138.48,48.32 138.31,48.49 138.12,48.49 138,48.62 138,48.8 138.48,49.29 138.48,49.47 138.31,49.65 138.13,49.65 137.61,49.13 137.43,49.13 137.2,49.36 137.2,49.54 137.75,50.1 137.75,50.28 127.38,60.65 127.38,61.38 126.47,62.29 126.47,69.07 122.78,72.76 122.78,73.58 v2(122.39,73.97)
  BOTTOM w0.079: U400.BC36 119.79,80.05 119.79,79.92 119.87,79.65 119.87,79.12 119.97,79.03 119.97,78.11 121.5,76.59 121.5,76.48
  BOTTOM w0.102: JDIM2801.63 141.57,44.33 141.82,44.07 141.82,42.53 141.67,42.37 v2(140.82,42.37) ; v2(122.39,73.97) 121.5,74.86 121.5,76.48
M_B_DQ39: length 52.4
  IN1 w0.127: v1(122.39,73.32) 122.39,72.62 126.09,68.92 126.09,62.13 127,61.22 127,60.49 135.72,51.77 135.72,51.59 135.18,51.06 135.18,50.84 135.4,50.62 135.58,50.62 136.13,51.18 136.31,51.18 136.49,51 136.49,50.82 135.94,50.26 135.94,50.08 136.12,49.9 136.3,49.9 136.85,50.46 137.03,50.46 137.21,50.28 137.21,50.1 136.66,49.54 136.66,49.36 140.85,45.18 v2(140.85,43.69)
  BOTTOM w0.079: U400.BC37 119.62,79.14 119.8,78.96 119.8,77.98 121.01,76.76 121.01,76.51
  BOTTOM w0.102: 121.01,76.51 121.01,74.3 121.12,74.2 121.65,74.2 121.8,74.05 121.8,73.87 121.67,73.74 121.09,73.74 120.99,73.64 120.99,73.46 121.13,73.32 v1(122.39,73.32) ; JDIM2801.59 140.57,43.97 140.85,43.69 v2(140.85,43.69)
M_B_DQ40: length 57.2
  IN1 w0.127: v1(126.83,72.01) 127.36,72.01 127.47,71.91 127.47,71.71 127.31,71.56 126.53,71.56 126.43,71.46 126.43,71.23 126.58,71.07 127.26,71.07 127.44,70.9 127.44,70.39 127.87,69.96 127.87,65.14 128.58,64.42 128.58,63.22 129.45,62.36 129.45,61.88 129.56,61.76 130.04,61.76 130.26,61.54 130.26,61.42 129.97,61.13 129.97,60.95 130.13,60.79 130.34,60.79 130.59,61.03 130.77,61.03 130.95,60.85 130.95,60.67 130.52,60.25 130.52,60.07 130.68,59.92 130.91,59.92 131.31,60.31 131.49,60.31 131.76,60.04 131.76,59.8 131.2,59.24 131.2,59 131.34,58.86 131.61,58.86 132.01,59.26 132.24,59.26 132.36,59.14 132.36,58.9 131.89,58.43 131.89,58.25 132.16,57.98 132.34,57.98 132.84,58.48 133.02,58.48 133.2,58.3 133.2,58.12 132.7,57.62 132.7,57.44 139.88,50.25 139.88,48.66 142.75,45.78 v2(142.75,43.67)
  BOTTOM w0.079: U400.BE35 120.52,80.22 120.52,79.98 120.31,79.4 120.31,78.39 121.99,76.7 122.67,75.37 122.67,74.86 123,74.27
  BOTTOM w0.102: v1(126.83,72.01) 126.45,71.81 126.32,71.81 125.92,71.94 125.46,72.21 124.04,73.23 123,74.27 ; v2(142.75,43.67) 142.57,43.86 JDIM2801.67
M_B_DQ41: length 57.6
  IN1 w0.127: v1(126.93,73.59) 127.44,73.59 128.81,72.22 128.81,71.61 129.45,70.97 129.45,70.54 130.02,69.97 130.02,63.86 133.08,60.8 133.08,60.31 135.67,57.72 135.67,56.32 144.23,47.76 144.23,47.5 144,47.27 143.52,47.27 143.32,47.07 143.32,46.84 144.25,45.91 144.25,42.05 142.93,40.74 142.93,39.4 v2(143.32,39.02)
  BOTTOM w0.079: 123.36,76.03 123.36,76.15 120.83,78.67 120.83,79.17 121.09,79.43 121.09,79.7 121.06,79.79 121.06,80.04 121.09,80.15 121.09,80.32 121.05,80.42 121.05,80.69 121.09,80.78 121.09,80.98 121.05,81.07 121.04,81.09 121.04,81.32 U400.BE34
  BOTTOM w0.102: v1(126.93,73.59) 126.93,73.67 126.2,74.4 124.21,74.4 123.36,75.25 123.36,76.03 ; v2(143.32,39.02) JDIM2801.70
M_B_DQ42: length 57.3
  IN1 w0.127: v2(146.82,39.05) 147.13,39.05 147.3,39.22 147.3,40.49 148.01,41.2 148.01,48.47 138.38,58.1 138.38,58.75 136.28,60.86 136.28,61.74 134.04,63.98 134.04,69.47 133.99,70.41 133.99,71.1 133.74,71.55 132.74,72.73 132.26,73.21 131.73,73.42 131.24,73.61 131.05,73.67 130.45,73.67 127.78,76.33 126.09,76.33 v1(124.49,77.48)
  BOTTOM w0.079: U400.BG35 122.13,80.65 122.45,80.34 122.45,80.02 122.46,79.98 122.56,79.68 122.56,78.85 123.76,77.65 124.32,77.65 v1(124.49,77.48)
  BOTTOM w0.102: v2(146.82,39.05) JDIM2801.84
M_B_DQ43: length 58.2
  IN1 w0.127: v2(126.09,74.99) 126.09,74.66 126.17,74.58 127.92,74.58 130.06,72.45 130.06,71.91 130.69,71.28 131.22,71.28 131.52,70.98 131.52,67.58 131.65,67.45 132.29,67.45 132.42,67.32 132.42,67.07 132.29,66.94 131.65,66.94 131.52,66.82 131.52,66.56 131.65,66.43 132.32,66.43 132.44,66.31 132.44,66.05 132.32,65.93 131.68,65.93 131.52,65.77 131.52,65.46 131.62,65.36 132.29,65.36 132.42,65.23 132.42,65.05 132.27,64.9 131.65,64.9 131.52,64.78 131.52,64.64 134.69,61.47 134.69,60.83 137.24,58.28 137.24,57.46 145.78,48.92 145.78,43.77 v2(145.66,43.64)
  BOTTOM w0.079: 123.6,76.13 123.6,76.23 121,78.84 121,79.1 121.26,79.36 121.26,79.73 121.22,79.82 121.22,80.01 121.26,80.12 121.26,80.36 121.22,80.45 121.22,80.65 121.26,80.74 121.26,81.02 121.2,81.13 121.2,81.35 121.37,81.52 U400.BG34
  BOTTOM w0.102: 123.6,76.13 123.6,75.34 124.29,74.66 125.76,74.66 v2(126.09,74.99) ; v2(145.66,43.64) 145.66,44.01 145.57,44.1 JDIM2801.79
M_B_DQ44: length 56.3
  IN1 w0.127: v1(126.15,73.6) 126.36,73.6 126.74,73.22 126.74,72.92 127,72.66 127.86,72.66 128.35,72.17 128.35,71.4 128.89,70.87 128.89,70.29 128.63,70.03 128.63,65.62 129.45,64.8 129.45,63.43 132.52,60.36 132.52,60.15 134.63,58.04 134.63,56.58 141.16,50.05 141.16,49.9 140.64,49.38 140.64,48.97 140.77,48.85 140.95,48.85 141.69,49.58 141.87,49.58 142.05,49.4 142.05,49.22 141.31,48.49 141.31,48.31 141.47,48.15 141.65,48.15 142.36,48.86 142.54,48.86 142.71,48.69 142.71,48.49 142.02,47.81 142.02,47.6 142.17,47.45 142.42,47.45 143.1,48.12 143.32,48.12 143.47,47.97 143.47,47.76 142.77,47.05 142.77,46.85 143.79,45.82 v2(143.79,43.58)
  BOTTOM w0.079: U400.BE37 120.67,79.41 120.67,78.6 123.12,76.14 123.12,75.04 123.21,74.95
  BOTTOM w0.102: v2(143.79,43.58) 143.79,44.03 143.57,44.26 JDIM2801.71 ; 123.21,74.95 124.06,74.1 125.65,74.1 v1(126.15,73.6)
M_B_DQ45: length 56.6
  IN1 w0.127: v1(125.77,73.1) 125.77,72.9 126.06,72.61 126.61,72.61 126.82,72.41 127.62,72.41 127.83,72.2 127.83,70.58 128.25,70.16 128.25,65.37 128.99,64.62 128.99,63.35 132.14,60.2 132.14,59.9 133.74,58.3 133.74,58.12 133.23,57.62 133.23,57.44 133.41,57.26 133.59,57.26 133.87,57.54 134.12,57.54 134.25,57.41 134.25,57.13 134,56.88 134,56.68 140.26,50.41 140.26,48.81 143.34,45.74 143.34,43.01 143.34,43 143.34,41.68 143.19,41.53 142.63,41.53 142.39,41.29 142.39,40.27 142.02,39.91 142.02,39.34 v2(142.32,39.05)
  BOTTOM w0.079: 123.02,74.73 122.94,74.8 122.94,76.08 120.47,78.56 120.47,79.37 120.68,79.95 120.68,80.07 U400.BE36
  BOTTOM w0.102: v2(142.32,39.05) JDIM2801.66 ; v1(125.77,73.1) 125.69,73.1 124.91,73.1 124.38,73.37 123.02,74.73
M_B_DQ46: length 56.4
  IN1 w0.127: v2(145.79,39.05) 146.21,39.05 146.29,39.12 146.29,40.98 147.47,42.16 147.47,48.38 138,57.85 138,58.6 135.74,60.86 135.74,61.75 133.61,63.87 133.61,70.9 133.4,71.28 131.55,72.62 131.35,73 131.27,73.1 131.02,73.26 130.56,73.26 130.2,73.43 127.62,76.01 126.07,76.01 v1(124.52,76.89)
  BOTTOM w0.079: U400.BG36 122.32,79.88 122.39,79.65 122.39,78.66 123.71,77.35 v1(124.52,76.89)
  BOTTOM w0.102: JDIM2801.80 145.82,39.02 v2(145.79,39.05)
M_B_DQ47: length 55.9
  IN1 w0.127: v1(124.49,76.31) 124.82,75.98 125.2,75.98 125.66,75.52 126.46,75.52 127.01,74.97 128.11,74.97 131.63,71.46 132.19,71.46 132.57,71.07 132.57,70.27 132.7,70.14 133,70.14 133.13,70.02 133.13,69.76 133,69.64 132.06,69.64 131.94,69.51 131.94,69.22 132.06,69.09 132.95,69.09 133.13,68.92 133.13,68.66 133,68.53 132.27,68.53 132.14,68.41 132.14,68.23 132.85,67.52 132.85,64.09 135.23,61.72 135.23,60.83 137.62,58.44 137.62,57.62 146.21,49.03 146.21,42.94 v2(145.65,42.37)
  BOTTOM w0.079: U400.BG37 122.13,78.54 124.37,76.31 v1(124.49,76.31)
  BOTTOM w0.102: v2(145.65,42.37) 146.57,43.29 JDIM2801.83
M_B_DQ48: length 91.4
  IN1 w0.127: v2(181.82,38.33) 181.26,38.88 181.26,40.39 179.51,42.14 179.27,42.14 178.8,42.62 178.8,43.82 177.76,44.86 154.6,44.86 135.68,63.78 135.68,71.02 135.01,71.69 135.01,72.27 132.8,74.48 130.62,74.48 128.1,76.99 126.6,76.99 125.33,78.26 120.96,78.26 118.12,81.11 118.12,81.79 117.82,82.09 v1(117.82,82.89)
  BOTTOM w0.079: U400.BA32 118.11,82.73 117.98,82.73 v1(117.82,82.89)
  BOTTOM w0.102: v2(181.82,38.33) JDIM2801.216
M_B_DQ49: length 92
  IN1 w0.127: v2(180.44,43.95) 178.77,45.62 154.91,45.62 137.68,62.86 137.68,64.09 137.52,64.24 136.94,64.24 136.79,64.39 136.79,64.66 136.88,64.75 136.97,64.83 137.48,64.83 137.63,64.99 137.63,65.21 137.5,65.34 136.91,65.34 136.79,65.47 136.79,65.72 136.91,65.85 137.56,65.85 137.68,65.98 137.68,66.23 137.56,66.36 136.89,66.36 136.76,66.48 136.76,66.71 136.91,66.87 137.56,66.87 137.68,66.99 137.68,67.25 137.56,67.37 136.89,67.37 136.74,67.53 136.74,67.75 136.86,67.88 137.56,67.88 137.68,68.01 137.68,70.41 135.98,72.11 135.98,74.07 134.69,75.36 130.7,75.36 128.33,77.73 126.7,77.73 124.98,79.46 120.81,79.46 118.68,81.59 v1(118.68,82.89)
  BOTTOM w0.079: U400.BA31 118.41,83.08 118.49,83.08 v1(118.68,82.89)
  BOTTOM w0.102: JDIM2801.211 180.57,44.3 180.44,44.18 v2(180.44,43.95)
M_B_DQ50: length 93.7
  IN1 w0.079: 120.89,82.66 120.89,83.18 v1(120.5,83.57)
  IN1 w0.114: 120.91,82.45 120.89,82.48 120.89,82.66
  IN1 w0.127: 120.91,82.45 121.32,82.05 122.07,82.05 122.19,81.92 122.19,81.36 122.32,81.23 122.57,81.23 122.7,81.36 122.7,81.92 122.83,82.05 123.08,82.05 123.21,81.92 123.21,81.36 123.34,81.23 123.59,81.23 123.72,81.36 123.72,81.92 123.84,82.05 124.16,82.05 124.29,81.92 124.29,81.54 124.33,81.5 124.42,81.41 124.6,81.41 124.75,81.56 124.75,81.9 124.9,82.05 125.71,82.05 127.8,79.96 128.61,79.96 131.05,77.53 135.65,77.53 139.64,73.53 139.64,71.82 141.43,70.04 141.43,62.53 155.99,47.97 179.73,47.97 181.93,45.77 182.56,45.77 184.18,44.15 184.18,43.26 184.37,43.08 v2(184.59,43.08)
  BOTTOM w0.079: U400.BD31 120.28,83.4 120.33,83.4 v1(120.5,83.57)
  BOTTOM w0.102: JDIM2801.225 184.07,44.24 184.18,44.13 184.18,43.48 v2(184.59,43.08)
M_B_DQ51: length 94
  IN1 w0.127: v2(183.7,39.65) 183.14,39.65 183.02,39.78 183.02,41.79 183.42,42.19 183.42,43.78 182.18,45.01 181.62,45.01 179.51,47.11 155.67,47.11 139.17,63.61 139.17,71.09 138.34,71.92 138.34,73.8 135.45,76.69 130.92,76.69 128.46,79.15 127.72,79.15 126.37,80.5 121.8,80.5 120.34,81.96 119.91,81.96 119.67,82.2 v1(119.67,82.92)
  BOTTOM w0.079: U400.BD32 119.91,82.76 119.83,82.76 v1(119.67,82.92)
  BOTTOM w0.102: JDIM2801.224 183.82,38.94 183.7,39.05 v2(183.7,39.65)
M_B_DQ52: length 92.8
  IN1 w0.127: v1(117.82,83.54) 117.51,83.54 117.38,83.42 117.38,82.66 117.1,82.38 117.1,81.06 117.58,80.57 118.09,80.57 120.7,77.96 125,77.96 126.34,76.62 128.02,76.62 130.53,74.12 132.57,74.12 134.63,72.07 134.63,71.53 135.3,70.86 135.3,63.62 154.44,44.48 176.66,44.48 177.4,43.74 177.4,42.69 178.33,41.76 179.33,41.76 180.75,40.35 v2(180.75,39.32)
  BOTTOM w0.079: v1(117.82,83.54) 117.96,83.69 118.09,83.69 U400.BA30
  BOTTOM w0.102: JDIM2801.212 180.82,38.13 181.03,38.35 181.03,39.03 v2(180.75,39.32)
M_B_DQ53: length 93.9
  IN1 w0.127: v1(118.75,84.23) 118.25,83.72 118.25,82.53 118.35,82.43 118.35,81.31 121.12,78.54 121.77,78.54 121.89,78.67 121.89,78.9 122.02,79.02 122.27,79.02 122.4,78.9 122.4,78.67 122.53,78.54 123.36,78.54 123.49,78.67 123.49,78.87 123.62,79 123.87,79 124,78.87 124,78.67 124.13,78.54 125.48,78.54 126.67,77.36 128.24,77.36 130.61,74.99 134.39,74.99 134.56,74.82 134.56,74.58 134.41,74.43 134.06,74.43 133.93,74.3 133.93,74.03 134.06,73.9 134.6,73.9 134.73,73.77 134.73,73.22 135.39,72.56 135.39,71.85 136.81,70.43 136.81,69.42 136.33,68.94 136.33,63.67 154.76,45.24 178.49,45.24 179.79,43.95 179.79,42.74 179.92,42.62 v2(180.45,42.62)
  BOTTOM w0.079: U400.BA29 118.47,84.52 v1(118.75,84.23)
  BOTTOM w0.102: JDIM2801.215 181.57,43.73 v2(180.45,42.62)
M_B_DQ54: length 94.8
  IN1 w0.079: 121.5,82.45 121.34,82.45 121.09,82.7 121.09,84.11 121.01,84.19 v1(120.55,84.19)
  IN1 w0.127: 121.5,82.45 125.84,82.45 127.95,80.35 129.78,80.35 129.95,80.17 129.95,79.69 130.08,79.56 130.36,79.56 130.49,79.69 130.49,79.99 130.59,80.09 130.82,80.09 130.95,79.96 130.95,79.08 131.2,78.82 131.38,78.82 131.55,79 131.55,79.46 131.71,79.61 133.1,79.61 133.36,79.35 133.36,78.03 133.49,77.91 133.87,77.91 133.99,78.03 133.99,78.75 134.09,78.85 134.4,78.85 134.55,78.69 134.55,78.08 134.7,77.93 135.77,77.93 140.01,73.69 140.01,71.99 141.97,70.04 141.97,62.54 156.15,48.35 179.89,48.35 182.09,46.15 182.95,46.15 185.29,43.8 v2(185.29,43.77)
  BOTTOM w0.079: v1(120.55,84.19) 120.08,84.19 119.98,84.29 119.98,84.41 U400.BD29
  BOTTOM w0.102: v2(185.29,43.77) 185.07,43.99 JDIM2801.229
M_B_DQ55: length 94.5
  IN1 w0.127: v1(119.64,84.19) 120.07,83.76 120.07,82.73 121.12,81.69 121.95,81.03 122.13,80.93 122.72,80.83 126.47,80.83 127.71,79.6 128.53,79.6 131.03,77.09 135.56,77.09 138.69,73.97 139.11,72.05 139.36,71.6 139.6,71.35 139.8,71.15 140,71 140.14,70.8 140.24,70.58 140.52,69.39 140.69,68.67 140.86,63.51 140.89,62.53 155.88,47.54 179.62,47.54 181.77,45.39 182.34,45.39 183.8,43.93 183.8,41.91 v2(183.66,40.92)
  BOTTOM w0.079: v1(119.64,84.19) 119.79,84.04 119.92,84.04 U400.BD30
  BOTTOM w0.102: v2(183.66,40.92) 183.96,40.92 184.82,40.06 JDIM2801.228
M_B_DQ56: length 91.8
  IN2 w0.127: v2(186.88,39.55) 186.5,39.55 186.11,39.93 186.11,40.32 183.93,42.5 183.93,43.52 175.61,51.84 175.61,52.57 168.59,59.58 166.82,59.58 165.48,60.91 163.45,60.91 162.97,61.4 157.79,61.4 156.69,62.5 153.84,62.5 152.76,63.57 149.94,63.57 149.7,63.81 147.89,63.81 147.54,64.16 142.62,64.16 141.47,65.31 134.91,65.31 131.68,68.54 131.68,70.62 129.35,72.95 129.35,74.86 127.39,76.81 127.01,76.81 125.15,78.67 125.15,79.15 124.85,79.46 124.16,79.46 121.07,82.55 121.07,83.15 v1(121.46,83.54)
  BOTTOM w0.079: v1(121.46,83.54) 121.62,83.38 121.75,83.38 U400.BG31
  BOTTOM w0.102: JDIM2801.236 186.82,39.49 v2(186.88,39.55)
M_B_DQ57: length 91.4
  IN2 w0.127: v1(121.46,82.89) 121.46,82.49 124.03,79.92 124.73,79.92 125.48,79.16 125.48,78.69 126.96,77.22 127.52,77.22 130.03,74.71 130.03,73.12 131.88,71.28 132.16,71.28 132.75,70.69 132.75,68.74 135.57,65.92 135.95,65.92 136.08,66.05 136.08,66.53 136.2,66.66 136.46,66.66 136.58,66.53 136.58,66.05 136.71,65.92 136.96,65.92 137.09,66.05 137.09,66.56 137.22,66.69 137.47,66.69 137.6,66.56 137.6,66.05 137.73,65.92 141.4,65.92 142.78,64.54 147.7,64.54 148.05,64.19 149.85,64.19 150.09,63.95 152.92,63.95 153.99,62.88 156.85,62.88 157.95,61.78 163.13,61.78 163.61,61.3 165.64,61.3 166.97,59.96 168.75,59.96 170.53,58.18 171.3,58.18 172.09,57.38 172.09,56.62 175.99,52.72 175.99,52 183.56,44.43 185.3,44.43 185.73,43.99 185.73,43.62 v2(186.72,42.63)
  BOTTOM w0.079: v1(121.46,82.89) 121.61,82.74 121.74,82.74 U400.BG32
  BOTTOM w0.102: JDIM2801.237 187.07,44.25 187.14,44.18 187.14,43.04 v2(186.72,42.63)
M_B_DQ58: length 91.6
  IN2 w0.127: v2(189.13,43.84) 189.13,44.06 186.94,46.25 186.94,46.46 185.62,47.78 184.76,47.78 182.25,50.3 180.91,50.3 178.5,52.7 178.5,53.42 174.68,57.24 174.68,58.29 171.96,61 171.16,61 169.89,62.28 167.84,62.28 165.83,64.29 159.71,64.29 158.87,65.12 154.93,65.12 153.63,66.42 151.12,66.42 151.11,66.44 148.98,66.44 148.63,66.79 143.71,66.79 140.88,69.62 140.88,69.88 140.7,70.06 140.47,70.06 140.27,69.86 140.27,69.52 140.14,69.39 139.41,69.39 139.28,69.52 139.28,70.64 139.1,70.82 138.84,70.82 138.71,70.69 138.71,69.41 138.59,69.29 138.35,69.29 138.18,69.45 138.18,70.69 138.06,70.82 137.8,70.82 137.68,70.69 137.68,70.31 137.57,70.21 137.37,70.21 136.68,70.9 136.68,71.08 136.89,71.28 136.89,71.46 136.71,71.64 136.53,71.64 136.33,71.44 136.15,71.44 135.97,71.62 135.97,71.8 136.17,72 136.17,72.18 135.99,72.36 135.81,72.36 135.61,72.16 135.43,72.16 133.45,74.13 133.45,74.53 131.05,76.94 130.95,76.94 128.35,79.53 127.5,79.53 125.14,81.89 124.62,81.89 124.2,82.32 v1(124.2,82.89)
  BOTTOM w0.079: U400.BK32 123.96,82.79 124.09,82.79 v1(124.2,82.89)
  BOTTOM w0.102: v2(189.13,43.84) 189.07,43.91 JDIM2801.245
M_B_DQ59: length 92.2
  IN2 w0.127: v2(189.67,42.79) 189.67,44.07 187.32,46.42 187.32,46.62 185.78,48.16 184.92,48.16 182.41,50.68 181.06,50.68 178.88,52.86 178.88,53.58 175.06,57.4 175.06,58.44 172.12,61.38 171.32,61.38 170.04,62.66 167.99,62.66 165.99,64.67 159.86,64.67 159.03,65.51 155.08,65.51 153.29,67.3 149.21,67.3 149.07,67.17 143.87,67.17 143.19,67.85 143.19,68.03 143.34,68.18 143.34,68.38 143.14,68.58 142.96,68.58 142.8,68.42 142.62,68.42 142.05,68.99 142.05,69.17 142.45,69.58 142.45,69.76 142.23,69.98 142.02,69.98 141.61,69.58 141.46,69.58 141.26,69.78 141.26,69.96 141.66,70.36 141.66,70.55 141.01,71.2 140.78,71.2 140.67,71.1 140.67,70.57 140.55,70.44 140.29,70.44 140.14,70.59 140.14,71.05 139.99,71.2 137.69,71.2 135.98,72.92 135.4,72.92 133.83,74.48 133.83,74.69 131.31,77.22 131.15,77.22 128.51,79.86 127.57,79.86 124.67,82.76 124.67,83.07 v1(124.2,83.54)
  BOTTOM w0.079: v1(124.2,83.54) 124.04,83.39 123.91,83.39 U400.BK31
  BOTTOM w0.102: JDIM2801.249 190.07,44.25 190.13,44.19 190.13,43.25 v2(189.67,42.79)
M_B_DQ60: length 92.8
  IN2 w0.127: v1(121.46,84.84) 121.88,84.43 121.88,82.48 124.21,80.15 125.02,80.15 125.84,79.33 125.84,78.81 127.12,77.53 127.8,77.53 131.5,73.82 131.5,72.68 132.65,71.53 133.16,71.53 133.82,70.87 133.82,68.64 134.4,68.05 134.86,68.05 135.74,67.17 138.44,67.17 138.57,67.04 138.57,66.43 138.7,66.3 138.95,66.3 139.08,66.43 139.08,67.04 139.21,67.17 139.46,67.17 139.59,67.04 139.59,66.43 139.71,66.3 139.97,66.3 140.1,66.43 140.1,67.04 140.22,67.17 140.69,67.17 142.94,64.92 147.86,64.92 148.21,64.57 150.01,64.57 150.25,64.33 153.08,64.33 154.15,63.26 158.09,63.26 158.93,62.42 165.06,62.42 167.13,60.34 168.91,60.34 170.69,58.56 171.46,58.56 172.66,57.35 172.66,56.58 176.37,52.88 176.37,52.16 183.64,44.89 185.56,44.89 186.22,44.23 186.22,43.76 v2(186.71,43.26)
  BOTTOM w0.079: v1(121.46,84.84) 121.65,84.66 121.78,84.66 U400.BG29
  BOTTOM w0.102: v2(186.71,43.26) 186.07,43.91 JDIM2801.233
M_B_DQ61: length 92.3
  IN2 w0.079: v1(121.46,84.19) 120.86,83.59 120.86,82.4
  IN2 w0.127: 120.86,82.4 120.86,82.3 124.18,78.99 124.18,78.76 124.52,78.42 124.98,78.42 127.14,76.26 127.37,76.26 128.71,74.92 128.71,72.51 130.39,70.83 130.39,70.58 130.78,70.18 130.78,68.65 134.66,64.78 141.47,64.78 142.46,63.78 147.38,63.78 147.73,63.43 149.54,63.43 149.78,63.19 152.61,63.19 153.68,62.11 155.95,62.11 157.56,60.5 165.36,60.5 166.66,59.2 168.43,59.2 170.71,56.92 170.71,56.91 173.3,54.32 173.3,53.93 175.07,52.17 175.07,51.84 183.55,43.36 183.55,42.14 184.49,41.2 184.49,39.88 184.67,39.7 v2(185.45,39.7)
  BOTTOM w0.079: U400.BG30 121.77,84.01 121.64,84.01 v1(121.46,84.19)
  BOTTOM w0.102: v2(185.45,39.7) 185.82,39.34 JDIM2801.232
M_B_DQ62: length 93.5
  IN2 w0.127: v1(124.2,84.19) 125.08,83.31 125.08,82.71 127.57,80.22 128.53,80.22 131.05,77.7 131.36,77.7 134.01,75.05 134.34,75.05 135.13,74.65 135.25,74.53 135.77,73.66 137.85,71.58 141.17,71.58 143.05,69.7 143.53,69.7 145.68,67.55 148.89,67.55 149.02,67.68 153.45,67.68 155.24,65.89 159.18,65.89 160.02,65.05 166.14,65.05 168.15,63.04 170.2,63.04 171.48,61.77 172.28,61.77 175.44,58.6 175.44,57.56 179.26,53.74 179.26,53.02 181.16,51.12 182.51,51.12 185.08,48.54 187.73,48.54 189.14,47.13 189.14,45.14 190.11,44.18 190.11,39.53 189.52,38.95 v2(189.52,38.94)
  BOTTOM w0.079: v1(124.2,84.19) 124.02,84.02 123.89,84.02 U400.BK30
  BOTTOM w0.102: v2(189.52,38.94) 190.32,38.15 JDIM2801.250
M_B_DQ63: length 93.9
  IN2 w0.127: v2(188.78,40.29) 188.78,41.76 188.5,42.04 188.5,42.77 188.64,42.91 188.64,44.01 186.56,46.09 186.56,46.31 185.47,47.4 183.26,47.4 178.12,52.54 178.12,53.26 174.3,57.09 174.3,58.13 171.8,60.62 171,60.62 169.73,61.9 167.68,61.9 165.67,63.91 159.55,63.91 158.71,64.74 154.77,64.74 153.47,66.04 150.96,66.04 150.95,66.06 148.83,66.06 148.47,66.41 143.55,66.41 141.06,68.91 138.05,68.91 137.52,69.44 137.34,69.44 136.94,69.05 136.74,69.05 136.54,69.25 136.54,69.43 136.94,69.83 136.94,70.02 133.07,73.88 133.07,74.38 128.27,79.18 127.41,79.18 125.63,80.95 124.95,80.95 123.76,82.15 123.76,84.07 123.63,84.19 v1(123.29,84.19)
  BOTTOM w0.079: U400.BK29 123.56,84.34 123.43,84.34 v1(123.29,84.19)
  BOTTOM w0.102: v2(188.78,40.29) 189.11,39.96 189.11,38.16 189.19,38.08 189.32,37.96 JDIM2801.246
M_B_DQSN0: length 52.4
  IN1 w0.114: v2(128.21,42.68) 128.48,42.96 128.48,43.19 128.71,43.41 128.71,43.63 113.83,58.51 113.83,61.46 113.36,61.93 112.93,61.93 112.68,62.18 112.68,62.75 112.96,63.02 113.09,63.02 113.2,63.14 113.2,63.32 112.68,63.84 112.68,70.31 113.88,71.51 114.24,71.51 114.47,71.73 114.47,72.04 114.32,72.19 114.03,72.19 113.8,72.42 113.8,73.65 114.05,73.89 114.51,73.89 114.62,74.01 v1(114.62,74.17)
  BOTTOM w0.079: U400.AP35 113.93,80.78 113.88,80.83 113.81,80.83 113.74,80.77 113.67,80.65 113.67,80.45 113.71,80.36 113.71,80.12 113.68,80.03 113.68,79.81 113.71,79.73 113.71,79.2 113.98,78.93 113.98,76.36 114.08,76.26 114.08,75.6 114.09,75.59 114.09,75.57
  BOTTOM w0.097: 114.09,75.57 114.09,73.96 114.19,73.86 114.32,73.86 114.62,74.16 v1(114.62,74.17) ; JDIM2801.11 128.57,44.33 128.74,44.16 128.74,43.87 129.03,43.58 129.03,43.44 128.9,43.31 128.72,43.31 128.51,43.1 128.51,42.99 v2(128.21,42.68)
M_B_DQSN1: length 85.3
  IN2 w0.114: v2(171.68,43.02) 172,43.34 172,44.9 165.13,51.77 163.41,51.77 163.18,52 160.76,52 160.18,52.58 154.29,52.58 152.89,53.98 149.02,53.98 147.22,55.78 136.07,55.78 134.12,57.73 131.17,57.73 125.33,63.57 125.17,63.57 124.78,63.18 124.43,63.18 124,63.6 124,63.95 124.4,64.34 124.4,64.51 124.11,64.79 123.94,64.79 123.55,64.4 123.2,64.4 122.78,64.82 122.78,67.43 121.62,68.59 119.82,68.59 117.1,71.3 117.1,73.16 117.36,73.41 117.71,73.41 v1(117.9,73.6)
  BOTTOM w0.079: 117.15,74.91 117.15,74.93 117.14,74.94 117.14,77.91 116.85,78.21 116.85,79.7 116.87,79.79 116.87,80.06 116.83,80.16 116.83,80.3 116.87,80.38 116.87,80.71 116.82,80.84 116.68,80.98 116.5,80.98 116.45,81.02 U400.AV34
  BOTTOM w0.097: 117.15,74.91 117.15,73.56 117.36,73.36 117.66,73.36 v1(117.9,73.6) ; v2(171.68,43.02) 172,43.33 172,44.18 172.07,44.25 JDIM2801.177
M_B_DQSN2: length 58.5
  IN1 w0.079: 111.81,81.34 111.81,81.35 111.83,81.36 111.83,82.58 111.8,82.61 111.8,83.07 111.72,83.16 111.52,83.16 111.44,83.08 v1(111.44,82.92)
  IN1 w0.114: 111.81,81.34 111.81,81.15 112.44,80.52 113.17,80.52 113.67,80.03 115.31,80.03 116.56,78.78 116.56,78.42 117.09,77.88 117.09,74.55 117.2,74.43 117.2,71.42 117.75,70.87 117.75,69.66 117.49,69.4 117.49,65.33 119.12,63.7 119.12,61.58 119.83,60.87 119.83,58.75 133.56,45.01 133.56,41.69 134.02,41.23 134.02,39.74 133.9,39.63 v2(133.71,39.63)
  BOTTOM w0.079: U400.AL31 111.76,83.09 111.6,83.09 v1(111.44,82.92)
  BOTTOM w0.097: JDIM2801.32 133.82,37.95 133.97,38.11 133.97,39.36 133.71,39.63 v2(133.71,39.63)
M_B_DQSN3: length 92.5
  IN2 w0.079: v1(115.08,82.89) 115.2,82.89 115.28,82.81 115.28,81.78 115.61,81.46 115.61,81.42 115.62,81.4
  IN2 w0.114: 115.62,81.4 116.83,80.19 118.85,80.19 122.92,76.13 122.92,73.7 127.44,69.18 127.44,68.02 133.32,62.14 140.32,62.14 142.17,60.28 148.95,60.28 150.8,58.44 155.12,58.44 155.72,57.84 162.09,57.84 162.94,56.98 165.15,56.98 165.66,56.47 166.69,56.47 177.27,45.88 177.27,42.51 177.64,42.15 177.64,41.83 177.45,41.64 176.93,41.64 176.63,41.34 176.63,40.77 176.88,40.52 177.63,40.52 177.79,40.37 177.79,39.88 177.55,39.65 177.55,39.06 177.41,38.92 v2(177.21,38.92)
  BOTTOM w0.079: U400.AU31 115.23,83.22 115.08,83.07 v1(115.08,82.89)
  BOTTOM w0.097: v2(177.21,38.92) 177.44,38.92 177.6,38.76 177.6,38.1 177.55,38.05 177.4,38.05 177.32,37.97 JDIM2801.198
M_B_DQSN4: length 53.3
  IN1 w0.114: v2(139.43,42.37) 139.64,42.58 139.83,42.58 140.29,43.04 140.29,44.84 134.55,50.58 134.55,52.05 129.84,56.76 129.1,56.76 127.54,58.32 127.54,59.06 126.37,60.23 126.37,60.96 125.46,61.87 125.46,68.65 121.85,72.26 121.85,75.39 121.48,75.77 120.52,75.77 v1(120.39,75.9)
  BOTTOM w0.079: U400.BB35 118.97,80.79 118.93,80.83 118.84,80.83 118.77,80.77 118.7,80.65 118.7,80.45 118.74,80.36 118.74,80.12 118.71,80.01 118.71,79.82 118.74,79.72 118.74,78.25 119.27,77.72 119.27,76.04 119.59,75.73 120.22,75.73 v1(120.39,75.9)
  BOTTOM w0.097: JDIM2801.53 139.06,44.02 138.8,43.76 138.8,42.84 139.01,42.62 139.18,42.62 v2(139.43,42.37)
M_B_DQSN5: length 57.2
  IN1 w0.114: v2(144.16,39.65) 144.51,40 144.51,41.15 144.92,41.56 144.92,48.57 136.38,57.1 136.38,57.89 133.71,60.56 133.71,61.2 130.67,64.25 130.67,70.11 130.11,70.66 130.11,71 129.25,71.86 129.25,72.42 127.65,74.02 125.19,74.02 124.8,74.41 124.8,75.01 125.11,75.32 v1(125.11,75.51)
  BOTTOM w0.079: 123.99,75.95 123.99,75.97 123.99,75.98 123.99,76.38 121.94,78.42 121.94,79.1 121.88,79.16 121.88,79.7 121.92,79.84 121.92,80.02 121.86,80.18 121.86,80.28 121.91,80.38 121.91,80.71 121.85,80.83 121.71,80.97 121.52,80.97 121.48,81.01 U400.BF34
  BOTTOM w0.097: v2(144.16,39.65) 144.43,39.38 144.43,38.08 144.32,37.96 JDIM2801.74 ; v1(125.11,75.51) 125.11,75.35 124.9,75.14 124.44,75.14 123.99,75.59 123.99,75.95
M_B_DQSN6: length 93.8
  IN1 w0.079: v1(118.73,83.54) 119.06,83.54 119.16,83.44 119.19,83.42 119.19,83.2 119.07,83.08 119.07,82.58 119.03,82.54 119.03,82.53
  IN1 w0.114: 119.03,82.53 119.03,81.57 120.81,79.79 126.25,79.79 126.86,79.18 126.86,78.52 127.32,78.06 128.67,78.06 130.77,75.95 134.98,75.95 137.02,73.92 137.02,72.01 138.31,70.72 138.31,63.12 155.18,46.25 179.04,46.25 181.14,44.15 181.83,44.15 182.56,43.42 182.56,42.55 182.38,42.37 182.19,42.37 182.05,42.51 v2(182.05,42.7)
  BOTTOM w0.079: v1(118.73,83.54) 119.11,83.54 119.18,83.47 U400.BC31
  BOTTOM w0.097: v2(182.05,42.7) 182.05,42.49 182.15,42.4 182.43,42.4 182.75,42.72 182.75,44.11 182.57,44.3 JDIM2801.219
M_B_DQSN7: length 92.2
  IN2 w0.114: v1(122.37,83.54) 122.69,83.23 122.69,82.23 124.54,80.37 125.26,80.37 126.13,79.51 126.38,79.51 126.78,79.11 126.78,78.5 127.32,77.96 128.28,77.96 132.22,74.02 132.22,73.49 135.57,70.13 135.57,69.01 136.78,67.8 140.95,67.8 143.2,65.55 148.12,65.55 148.47,65.2 150.27,65.2 150.51,64.96 153.34,64.96 154.41,63.89 158.35,63.89 159.19,63.05 165.32,63.05 167.32,61.04 169.15,61.04 171,59.19 171.72,59.19 173.44,57.47 173.44,56.73 177.26,52.91 177.26,52.19 183.94,45.52 185.82,45.52 187.36,43.97 187.36,41.39 187.92,40.83 187.92,39.87 v2(187.63,39.58)
  BOTTOM w0.079: U400.BH31 122.68,83.37 122.54,83.37 v1(122.37,83.54)
  BOTTOM w0.097: JDIM2801.240 187.82,37.99 187.96,38.13 187.96,39.25 v2(187.63,39.58)
M_B_DQSN8: length 6
  TOP w0.102: v2(148.47,42.37) 149.03,42.93 149.03,44.4 R2838.2
  BOTTOM w0.102: v2(148.47,42.37) 149.35,43.25 149.35,43.99 149.57,44.2 JDIM2801.95
M_B_DQSP0: length 52.5
  IN1 w0.114: v1(114.62,73.4) 114.62,73.55 114.51,73.67 114.14,73.67 114.03,73.55 114.03,72.52 114.12,72.42 114.41,72.42 114.69,72.14 114.69,71.64 114.33,71.28 113.98,71.28 112.91,70.21 112.91,63.93 113.43,63.41 113.43,63.04 113.18,62.79 113.05,62.79 112.91,62.65 112.91,62.27 113.03,62.16 113.45,62.16 114.06,61.55 114.06,58.6 128.94,43.72 128.94,43.32 128.71,43.09 128.71,42.94 v2(128.97,42.68)
  BOTTOM w0.079: U400.AP34 113.93,81.05 113.89,81 113.74,81 113.61,80.87 113.5,80.69 113.5,80.41 113.54,80.32 113.54,80.15 113.51,80.05 113.51,79.78 113.54,79.7 113.54,79.13 113.81,78.86 113.81,76.29 113.91,76.19 113.91,75.6 113.9,75.59 113.9,75.57
  BOTTOM w0.097: 113.9,75.57 113.9,73.88 114.11,73.68 114.34,73.68 v1(114.62,73.4) ; v2(128.97,42.68) 128.71,42.94 128.71,43.02 128.81,43.11 128.98,43.11 129.23,43.36 129.23,43.66 128.93,43.95 128.93,44.17 129.07,44.3 JDIM2801.13
M_B_DQSP1: length 85.3
  IN2 w0.114: v2(172.44,43.02) 172.23,43.23 172.23,45 165.23,52 163.51,52 163.28,52.23 160.85,52.23 160.28,52.81 154.39,52.81 152.99,54.21 149.12,54.21 147.31,56.01 136.16,56.01 134.21,57.96 131.26,57.96 125.43,63.8 125.07,63.8 124.68,63.41 124.52,63.41 124.23,63.7 124.23,63.86 124.62,64.25 124.62,64.6 124.2,65.02 123.85,65.02 123.46,64.63 123.3,64.63 123.01,64.92 123.01,67.52 121.72,68.81 119.91,68.81 117.33,71.4 117.33,73.06 117.45,73.18 117.79,73.18 117.9,73.07 v1(117.9,72.96)
  BOTTOM w0.079: 116.97,74.91 116.97,74.93 116.98,74.94 116.98,77.84 116.68,78.14 116.68,79.73 116.71,79.82 116.71,80.03 116.66,80.13 116.66,80.34 116.71,80.42 116.71,80.68 116.68,80.74 116.61,80.81 116.5,80.81 116.45,80.76 U400.AV35
  BOTTOM w0.097: 116.97,74.91 116.97,73.49 117.28,73.18 117.69,73.18 v1(117.9,72.96) ; v2(172.44,43.02) 172.29,43.02 172.19,43.11 172.19,44.1 172.3,44.2 172.47,44.2 172.57,44.3 JDIM2801.179
M_B_DQSP2: length 58.5
  IN1 w0.079: v1(111.44,83.54) 111.66,83.32 111.79,83.32 111.97,83.14 111.97,82.68 112,82.65 112,81.39 112.04,81.35 112.04,81.34
  IN1 w0.114: 112.04,81.34 112.04,81.25 112.54,80.75 113.27,80.75 113.76,80.26 115.41,80.26 116.78,78.88 116.78,78.51 117.32,77.98 117.32,74.64 117.43,74.53 117.43,71.51 117.98,70.97 117.98,69.56 117.72,69.3 117.72,65.42 119.34,63.8 119.34,61.68 120.06,60.97 120.06,58.84 133.79,45.11 133.79,41.78 134.25,41.32 134.25,39.85 v2(134.47,39.63)
  BOTTOM w0.079: v1(111.44,83.54) 111.61,83.72 111.75,83.72 U400.AL30
  BOTTOM w0.097: v2(134.47,39.63) 134.17,39.33 134.17,38.11 134.32,37.96 JDIM2801.34
M_B_DQSP3: length 92.4
  IN2 w0.079: v1(115.08,83.54) 115.45,83.18 115.45,81.85 115.72,81.58 115.77,81.58 115.78,81.56
  IN2 w0.114: 115.78,81.56 116.92,80.42 118.95,80.42 123.15,76.22 123.15,73.79 127.67,69.27 127.67,68.11 133.41,62.37 140.41,62.37 142.27,60.51 149.05,60.51 150.89,58.67 155.21,58.67 155.81,58.07 162.18,58.07 163.04,57.21 165.24,57.21 165.75,56.7 166.78,56.7 177.5,45.98 177.5,42.6 177.87,42.24 177.87,41.74 177.54,41.41 177.02,41.41 176.86,41.25 176.86,40.86 176.97,40.75 177.73,40.75 178.02,40.46 178.02,39.79 177.78,39.55 177.78,39.11 v2(177.97,38.92)
  BOTTOM w0.079: v1(115.08,83.54) 115.24,83.7 115.37,83.7 U400.AU30
  BOTTOM w0.097: v2(177.97,38.92) 177.8,38.75 177.8,37.98 177.82,37.97 JDIM2801.200
M_B_DQSP4: length 53.3
  IN1 w0.114: v2(139.43,43.13) 139.43,42.92 139.55,42.8 139.73,42.8 140.06,43.13 140.06,44.75 134.33,50.48 134.33,51.95 129.74,56.53 129,56.53 127.31,58.22 127.31,58.96 126.14,60.13 126.14,60.86 125.23,61.78 125.23,68.56 121.62,72.17 121.62,75.3 121.38,75.54 120.54,75.54 120.38,75.39 v1(120.38,75.31)
  BOTTOM w0.079: U400.BB34 118.97,81.05 118.92,81 118.77,81 118.64,80.87 118.54,80.69 118.54,80.41 118.57,80.32 118.57,80.15 118.54,80.04 118.54,79.79 118.58,79.69 118.58,78.18 119.1,77.65 119.1,75.97 119.52,75.56 120.27,75.56 120.38,75.45 v1(120.38,75.31)
  BOTTOM w0.097: v2(139.43,43.13) 139.43,42.94 139.32,42.82 139.09,42.82 139,42.92 139,43.67 139.26,43.94 139.26,44.02 139.57,44.32 JDIM2801.55
M_B_DQSP5: length 57.2
  IN1 w0.114: v2(144.92,39.65) 144.74,39.83 144.74,41.06 145.14,41.46 145.14,48.66 136.61,57.2 136.61,57.99 133.94,60.66 133.94,61.3 130.89,64.34 130.89,70.2 130.34,70.76 130.34,71.1 129.48,71.95 129.48,72.51 127.74,74.25 125.28,74.25 125.03,74.5 125.03,74.92 125.18,75.06 v1(125.49,75.06)
  BOTTOM w0.079: U400.BF35 121.48,80.76 121.52,80.8 121.64,80.8 121.71,80.73 121.74,80.67 121.74,80.42 121.69,80.32 121.69,80.15 121.75,79.99 121.75,79.86 121.71,79.73 121.71,79.09 121.77,79.03 121.77,78.35 123.82,76.31 123.82,75.98 123.81,75.97 123.81,75.95
  BOTTOM w0.097: 123.81,75.95 123.81,75.51 124.37,74.95 124.98,74.95 125.13,75.11 125.44,75.11 v1(125.49,75.06) ; v2(144.92,39.65) 144.63,39.36 144.63,38.16 144.82,37.98 JDIM2801.76
M_B_DQSP6: length 93.8
  IN1 w0.079: 119.26,82.53 119.26,82.54 119.24,82.56 119.24,83.01 119.35,83.13 119.35,83.26 v1(119.64,83.54)
  IN1 w0.114: 119.26,82.53 119.26,81.66 120.91,80.02 126.35,80.02 127.08,79.28 127.08,78.62 127.41,78.29 128.76,78.29 130.87,76.18 135.08,76.18 137.24,74.01 137.24,72.11 138.54,70.81 138.54,63.21 155.27,46.48 179.14,46.48 181.24,44.38 181.92,44.38 182.79,43.52 182.79,42.46 182.48,42.14 182.26,42.14 v2(182.05,41.94)
  BOTTOM w0.079: U400.BC30 119.32,83.73 119.45,83.73 v1(119.64,83.54)
  BOTTOM w0.097: JDIM2801.221 183.07,44.28 182.95,44.16 182.95,42.63 182.51,42.2 182.31,42.2 v2(182.05,41.94)
M_B_DQSP7: length 92.2
  IN2 w0.114: v2(188.41,39.58) 188.15,39.84 188.15,40.92 187.59,41.48 187.59,44.07 185.91,45.74 184.03,45.74 177.49,52.28 177.49,53 173.67,56.83 173.67,57.56 171.81,59.42 171.1,59.42 169.24,61.27 167.42,61.27 165.41,63.28 159.29,63.28 158.45,64.11 154.51,64.11 153.44,65.19 150.61,65.19 150.37,65.43 148.56,65.43 148.21,65.78 143.29,65.78 141.04,68.03 136.87,68.03 135.8,69.1 135.8,70.23 132.44,73.58 132.44,74.12 128.37,78.19 127.42,78.19 127.01,78.59 127.01,79.2 126.47,79.74 126.22,79.74 125.36,80.6 124.64,80.6 122.92,82.32 122.92,83.18 v1(123.29,83.54)
  BOTTOM w0.079: U400.BH30 122.96,83.74 123.09,83.74 v1(123.29,83.54)
  BOTTOM w0.097: v2(188.41,39.58) 188.16,39.34 188.16,38.12 188.32,37.96 JDIM2801.242
M_B_DQSP8: length 5.8
  TOP w0.102: R2832.2 149.84,43.7 149.79,43.65 v2(149.79,43.15) 149.79,42.8 v2(149.33,42.35)
  BOTTOM w0.102: v2(149.33,42.35) 149.79,42.8 149.79,43.69 150.07,43.97 JDIM2801.97
M_B_ODT0: length 93.7
  IN2 w0.079: 113.35,71.84 113.35,74.82 113.04,75.13 v1(112.26,75.13)
  IN2 w0.165: 113.35,71.84 113.35,69.9 116.17,67.08 116.17,64.81 118.7,62.28 118.7,62.05 118.48,61.83 118.48,61.62 118.65,61.46 118.88,61.46 119.1,61.68 119.31,61.68 119.45,61.53 119.45,61.33 119.1,60.98 119.1,60.74 119.27,60.58 119.5,60.58 120.55,61.63 120.76,61.63 121.17,61.23 121.17,61.05 121,60.89 120.51,60.89 119.83,60.21 119.83,59.97 119.99,59.81 120.23,59.81 120.79,60.37 121.02,60.37 121.19,60.2 121.19,59.95 120.64,59.39 120.64,59.16 120.88,58.92 121.08,58.92 121.73,59.57 122.09,59.57 122.23,59.43 122.23,59.22 121.51,58.5 121.51,58.29 125.83,53.97 132.48,53.97 134.67,51.79 145.6,51.79 147.17,50.22 151.29,50.22 152.66,48.84 157.76,48.84 158.78,47.82 163.84,47.82 167.27,44.4 167.27,42.82 v2(167.14,42.69)
  BOTTOM w0.079: U400.AL36 112.22,80.07 112.22,79.97 112.32,79.65 112.32,78.88 112.41,78.79 112.41,78.28 112.89,77.8 112.89,76.69 112.86,76.66 112.86,76.55
  BOTTOM w0.127: 112.86,76.55 112.86,76.23 112.64,76.02 112.64,75.78 112.86,75.56 112.86,75.31 112.69,75.13 v1(112.26,75.13) ; v2(167.14,42.69) 167.03,42.81 166.69,42.81 166.35,42.47 166.15,42.47 166,42.63 166,42.86 166.36,43.21 166.36,44.04 166.57,44.25 JDIM2801.155
M_B_ODT1: length 92.9
  IN2 w0.079: 114.36,71.76 114.36,71.96 113.93,72.4 113.93,76.64 113.65,76.91 v1(112.26,76.91)
  IN2 w0.165: v2(168.26,43.71) 168.26,44.59 164.19,48.66 159.18,48.66 158.16,49.67 153.01,49.67 151.63,51.05 147.52,51.05 145.76,52.81 134.93,52.81 132.93,54.81 126.66,54.81 126.5,54.97 126.5,55.2 127.3,55.99 127.3,56.23 127.13,56.39 126.9,56.39 125.87,55.36 125.66,55.36 125.52,55.51 125.52,55.71 126.53,56.72 126.53,56.92 126.38,57.07 126.18,57.07 125.17,56.06 124.96,56.06 124.82,56.21 124.82,56.41 125.67,57.27 125.67,57.47 125.53,57.62 125.32,57.62 124.47,56.76 124.26,56.76 124.12,56.91 124.12,57.11 124.82,57.82 124.82,58.02 122.79,60.05 122.79,60.79 120.73,62.85 119.32,62.85 117.01,65.16 117.01,67.33 114.36,69.98 114.36,71.76
  BOTTOM w0.079: v1(112.26,76.91) 112.48,76.91 112.56,76.99 112.56,77.66 112.08,78.14 112.08,78.65 111.81,78.91 111.81,79.7 111.84,79.77 111.84,80.05 111.81,80.13 111.81,80.35 111.84,80.43 111.84,80.67 111.81,80.75 111.81,81.27 U400.AL34
  BOTTOM w0.127: JDIM2801.161 168.07,44.23 167.88,44.04 167.88,43.84 168,43.71 v2(168.26,43.71)
M_B_PARITY: length 92.1
  IN2 w0.079: 108.39,72.29 108.39,72.5 v1(108.77,72.88)
  IN2 w0.165: 108.39,72.29 108.39,66.71 108.95,63.51 109.09,62.68 109.2,62.21 109.3,61.94 110.28,60.12 116.46,53.94 116.46,53.73 116.25,53.52 116.25,53.31 116.39,53.17 116.6,53.17 116.81,53.38 117.02,53.38 117.16,53.24 117.16,53.03 116.95,52.82 116.95,52.61 117.09,52.47 117.3,52.47 117.51,52.68 117.72,52.68 117.86,52.54 117.86,52.33 117.65,52.12 117.65,51.91 117.79,51.77 118,51.77 118.21,51.98 118.42,51.98 120.29,50.11 120.29,49.91 120.07,49.69 120.07,49.49 120.22,49.34 120.42,49.34 120.64,49.56 120.84,49.56 120.99,49.41 120.99,49.21 120.77,48.99 120.77,48.79 120.92,48.64 121.12,48.64 121.34,48.86 121.54,48.86 121.69,48.71 121.69,48.51 121.47,48.29 121.47,48.08 121.62,47.94 121.82,47.94 122.04,48.16 122.24,48.16 122.39,48.01 122.39,47.8 122.17,47.59 122.17,47.38 122.32,47.24 122.52,47.24 122.74,47.45 122.98,47.45 125.23,45.2 130.96,45.2 132.51,43.65 133.28,43.65 133.59,43.34 133.59,42.16 133.89,41.86 151.41,41.86 151.54,41.99 152.54,41.99 152.87,41.65 155.06,41.65 155.53,41.18 159.04,41.18 159.11,41.1 v2(159.9,41.1)
  BOTTOM w0.079: U400.AE34 109.03,81.52 109.18,81.38 109.18,80.86 109.15,80.84 109.15,80.48 109.13,80.36 109.13,80.11 109.15,80.01 109.15,79.79 109.13,79.7 109.13,79.1 109.2,79.03 109.2,78.77
  BOTTOM w0.127: JDIM2801.143 161.57,44.18 161.35,42.38 161.33,42.11 161.23,41.91 160.96,41.64 160.32,41.32 v2(159.9,41.1) ; 109.2,78.77 109.2,73.31 v1(108.77,72.88)
M_B_RAS#: length 94.2
  IN2 w0.079: 113.25,67.44 113.25,67.46 111.74,68.97 111.74,75.98 110.92,76.8 v1(110.62,76.8)
  IN2 w0.165: v2(165.63,38.36) 165.41,38.13 165.41,37.71 165.53,37.59 166.26,37.59 166.38,37.47 166.38,37.29 166.26,37.17 165.53,37.17 165.41,37.05 165.41,35.54 165.23,35.36 165.03,35.36 164.85,35.54 164.85,41.75 164.78,41.81 164.78,43.84 162.9,45.73 157.91,45.73 156.89,46.74 151.67,46.74 150.29,48.12 142.43,48.12 140.85,49.69 127.14,49.69 114.95,61.89 114.95,62.75 114.25,63.44 114.24,63.51 113.25,67.44
  BOTTOM w0.079: v1(110.62,76.8) 111.02,77.2 111.02,77.49 110.51,78 110.51,79.19 110.34,79.36 110.34,79.69 110.44,79.94 110.44,80.98 110.77,81.3 U400.AJ34
  BOTTOM w0.127: JDIM2801.152 165.82,37.93 165.63,38.11 v2(165.63,38.36)
M_B_WE#: length 95
  IN2 w0.079: 113.79,67.24 111.95,69.09 111.95,72.62 112.06,72.74 v1(112.31,72.74)
  IN2 w0.165: 113.79,67.24 114.03,66.22 114.52,64.09 115.74,62.87 115.74,62.67 115.37,62.29 115.37,62.06 115.53,61.9 115.7,61.9 116.12,62.32 116.29,62.32 116.48,62.13 116.48,61.92 116.11,61.55 116.11,61.32 116.23,61.19 116.44,61.19 116.54,61.3 116.67,61.3 116.8,61.16 116.8,60.62 127.32,50.11 141.36,50.11 141.53,49.95 141.53,49.61 141.65,49.49 141.9,49.49 142.02,49.61 142.02,49.95 142.19,50.11 142.42,50.11 142.54,49.99 142.54,48.75 142.69,48.6 142.92,48.6 143.04,48.72 143.04,49.99 143.16,50.11 143.42,50.11 143.57,49.96 143.57,48.7 143.73,48.54 143.97,48.54 144.08,48.65 144.08,49.96 144.23,50.11 144.46,50.11 144.59,49.99 144.59,48.7 144.75,48.54 144.93,48.54 145.09,48.7 145.09,49.43 145.22,49.56 145.45,49.56 145.62,49.4 145.62,48.7 145.78,48.54 150.54,48.54 151.92,47.16 157.07,47.16 158.08,46.15 163.14,46.15 165.31,43.98 v2(165.31,43.85)
  BOTTOM w0.079: 111.49,76.13 111.49,76.48 111.55,76.55 111.55,77.68 111.01,78.22 111.01,79.42 111.02,79.43 111.02,79.69 110.99,79.75 110.99,80.01 111.02,80.09 111.02,80.62 U400.AJ35
  BOTTOM w0.127: v2(165.31,43.85) 165.62,43.85 165.71,43.93 165.71,44.11 165.57,44.25 JDIM2801.151 ; v1(112.31,72.74) 112.31,72.64 111.72,72.04 111.54,72.04 111.34,72.24 111.34,72.6 111.47,72.74 111.84,72.74 111.95,72.85 111.95,73.01 111.84,73.12 111.4,73.12 111.29,73.23 111.29,73.39 111.4,73.5 111.86,73.5 111.98,73.61 111.98,73.77 111.86,73.88 111.46,73.88 111.29,74.06 111.29,75.19 111.49,75.39 111.49,76.13
MAIN_BAT_DET#: length 162.1
  TOP w0.102: C4721.1 v2(211.44,45.98) R4765.2 ; v2(93.81,30.34) 94.35,29.79 PR8515.1
  IN1 w0.114: v2(93.81,30.34) 93.81,30.34 97.53,30.34 98.18,29.69 102.59,29.69 104.22,28.06 110.95,28.06 112.19,26.82 115.83,26.82 117.48,25.17 121.57,25.17 123.54,23.2 123.54,22.97 127.76,18.75 v2(130.3,18.75) 131.15,19.6 132.24,19.6 133.8,18.04 133.8,16.87 135.97,14.7 136.55,14.7 137.07,14.18 137.07,13.21 138.21,12.07 143.39,12.07 147.17,8.28 149.63,8.28 150.66,7.26 155.7,7.26 158.81,10.37 162.82,10.37 164.32,11.87 173.72,11.87 174.2,12.35 185.38,12.35 187.53,10.21 191,10.21 191.82,11.03 194.37,11.03 196.09,12.75 197.44,12.75 198.74,14.04 198.74,16.08 203.93,21.28 203.93,32.71 208.12,36.9 208.12,40.71 209.96,42.55 209.96,45.11 210.83,45.98 v2(211.44,45.98)
  BOTTOM w0.102: PR8222.1 130.67,19.12 v2(130.3,18.75)
MDI0+: length 17.5
  TOP w0.097: v2(200.35,66.25) 200.15,66.45 200.09,66.45 199.94,66.31 199.94,65.84 199.6,65.49 198.88,65.49 198.79,65.59 198.15,65.59 197.97,65.77 197.73,65.77 197.67,65.71 U4000.1
  BOTTOM w0.097: U4001.2 211.14,66.17 210.78,66.53 210.52,66.53 208.67,68.38 205.36,68.38 205.23,68.25 203.35,68.25 201.6,66.5 200.6,66.5 v2(200.35,66.25)
