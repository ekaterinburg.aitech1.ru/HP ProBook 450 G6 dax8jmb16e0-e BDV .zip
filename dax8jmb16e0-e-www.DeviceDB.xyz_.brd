# Allegro board dax8jmb16e0-e-www.DeviceDB.xyz_.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CLKIN_XTAL_LCP: length 19.4
  BOTTOM w0.079: U400.CM3 136.85,101.24 138.46,101.24 138.63,101.4 138.94,101.4 139.17,101.17 141.67,101.17 142.01,100.84 143.04,100.84 144.03,99.85
  BOTTOM w0.102: 144.03,99.85 144.7,99.18 146.84,99.18 146.96,99.07 v2(149.94,99.07) 150.2,99.33 150.88,99.33 150.94,99.26 152.12,99.26 C423.2 153.14,98.86 153.24,98.76 R588.2 154.13,98.41 L400.2
CLKIN_XTAL_LCP_R: length 28.7
  IN2 w0.114: v2(158.86,93.93) 159.04,93.93 159.88,93.1 162.25,93.1 162.8,93.64 168.33,93.64 168.44,93.53 175.22,93.53 v2(175.48,93.79)
  BOTTOM w0.102: v2(158.86,93.93) 158.16,93.93 156.14,95.95 156.14,96.56 L400.1 ; CN4100.64 176.45,91.46 176.69,91.7 177.1,91.7 177.43,92.03 177.43,92.94 176.59,93.78 175.49,93.78 v2(175.48,93.79)
CLKRUN#: length 253.5
  TOP w0.102: v2(159.52,52.13) 156.84,52.13 154.7,49.99 142.86,49.99 142.16,49.29 118.4,49.29 117.35,50.34 104.77,50.34 103.32,51.78 59.9,51.78 58.28,53.4 v2(55.83,53.4)
  IN1 w0.114: v2(159.52,52.13) 159.08,52.13 152.49,58.71 152.49,62.47 149.84,65.13 149.84,65.16 148.6,66.4 148.6,67.42 148.76,67.58 148.76,68.19 148.28,68.67 147.07,68.67 146.88,68.87 146.61,68.87 145.83,69.65 145.83,71.63 145.28,72.19 144.11,72.19 142.47,73.82 141.42,73.82 136.76,78.49 136.76,78.88 136.11,79.53 135.15,79.53 133.86,80.82 132.09,80.82 131.58,81.33 131.58,82.23 131.07,82.73 131.07,83.19 130.56,83.7 v1(130.56,83.7)
  IN2 w0.114: v2(55.83,53.4) 55.1,54.14 55.1,56.19 54.85,56.44 54.85,58.98 58.75,62.89 58.75,63.95 59.52,64.72 59.52,65.06 63.66,69.19 v2(63.85,69.19)
  BOTTOM w0.102: R630.2 63.14,127.61 62.67,128.08 58.33,128.08 57.98,127.73 57.98,125.86 55.29,123.17 51,123.17 49.37,121.54 49.37,105.33 49.05,105.02 49.05,100.33 50.83,98.56 50.83,97.57 54.63,93.77 54.63,93.46 55.1,93 55.1,88.37 55.57,87.89 55.57,76.03 58.11,73.5 58.66,72.94 61.75,72.94 63.85,70.84 v2(63.85,69.19) ; U400.BY30 130.29,83.7 v1(130.56,83.7)
CNV_BRI_DT: length 30.1
  TOP w0.102: R471.1 v2(150.79,89.27) 151.22,88.84 151.98,88.84 152.52,88.3 153.86,88.3 154.17,88.61 155.94,88.61 157.91,90.58 158.97,90.58 159.09,90.7 159.52,90.7 159.8,90.42 159.8,89.92 160.07,89.66 162.5,89.66 163.02,89.14 163.02,88.38 163.16,88.24 164.27,88.24 164.64,88.61 165.75,88.61 165.87,88.5 165.87,86.9 166.15,86.62 166.68,86.62 166.77,86.53 167.17,86.53 167.3,86.41 167.74,86.41 168.43,87.1 168.87,87.1 169.76,87.98 169.76,88.97 169.7,89.03 v2(169.7,89.3) 169.91,89.5 169.91,90.56 R4144.2
  BOTTOM w0.102: CN4100.36 169.45,89.65 169.7,89.39 v2(169.7,89.3)
CNV_BRI_RSP: length 30.4
  TOP w0.102: v1(135.74,89.58) 136.03,89.29 137.82,89.29 137.98,89.13 140.17,89.13 140.57,88.73 141.92,88.73 143.65,90.45 144.6,90.45 145.29,89.77 146.18,89.77 146.48,90.07 147.21,90.07 R497.2 147.44,89.85 147.94,89.85 148.05,89.95 150.89,89.95 151.58,89.27 151.83,89.27 152.37,88.73 153.98,88.73 154.08,88.83 155.49,88.83 v2(157,90.34) 157.46,90.8 158.87,90.8 159.1,91.03 159.73,91.03 160.08,90.68 161.5,90.68 R4119.1
  BOTTOM w0.079: U400.CK20 136.13,90.07 135.74,89.67 v1(135.74,89.58)
CNV_BRI_RSP_R: length 7.3
  TOP w0.102: v2(163.59,88.73) 163.59,88.9 162.82,89.66 R4119.2
  BOTTOM w0.102: v2(163.59,88.73) 163.59,89 164.07,89.48 165.66,89.48 165.95,89.78 CN4100.22 165.95,91.54 v2(165.32,92.16)
CNV_RF_RESET#: length 43.6
  TOP w0.102: R4123.2 159.17,86.54 157.64,86.54 156.66,85.57 156.66,84.19 158.07,82.78 158.07,76.08 157.49,75.49 156.96,75.49 156.07,74.61 156.07,74.35 155.69,73.97 155.46,73.97 155.41,74.02 155.38,74.02 155.15,74.25 155.15,74.27 154.92,74.5 154.92,75.24 154.29,75.88 154.29,76.36 v2(154.36,76.43) 154.36,76.92 154.29,76.99 154.29,77.31 R576.1 153.25,77.88 153.2,77.83 150.25,77.83 147.93,80.16 144.86,80.16 143.5,78.8 140.8,78.8 140.47,79.12 138.59,79.12 137.55,80.17 137.55,81.21 136.69,82.07 136.69,82.22 136.28,82.63 v1(136.08,82.63)
  BOTTOM w0.079: v1(136.08,82.63) 136.01,82.57 U400.CJ32
CNV_RF_RESET#_L: length 6.5
  TOP w0.102: R4123.1 161.37,86.32 v2(161.39,86.34)
  BOTTOM w0.102: CN4100.10 162.95,89.67 162.93,89.64 162.93,88.83 162.43,88.33 161.66,88.33 161.39,88.06 v2(161.39,86.34)
CNV_RGI_DT: length 16.4
  TOP w0.102: R470.1 155.19,90.23 v2(155.43,90.48) 155.96,91.01 158.78,91.01 159.01,91.24 159.82,91.24 160.17,90.9 161.65,90.9 161.85,90.7 167.33,90.7 R4143.1 168.02,90.02 168.02,89.72 v2(168.43,89.3)
  BOTTOM w0.102: CN4100.32 168.45,89.71 168.44,89.69 168.44,89.3 v2(168.43,89.3)
CNV_RGI_RSP: length 38.7
  TOP w0.102: R4118.1 168.5,90.21 167.8,90.91 161.99,90.91 161.78,91.11 160.26,91.11 159.75,91.62 158.17,91.62 157.82,91.98 155.28,91.98 v2(155.05,91.75) 155.05,90.86 154.8,90.61 154.16,90.61 153.91,90.86 R500.1 151.53,90.86 151.08,90.41 148.95,90.41 148.88,90.48 146.27,90.48 145.57,91.18 145.01,91.18 144.7,90.87 143.43,90.87 141.73,89.18 140.76,89.18 140.06,89.89 137.87,89.89 137.48,90.28 137.1,90.28 136.79,89.97 136.17,89.97 135.88,90.26 135.07,90.26 v1(134.69,90.64)
  BOTTOM w0.079: v1(134.69,90.64) 134.68,90.65 134.68,90.92 U400.CH19
CNV_RGI_RSP_R: length 2.8
  TOP w0.102: R4118.2 169.28,89.67 169.23,89.62 169.23,89.46 v2(169.07,89.3) 169.07,88.92 v2(169.35,88.64)
  BOTTOM w0.102: v2(169.07,89.3) 168.95,89.42 CN4100.34
CNVI_EN#: length 49.9
  TOP w0.102: R4140.2 174.02,87.58 173.91,87.48 173.91,86.46 173.54,86.09 172.78,86.09 172.5,85.81 172.5,84.69 172.37,84.56 171.33,84.56 170.67,83.9 170.67,82.6 167.97,79.89 v2(167.91,79.89)
  IN1 w0.114: v1(134.2,82.3) 134.4,82.5 134.98,82.5 135.75,81.74 135.75,81.13 136.33,80.55 138.41,80.55 139.05,81.18 150.33,81.18 153.56,77.95 161.92,77.95 162.16,78.19 166.6,78.19 167.91,79.51 v2(167.91,79.89)
  BOTTOM w0.079: U400.CH32 134.46,82.57 v1(134.2,82.3)
CNVI_EN#_R: length 5.6
  TOP w0.102: Q4109.2 177.12,87.58 177,87.71 176,87.71 175.88,87.84 175.46,87.84 R4140.1 175.52,87.58 175.66,87.45 R4138.2 175.66,86.23 176.14,85.75 R4137.1
CORE_VID_0: length 13
  BOTTOM w0.079: U400.CB36 131.32,79.67 131.32,79.36 131.31,79.34 131.31,77.91 131.82,77.39 133.74,77.39 134.95,76.19 136.05,76.19 136.82,75.42
  BOTTOM w0.102: 136.82,75.42 137.88,75.42 138.62,74.68 138.62,73.97 139.58,73 TP423.1
CORE_VID_1: length 12.7
  BOTTOM w0.079: 136.8,75.19 136.73,75.19 135.9,76.02 134.85,76.02 133.65,77.23 131.76,77.23 131.14,77.84 131.14,79.41 131.16,79.43 131.16,80.15 U400.CB35
  BOTTOM w0.102: TP424.1 138.26,73.59 138.26,74.67 137.74,75.19 136.8,75.19
CPU_C10_GATE#: length 167.5
  TOP w0.102: PR9609.2 109.16,60.8 108.53,61.43 108.53,61.95 109.4,62.82 113.39,62.82 v2(114.08,62.13) ; v2(157.29,105.82) 156.6,106.51 156.6,108.87 150.23,115.23 v2(146.16,115.23) 145.66,114.74 144.13,114.74 143.49,115.37 v2(140.19,115.37) 138.17,115.37 PR9618.2 ; v2(145.14,86.54) 145.27,86.54 146.6,85.21 149.01,85.21 149.72,84.51 150.48,84.51 150.61,84.38 150.99,84.38 151.37,84.77 155.1,84.77 v2(155.89,85.55) 156.19,85.25 156.19,84.26 157.84,82.61 157.84,76.15 157.44,75.75 156.88,75.75 v2(155.56,74.43)
  IN1 w0.114: v2(157.72,71.38) 157.13,70.8 154.8,70.8 154.42,70.41 154.42,68 157.34,65.08 157.34,62.03 157.84,61.52 159.88,61.52 160.51,60.89 160.51,57.71 160.26,57.46 v2(160.26,57.33)
  BOTTOM w0.079: U400.CN27 137.79,86.66 137.9,86.77 139.53,86.77 139.63,86.67 139.96,86.67
  BOTTOM w0.102: v2(157.72,71.38) 157.72,71.39 157.46,71.65 157.46,72.57 155.61,74.43 v2(155.56,74.43) ; v2(155.89,85.55) 155.89,85.98 157.11,87.2 157.11,89.49 158.48,90.86 158.48,91.95 158.61,92.08 158.61,93.02 159.29,93.71 159.29,94.37 157.46,96.2 157.46,97.97 157.08,98.35 157.08,100.13 158.73,101.78 158.73,105.09 158.02,105.8 157.31,105.8 v2(157.29,105.82) ; 139.96,86.67 141.31,86.67 141.53,86.45 144.54,86.45 144.64,86.54 v2(145.14,86.54) 145.27,86.67 145.27,87.15 R4706.1 145.24,87.66 TP427.1 ; v2(160.26,57.33) 159.37,56.44 156.32,56.44 156.19,56.57 132.83,56.57 127.29,62.11 120.1,62.11 119.95,62.26 114.21,62.26 v2(114.08,62.13) ; PR9217.2 146.29,115.12 146.17,115.23 v2(146.16,115.23)
CPU_PROCHOT#: length 246.3
  TOP w0.102: PR8810.1 PR8804.2 41.94,93.23 41.94,92.1 42.4,91.65 42.57,91.65 v2(43.19,91.03)
  IN1 w0.127: v2(132.67,25.58) 133.03,25.58 133.21,25.76 133.21,27.64 132.77,28.07 132.22,28.07 130.23,30.06 130.23,30.06 128.92,31.37 121.01,31.37 119.29,33.09 114.13,33.09 113.48,33.74 104.15,33.74 103.49,34.4 94.47,34.4 93.4,33.33 87.07,33.33 86.73,32.99 82.91,32.99 82.7,33.2 66.3,33.2 65.49,32.39 61.84,32.39 59.95,34.28 51.83,34.28 51.16,33.61 50.06,33.61 44.55,39.12 44.55,44.49 44,45.04 44,46.67 44.6,47.27 45.17,47.27 45.58,47.68 45.58,51.24 45.83,51.49 45.83,56.75 46.16,57.08 46.16,62.79 45.32,63.63 45.32,75.08 45.9,75.66 45.9,81.51 46.59,82.19 46.59,87.58 50.2,91.2 50.2,93.08 49.92,93.35 47.96,93.35 47.33,92.72 44.35,92.72 44.13,92.5 44.13,91.96 v2(43.19,91.03)
  IN2 w0.127: v2(43.19,91.03) 43.48,90.74 54.25,90.74 55.09,91.58 57.99,91.58 60.46,94.05 65.31,94.05 67.99,96.73 69.74,96.73 77.87,104.86 78.21,104.86 84.37,111.02 94.18,111.02 94.26,111.09 97.24,111.09 97.72,110.61 v2(98.33,110.61) 98.9,110.61 99.39,111.09 102.07,111.09 102.98,110.17 104.23,110.17 104.92,109.49 v2(104.92,109.48)
  BOTTOM w0.102: v2(98.33,110.61) 98.18,110.61 R403.1 97.88,109.75 98.34,109.29 C400.1 ; v2(132.67,25.58) 132.75,25.66 134.8,25.66 PR8519.1 ; R404.1 104.94,109.5 v2(104.92,109.48)
CPU_PROCHOT#_R: length 8.1
  BOTTOM w0.079: 105.43,107.38 105.69,107.12 105.69,103.71 105.49,103.52 105.49,101.61 105.77,101.33 105.77,101.08 105.47,100.77 U400.Y4
  BOTTOM w0.102: R404.2 104.94,107.87 105.43,107.38
CPU_THERM#: length 208
  TOP w0.102: v2(62.41,56.26) 59.44,59.23 58.93,59.74 58.93,60.72 53.81,65.84 51.67,65.84 50.15,67.37 49.54,67.37 49.36,67.54 Q5400.2 ; 168.07,102.38 168.77,101.68 168.77,100.67 169.07,100.36 R5405.1 169.62,100.55 v2(169.17,101)
  TOP w0.114: U5400.4 168.07,102.38
  IN1 w0.114: v2(55.66,90.92) 56.55,91.8 63.61,91.8 65.6,93.79 72.54,93.79 82.76,104.01 82.76,105.68 87.88,110.81 v2(87.88,111.45)
  IN2 w0.114: v2(155.33,121.09) 155.33,120.73 153.69,119.09 144.45,119.09 143.56,118.2 140.76,118.2 140.3,118.66 131.27,118.66 131.11,118.81 124.67,118.81 122.39,116.53 120.21,116.53 118.92,115.24 117.07,115.24 115.51,113.68 110.63,113.68 109.07,112.11 106.29,112.11 105.21,111.03 103.31,111.03 102.22,112.11 90,112.11 89.76,112.35 88.16,112.35 87.88,112.08 v2(87.88,111.45)
  BOTTOM w0.102: v2(55.66,90.92) 55.3,90.56 55.3,89.29 56.39,88.21 56.39,75.79 58.83,73.35 61.92,73.35 65.14,70.12 65.14,66.59 64.8,66.25 64.8,58.65 v2(62.41,56.26) ; v2(155.33,121.09) 155.56,120.86 155.56,118.52 155.94,118.14 155.94,117.13 155.71,116.9 155.71,115.97 162.42,109.27 162.42,108.39 163.36,107.45 165.39,107.45 167.7,105.14 167.7,102.8 169.17,101.33 v2(169.17,101)
CSP_C: length 2.1
  TOP w0.152: R6110.1 186.46,112.94 186.46,112.48 U6100.1
CSP_GND: length 2
  TOP w0.152: R6114.1 187.85,114.19 187.38,113.72 187.22,113.72 186.86,113.37 U6100.40
CYPRE_INT: length 236.2
  TOP w0.102: v2(220.37,29.64) 218.86,29.64 218.78,29.56 218.15,29.56 217.77,29.94 217.77,30.25 216.19,31.83 216.19,32.4 v2(215.77,32.81) ; v2(192.91,55.99) 193.06,55.84 R4715.2 ; v2(186.12,102.94) 186.57,103.39 186.67,103.39 186.94,103.66 R6103.2 187.36,105.14 188.43,105.14 188.86,105.57 U6100.15
  IN1 w0.114: v2(166.91,8.97) 167.19,8.69 172.98,8.69 175.57,11.28 184.52,11.28 188.27,7.54 195.61,7.54 196.73,8.65 197.7,8.65 199.25,10.21 199.25,10.4 203.56,14.71 203.56,17.19 204.82,18.45 206.55,18.45 208.71,20.61 209.89,20.61 210.49,21.21 213.85,21.21 215.83,23.19 215.83,24.75 219.08,28 219.08,28.33 220.12,29.37 220.12,29.4 v2(220.37,29.64) 220.7,29.97 220.7,36.59 219.87,37.43 219.87,39 220.38,39.51 220.38,56.52 215.1,61.8 211.54,61.8 211.31,62.03 210.17,62.03 208.9,63.3 208.9,67.24 207.12,69.02 207.12,70.31 205.58,71.85 205.05,71.85 203.54,73.36 203.54,76.15 203.39,76.31 203.39,77.83 202.55,78.67 202.55,79.56 202.42,79.69 202.42,82.15 201.63,82.94 201.63,83.52 200.13,85.02 200.13,88.83 200.52,89.21 200.52,91.08 197.14,94.45 197.14,97.41 196.83,97.72 195.94,97.72 191.36,102.3 188.44,102.3 188.07,102.67 188.07,103.16 187.81,103.43 186.7,103.43 186.59,103.32 186.5,103.32 v2(186.12,102.94)
  IN2 w0.114: v2(194.86,37.78) 195.09,37.78 195.41,38.09 195.41,38.45 196.04,39.08 196.04,39.88 195.73,40.19 195.73,42.24 193.98,43.99 193.98,44.75 192.41,46.32 192.41,50.9 192.19,51.12 192.19,53.91 192.46,54.18 192.46,55.18 192.91,55.62 v2(192.91,55.99)
  BOTTOM w0.102: v2(215.77,32.81) 216.26,33.3 216.26,34.66 214.73,36.19 214.73,40.63 214.24,41.12 211.1,41.12 209.49,39.51 207.4,39.51 206.5,38.62 204.02,38.62 201.66,36.26 198.97,36.26 198.71,36.01 197.41,36.01 197.15,36.26 196.14,36.26 194.86,37.55 v2(194.86,37.78) ; R7732.1 169.33,12.71 169.33,11.81 166.91,9.39 v2(166.91,8.97)
CYPRE_INT_C: length 3.6
  BOTTOM w0.102: CN7702.7 170.95,13.55 R7732.2 170.69,14.26 169.99,14.26 v2(169.56,13.83)
DCICLK: length 1.2
  TOP w0.102: U5800.14 203.79,109.98 203.75,109.94 TP5801.1
DCIDATA: length 1.4
  TOP w0.102: U5800.11 203.43,111.18 TP5800.1
DCIN_EN: length 1.7
  TOP w0.102: v2(211.11,88.69) 211.24,88.82 U3501.8
  BOTTOM w0.102: v2(211.11,88.69) 211.26,88.55 R3506.1
DCPRTC: length 1.3
  TOP w0.102: v1(125.91,87.95) 125.99,88.03 C439.2
  BOTTOM w0.079: U400.BP24 126.24,87.62 v1(125.91,87.95)
DDI2_AUX_DN: length 123.1
  TOP w0.097: C5809.1 206.78,102.79 206.78,102.67 206.41,102.29 205.34,102.29 204.5,103.13 202.48,103.13 201.97,102.63 201.36,102.63 201.18,102.44 200.18,102.44 200,102.63 198.08,102.63 193.19,97.73 182.92,97.73 181.54,99.12 178.74,99.12 172.77,105.09 171,105.09 164.29,111.8 160.68,111.8 157.24,115.23 157.24,116.16 v2(156.97,116.44)
  IN2 w0.114: v2(108.26,104.68) 108.69,105.1 108.69,105.11 108.89,105.31 109.42,105.31 110.18,106.07 110.18,107.41 111.04,108.27 112.27,108.27 113.54,109.55 114.28,109.55 115.79,111.06 116.29,111.06 118.07,112.84 121.12,112.84 121.96,113.68 124.14,113.68 124.65,114.18 124.65,115.4 125.22,115.98 126.33,115.98 126.75,115.55 131.86,115.55 132.82,114.59 136.56,114.59 137.19,115.22 141.59,115.22 142.03,115.66 147.45,115.66 147.63,115.48 155.21,115.48 156.62,116.9 156.95,116.9 157.14,116.71 157.14,116.6 v2(156.97,116.44)
  BOTTOM w0.079: U400.AD4 108.19,100.86 108.19,101.53 108,101.71 108,102.41 107.89,102.52 107.89,104.31 v2(108.26,104.68)
DDI2_AUX_DN_C: length 3.6
  TOP w0.097: U5800.25 206.56,106.28 206.48,106.21 206.48,106.01 206.59,105.9 206.59,105.13 R5810.1 206.58,104.31 206.58,104.18 C5809.2
DDI2_AUX_DP: length 123.1
  TOP w0.097: C5808.1 206.48,102.99 206.59,102.89 206.59,102.75 206.33,102.49 205.42,102.49 204.58,103.33 202.4,103.33 201.89,102.83 201.28,102.83 201.09,102.64 200.27,102.64 200.08,102.82 198,102.82 193.11,97.93 183.01,97.93 181.62,99.32 178.83,99.32 172.86,105.29 171.08,105.29 164.37,112 160.76,112 157.44,115.32 157.44,116.25 v2(157.63,116.44)
  IN2 w0.114: v2(157.63,116.44) 157.37,116.7 157.37,116.81 157.05,117.12 156.53,117.12 155.12,115.71 147.73,115.71 147.54,115.89 141.94,115.89 141.49,115.45 137.09,115.45 136.46,114.82 132.91,114.82 131.95,115.78 126.85,115.78 126.42,116.2 125.13,116.2 124.42,115.49 124.42,114.27 124.05,113.91 121.87,113.91 121.03,113.07 117.97,113.07 116.19,111.29 115.7,111.29 114.19,109.78 113.45,109.78 112.17,108.5 110.95,108.5 109.95,107.5 109.95,106.17 109.33,105.54 108.8,105.54 108.59,105.34 v2(108.29,105.34)
  BOTTOM w0.079: v2(108.29,105.34) 107.73,104.78 107.73,102.46 107.85,102.34 107.85,101.63 108.02,101.46 108.02,101.34 U400.AD3
DDI2_AUX_DP_C: length 3.6
  TOP w0.097: C5808.2 206.39,104.18 206.39,104.31 R5811.2 206.39,105.13 206.39,105.82 206.28,105.92 206.28,106.21 206.16,106.33 U5800.24
DDI2_TX0_DN: length 122.1
  TOP w0.097: C5800.1 201.22,112.88 200.97,112.88 198.44,110.36 198.44,107.92 197.22,106.7 197.22,105.7 192.01,100.49 184.08,100.49 182.56,102.01 180.45,102.01 174.69,107.77 174.31,107.77 173.66,108.42 173.07,108.42 170.1,111.38 168.52,111.38 165.29,114.62 163.92,114.62 159.39,119.15 157.68,119.15 v2(157.48,118.95)
  IN2 w0.114: v2(157.48,118.95) 157.32,119.11 156.8,119.11 156.73,119.04 156.73,118.04 154.83,116.14 148.12,116.14 147.92,116.34 141.79,116.34 141.43,115.98 138.49,115.98 138.13,116.34 126.93,116.34 126.65,116.62 124.96,116.62 123.11,114.78 120.94,114.78 119.65,113.49 117.8,113.49 116.02,111.71 115.53,111.71 114.01,110.2 113.28,110.2 112,108.92 110.7,108.92 108.16,106.38 108.16,105.9 107.76,105.49 107.76,104.23 107.33,103.81 107.33,103.77 106.92,103.36 v2(106.82,103.36)
  BOTTOM w0.079: v2(106.82,103.36) 107.04,103.13 107.04,102.65 106.94,102.54 106.94,102.44 106.92,102.42 106.92,101.99 106.94,101.97 106.94,101.79 106.92,101.77 106.92,101.37 106.96,101.33 106.96,101.21 107.07,101.09 107.07,100.71 107.34,100.43 U400.AC4
DDI2_TX0_DN_C: length 3.3
  TOP w0.097: U5800.10 203.9,111.58 203.79,111.69 203.53,111.69 203.29,111.93 203.29,112.75 203.05,112.98 202.71,112.98 C5800.2
DDI2_TX0_DP: length 122.1
  TOP w0.097: v2(157.48,119.61) 157.75,119.35 159.47,119.35 164,114.82 165.37,114.82 168.61,111.58 170.18,111.58 173.15,108.62 173.74,108.62 174.39,107.97 174.77,107.97 180.53,102.21 182.64,102.21 184.16,100.69 191.92,100.69 197.02,105.78 197.02,106.78 198.24,108 198.24,110.44 200.88,113.08 201.01,113.08 C5801.1
  IN2 w0.114: v2(157.48,119.61) 157.21,119.34 156.71,119.34 156.5,119.13 156.5,118.13 154.73,116.37 148.21,116.37 148.01,116.57 141.7,116.57 141.34,116.21 138.58,116.21 138.23,116.57 127.03,116.57 126.74,116.85 124.86,116.85 123.02,115.01 120.84,115.01 119.55,113.72 117.71,113.72 115.92,111.94 115.43,111.94 113.92,110.43 113.18,110.43 111.9,109.15 110.61,109.15 107.93,106.48 107.93,105.99 107.53,105.59 107.53,104.32 107.22,104.02 v2(106.84,104.02)
  BOTTOM w0.079: U400.AC3 107.34,101.05 107.11,101.28 107.11,101.4 107.09,101.43 107.09,101.7 107.11,101.72 107.11,102.04 107.09,102.06 107.09,102.35 107.11,102.37 107.11,102.47 107.22,102.59 107.22,103.64 v2(106.84,104.02)
DDI2_TX0_DP_C: length 3.3
  TOP w0.097: U5800.9 203.88,111.98 203.79,111.89 203.61,111.89 203.49,112.01 203.49,112.83 203.14,113.18 202.71,113.18 202.3,113.59 C5801.2
DDI2_TX1_DN: length 123.5
  TOP w0.097: C5803.1 201.52,111.06 201.42,111.16 200.52,111.16 199.13,109.77 199.13,107.65 197.89,106.42 197.89,105.41 192.25,99.76 183.79,99.76 182.25,101.31 180.01,101.31 174.22,107.1 174.02,107.1 173.38,107.73 172.72,107.73 169.74,110.71 168.24,110.71 165.01,113.94 163.64,113.94 159.92,117.66 158.58,117.66 158.3,117.94 158.3,118.3 158.22,118.37 v2(157.88,118.37)
  IN2 w0.114: v2(157.88,118.37) 158.15,118.37 158.2,118.42 158.27,118.49 158.27,119.66 157.68,120.25 156.57,120.25 155.86,119.54 155.86,118.66 155.02,117.81 151.33,117.81 150.43,116.91 148.62,116.91 148.43,117.09 137.97,117.09 137.57,117.5 130.86,117.5 130.66,117.7 125.12,117.7 123.78,116.36 122.85,115.43 120.67,115.43 119.38,114.14 117.53,114.14 115.97,112.57 112.96,112.57 109.55,109.17 109.55,108.69 109.46,108.6 109.42,108.6 107.22,106.4 107.22,106.02 106.84,105.64 v2(106.84,105.29)
  BOTTOM w0.079: v2(106.84,105.29) 107.25,105.29 107.39,105.14 107.39,102.25 U400.AC1
DDI2_TX1_DN_C: length 2.5
  TOP w0.097: C5803.2 202.66,110.96 202.8,110.96 203.28,110.47 203.79,110.47 203.88,110.38 U5800.13
DDI2_TX1_DP: length 123.6
  TOP w0.097: C5802.1 201.32,111.36 200.44,111.36 198.93,109.85 198.93,107.73 197.7,106.5 197.7,105.49 192.17,99.96 183.87,99.96 182.33,101.5 180.1,101.5 174.3,107.29 174.1,107.29 173.47,107.93 172.8,107.93 169.82,110.91 168.33,110.91 165.09,114.14 163.72,114.14 160,117.86 158.66,117.86 158.49,118.02 158.49,118.21 v2(158.69,118.4)
  IN2 w0.114: v2(106.76,106.18) 106.76,106.26 109.32,108.82 109.32,109.26 112.86,112.8 115.87,112.8 117.44,114.37 119.28,114.37 120.58,115.66 122.75,115.66 123.68,116.59 125.02,117.93 130.76,117.93 130.96,117.73 137.66,117.73 138.07,117.32 148.53,117.32 148.71,117.14 150.34,117.14 151.24,118.04 154.92,118.04 155.63,118.75 155.63,119.63 156.48,120.48 157.78,120.48 158.5,119.76 158.5,118.59 v2(158.69,118.4)
  BOTTOM w0.079: U400.AC2 107.63,101.84 107.63,102.32 107.56,102.39 107.56,105.21 106.76,106.01 v2(106.76,106.18)
DDI2_TX1_DP_C: length 2.5
  TOP w0.097: U5800.12 203.88,110.78 203.77,110.67 203.36,110.67 202.88,111.16 202.71,111.16 C5802.2
DDI2_TX2_DN: length 115.9
  TOP w0.097: v2(159.18,116.31) 159.48,116.62 160,116.62 163.36,113.27 164.73,113.27 167.99,110.01 169.41,110.01 172.38,107.04 173.11,107.04 179.53,100.62 181.97,100.62 183.5,99.09 192.54,99.09 198.57,105.11 198.57,106.14 200.13,107.7 200.13,108.74 200.55,109.15 201.04,109.15 C5805.1
  IN2 w0.114: v2(109.23,103.56) 109.46,103.79 109.68,103.79 110.22,104.33 110.22,105.19 110.83,105.8 110.83,106.75 111.32,107.24 112.16,107.24 113.81,108.9 114.55,108.9 116.06,110.41 116.57,110.41 117.48,111.33 118.29,111.33 118.91,111.95 121.42,111.95 122.5,113.03 124.51,113.03 124.98,113.49 126.22,113.49 126.45,113.73 136.89,113.73 137.26,114.1 139.5,114.1 139.81,114.41 141.77,114.41 142.25,114.89 142.8,114.89 143.13,114.56 157.13,114.56 158.71,116.14 158.71,116.42 158.8,116.52 158.98,116.52 v2(159.18,116.31)
  BOTTOM w0.079: U400.AE4 108.47,100.5 108.77,100.8 108.77,101.25 108.86,101.33 108.86,101.33 108.88,101.36 108.88,101.75 108.85,101.79 108.85,101.96 108.88,102 108.88,102.02 108.92,102.06 108.92,102.54 108.94,102.56 108.94,103.28 v2(109.23,103.56)
DDI2_TX2_DN_C: length 2.4
  TOP w0.097: C5805.2 202.69,109.05 203.04,109.05 203.24,109.26 203.79,109.26 203.86,109.18 U5800.16
DDI2_TX2_DP: length 115.8
  TOP w0.097: v2(159.18,116.98) 159.33,116.82 160.09,116.82 163.44,113.47 164.81,113.47 168.07,110.21 169.5,110.21 172.46,107.24 173.19,107.24 179.61,100.82 182.05,100.82 183.58,99.28 192.46,99.28 198.37,105.19 198.37,106.22 199.93,107.78 199.93,108.82 200.47,109.35 201.24,109.35 C5804.1
  IN2 w0.114: v2(109.13,104.25) 109.36,104.02 109.58,104.02 109.99,104.42 109.99,105.29 110.6,105.9 110.6,106.85 111.22,107.47 112.06,107.47 113.72,109.13 114.46,109.13 115.97,110.64 116.48,110.64 117.39,111.56 118.2,111.56 118.81,112.17 121.33,112.17 122.41,113.26 124.42,113.26 124.88,113.72 126.12,113.72 126.36,113.96 136.79,113.96 137.16,114.32 139.4,114.32 139.72,114.64 141.67,114.64 142.15,115.12 142.9,115.12 143.22,114.79 157.03,114.79 158.48,116.24 158.48,116.52 158.71,116.74 158.95,116.74 159.09,116.88 v2(159.18,116.98)
  BOTTOM w0.079: v2(109.13,104.25) 108.78,103.9 108.78,102.63 108.76,102.61 108.76,102.11 108.72,102.08 108.72,102.06 108.68,102.02 108.68,101.73 108.72,101.68 108.72,101.42 108.7,101.4 108.7,101.4 108.47,101.17 U400.AE3
DDI2_TX2_DP_C: length 2.4
  TOP w0.097: C5804.2 202.68,109.25 202.95,109.25 203.16,109.45 203.77,109.45 203.9,109.58 U5800.15
DDI2_TX3_DN: length 114
  TOP w0.097: v2(159.83,114.31) 159.83,114.89 159.93,115 160.25,115 162.65,112.59 164.45,112.59 167.71,109.34 169.12,109.34 172.17,106.28 172.73,106.28 179.12,99.88 181.74,99.88 183.21,98.41 192.88,98.41 199.25,104.78 199.25,105.72 200.83,107.3 201.68,107.3 201.79,107.19 201.79,107 C5807.1
  IN2 w0.114: v2(159.83,114.31) 159.83,114.89 159.69,115.02 158.69,115.02 157.58,113.91 142.94,113.91 142.79,113.76 140.08,113.76 138.54,112.22 137.43,112.22 136.57,113.08 126.76,113.08 126.52,112.83 125.27,112.83 124.82,112.38 122.77,112.38 121.69,111.3 119.33,111.3 116.99,108.96 115.87,108.96 115.16,108.25 114.08,108.25 112.96,107.13 112.96,106.36 112.15,105.55 112.15,104.76 109.68,102.29 109.05,102.29 108.59,102.75 v1(108.42,102.75)
  BOTTOM w0.079: U400.AE1 108.38,102.29 108.38,102.71 v1(108.42,102.75)
DDI2_TX3_DN_C: length 2.9
  TOP w0.097: C5807.2 202.74,107.17 202.88,107.17 203.13,107.42 203.13,107.83 203.34,108.03 203.85,108.03 203.89,107.98 U5800.19
DDI2_TX3_DP: length 114.1
  TOP w0.097: C5806.1 201.32,107.5 200.75,107.5 199.05,105.8 199.05,104.86 192.79,98.61 183.29,98.61 181.82,100.08 179.21,100.08 172.81,106.48 172.26,106.48 169.2,109.53 167.79,109.53 164.53,112.79 162.74,112.79 160.33,115.19 160.06,115.19 v2(159.83,115.43)
  IN2 w0.114: v2(159.83,115.43) 159.65,115.25 158.59,115.25 157.48,114.14 142.84,114.14 142.69,113.99 139.98,113.99 138.44,112.45 137.52,112.45 136.67,113.31 126.67,113.31 126.42,113.06 125.18,113.06 124.73,112.61 122.68,112.61 121.6,111.53 119.23,111.53 116.89,109.19 115.77,109.19 115.07,108.48 113.99,108.48 112.73,107.23 112.73,106.46 111.92,105.64 111.92,104.86 109.58,102.52 109.15,102.52 108.9,102.76 108.9,103.07 108.59,103.38 v2(108.36,103.38)
  BOTTOM w0.079: v2(108.36,103.38) 108.06,103.08 108.06,102.6 108.21,102.45 108.21,102.06 108.47,101.8 U400.AE2
DDI2_TX3_DP_C: length 2.9
  TOP w0.097: C5806.2 202.63,107.37 202.8,107.37 202.93,107.5 202.93,107.91 203.25,108.23 203.74,108.23 203.89,108.38 U5800.18
DDR3_DRAMRST#: length 248.1
  TOP w0.102: v2(159.57,35.46) 159.27,35.16 155.56,35.16 155.3,35.41 155.3,36.02 155.1,36.23 153.17,36.23 152.68,35.73 150.41,35.73 149.77,35.08 v2(149.77,33.66) ; C2829.2 152.36,40.59 v2(153.22,39.73) ; v2(91.4,39.02) 90.33,37.95 90.18,37.95 89.24,37.01 76.23,37.01 75.6,37.65 75.6,38.97 v2(74.89,39.68) 74.71,39.86 C2800.2 ; v1(128.7,82.92) 129.22,82.4 129.22,81.21 128.59,80.58 128.59,78.05 130.46,76.18 130.46,75.24 130.16,74.94 130.16,73.36 130.21,73.31 130.21,70.74 130.71,70.25 R544.1 130.71,68.46 134.43,64.74 146.14,64.74 146.85,65.45 150.47,65.45 151.23,66.2 153.45,66.2 153.95,65.7 159.78,65.7 160.16,66.07 161.35,66.07 v2(161.52,65.9)
  IN1 w0.127: v2(91.4,39.02) 91.84,39.46 91.84,39.72 92.2,40.07 93.54,40.07 93.73,39.88 95,39.88 95.39,40.26 96.07,40.26 96.4,39.93 97.04,39.93 97.95,40.85 99.83,40.85 100.34,40.34 108.62,40.34 v2(109.18,39.78)
  IN2 w0.127: v2(109.18,39.78) 109.11,39.72 109.11,38.12 109.72,37.51 113.65,37.51 114.16,38.03 118.42,38.03 121.77,34.68 125.36,34.68 125.49,34.54 126,34.54 128.64,34 130.11,33.8 131.2,33.7 134.76,33.7 134.81,33.66 v2(149.77,33.66) ; v2(159.57,35.46) 159.7,35.34 161.04,35.34 161.35,35.64 161.91,35.64 162.24,35.31 162.24,35.03 162.99,34.28 167.78,34.28 168.59,33.47 170.85,33.47 173.56,36.18 182.17,36.18 183.4,37.41 188.11,37.41 188.77,36.76 190.9,36.76 192.85,38.71 192.85,40 192.46,40.38 192.46,44.12 190.77,45.82 190.77,47.81 187.48,51.09 184.83,51.09 179.67,56.25 179.67,59.29 176.78,62.18 176.78,63.9 176.09,64.59 174.45,64.59 174.1,64.24 172.8,64.24 172.45,64.6 170.92,64.6 169.71,65.82 168.69,65.82 168.28,66.23 166.15,66.23 165.61,65.68 161.74,65.68 v2(161.52,65.9)
  BOTTOM w0.079: v1(128.7,82.92) 128.6,82.92 U400.BU31
  BOTTOM w0.102: JDIM2800.108 75.85,38.03 75.8,38.08 75.8,39.11 75.24,39.68 v2(74.89,39.68) ; v2(149.77,33.66) 149.77,35.01 150.43,35.67 152.54,35.67 152.82,35.95 JDIM2801.108 152.82,39.38 153.17,39.73 v2(153.22,39.73)
DDR_PG_CNTL: length 22.5
  TOP w0.102: v1(92.34,80.04) 92.19,80.19 82.93,80.19 79.91,77.16 v2(77.42,77.16) R551.1
  BOTTOM w0.079: v1(92.34,80.04) 92.72,80.42 93.96,80.42 94.04,80.35 94.42,80.35 94.6,80.52 95.09,80.52 U400.C35
DDR_VTT: length 64.3
  IN1 w0.508: 157.32,36.16 156.97,36.52 151.06,36.52 150.7,36.16 125.12,36.16 123.81,37.47 119.64,37.47 118.65,38.46 v2(115.58,38.46)
  IN1 w0.635: 159.07,36.16 160.03,36.16 160.32,36.45 169.24,36.45 169.68,36.89 171.2,36.89 171.86,37.55 174.58,37.55 v4(175.95,38.92)
  BOTTOM w0.203: v4(192.11,38.74) 192.31,38.54 192.31,38.18 192.32,38.18 JDIM2801.258
  BOTTOM w0.254: v2(115.58,38.46) 115.58,38.31 115.35,38.09 JDIM2800.258
  vias: v2(150.26,21.2) v2(150.26,20.57) v2(150.94,21.21) v2(150.94,20.58) v2(157.79,35.68) v2(158.58,35.67)
DDR_VTT_PG_CTRL: length 209.5
  TOP w0.102: v2(55.76,49.84) 55.53,50.07 53.73,50.07 53.5,49.84 50.4,49.84 49.94,49.38 49.94,47 45.73,42.78 45.73,39.5 50.05,35.18 53.76,35.18 54.42,34.52 59.76,34.52 60.21,34.08 60.21,33.26 60.08,33.13 60.08,30.59 58.43,28.94 58.43,26.53 v2(59.11,25.85) ; v2(64.53,69.37) 64.68,69.51 R550.1 72.47,69.98 72.83,70.34 Q403.3 72.47,71.1 R548.2 ; v2(135.14,14.25) 135.55,14.25 137.44,12.37 143.41,12.37 146.09,9.68 148.95,9.68 v2(149.23,9.95) 149.63,10.36 150.89,10.36 151.72,9.53 151.72,8.81 151.81,8.72 153.13,8.72 154.02,7.83 154.02,7.47 154.62,6.86 156.81,6.86 157.26,7.31 160.83,7.31 162.26,8.75 162.26,10.23 162.45,10.42 163.17,10.42 164.04,11.29 PQ8702.2
  IN1 w0.114: v2(119.95,22.41) 119.52,22.84 117.6,22.84 115.16,25.28 111.04,25.28 110.53,25.79 v2(109.78,25.79)
  IN2 w0.114: v2(119.95,22.41) 120.37,21.98 122.34,21.98 125.26,19.07 125.26,14.36 128.44,11.17 128.61,11.17 128.91,10.87 131.65,10.87 131.99,10.54 133.85,10.54 135.44,12.13 135.44,12.19 135.57,12.32 135.57,13.82 v2(135.14,14.25) ; v2(59.11,25.85) 59.91,25.85 60.4,26.33 64.72,26.33 65.9,25.15 67.12,25.15 70.23,28.26 75.61,28.26 77.71,30.36 80.7,30.36 81.74,29.33 90.65,29.33 91.84,28.14 95.77,28.14 97.1,29.46 98.84,29.46 99.03,29.66 101.22,29.66 103.92,26.96 108.61,26.96 v2(109.78,25.79)
  BOTTOM w0.102: v2(64.53,69.37) 64.53,66.77 64.4,66.63 64.4,64.88 62.89,63.37 62.89,58.45 57.1,52.66 57.1,51.18 v2(55.76,49.84) ; v2(149.23,9.95) 149.23,9.96 R3306.1
DDR_VTTREF: length 2
  BOTTOM w0.254: PR8706.1 149.33,14.71 149.44,14.82 PC8712.1 150.32,14.82 v2(150.72,15.22)
DDSP_1_HPD1: length 98.5
  TOP w0.102: v2(188.58,94.56) 193.55,94.56 194.27,95.28 R6112.1 194.49,96.69 194.69,96.9 194.69,97.42 195.09,97.82 196.91,97.82 197.65,97.08 Q6100.1 197.65,96.09 197.8,95.94 198.61,95.94 198.86,96.2 198.86,98.35 199.22,98.71 200.29,98.71 201.23,99.66 203.21,99.66 203.62,100.06 203.62,100.89 v2(203.63,100.9) ; v1(136.58,98.44) 137.36,98.44 139.18,100.25 141.51,100.25 141.61,100.15 142.79,100.15 143.73,99.21 146.29,99.21 146.35,99.27 149.85,99.27 150.12,99.54 152.32,99.54 C405.2 152.87,98.99 153.72,98.99 154.54,98.17 R540.1 155.09,98.09 155.24,97.94 157.18,97.94 158.71,99.47 161.78,99.47 v2(162.01,99.7)
  TOP w0.114: U5800.32 209.12,108.78 209.32,108.99 v2(209.32,109.01)
  IN2 w0.114: v2(162.01,99.7) 162.01,99.6 162.72,98.89 165.68,98.89 166.6,99.8 169.91,99.8 170.13,99.58 172.43,99.58 174.07,97.95 176.16,97.95 176.61,98.39 181.86,98.39 183.28,96.97 185.02,96.97 187.43,94.56 v2(188.58,94.56) ; v2(209.32,109.01) 209.01,109.01 207.59,107.58 204.42,107.58 204.04,107.97 202.91,107.97 202.16,107.21 202.16,103.38 201.95,103.17 201.95,101.73 203.01,100.67 203.39,100.67 v2(203.63,100.9)
  BOTTOM w0.079: v1(136.58,98.44) 136.82,98.67 U400.CM6
DEV_MODE_DET: length 8
  TOP w0.102: TP4700.1 214.14,48.02 210.97,48.02 210.64,48.35 210.64,48.76 210.22,49.18 209.59,49.18 209.37,48.96 208.94,48.96 208.19,49.71 U4701.M2
DEVSLP0: length 13.9
  BOTTOM w0.079: 144.5,95.87 144.28,96.08 142.76,96.08 141.74,97.11 141.74,97.5 141.44,97.8 141.09,97.8 140.95,97.94 140.25,97.94 140.11,98.07 138.67,98.07 138.6,98.03 138.37,97.8 U400.CP8
  BOTTOM w0.102: R555.1 149.24,94.95 v2(149.01,94.95) 148.81,95.15 145.22,95.15 144.5,95.87
DEVSLP1: length 161.5
  IN1 w0.114: v2(173.39,94.28) 173.74,93.93 174.59,93.93 175.92,92.6 176.86,92.6 178.57,90.89 179.79,90.89 180.71,89.97 181.02,89.97 181.71,89.28 181.71,87.53 182.63,86.61 182.63,84.97 182.15,84.48 182.15,80.89 183.74,79.3 183.74,73.1 184.13,72.7 184.13,69.91 182.74,68.51 182.1,68.51 181.1,67.51 181.1,64.12 182.38,62.84 182.38,58.49 186.45,54.42 187.72,53.14 189.24,53.14 189.83,52.55 189.83,51.85 190.21,51.48 190.56,51.48 190.58,51.49 190.6,51.49 190.61,51.5 192.66,51.5 194.02,50.15 195.97,50.15 197.85,48.26 197.85,47.14 200.36,44.63 200.36,43.04 200.69,42.7 200.69,35.82 200.31,35.43 200.31,22.8 194.62,17.11 193.59,17.11 193.3,16.82 191.53,16.82 v2(190.54,15.83)
  IN2 w0.114: v2(173.39,94.28) 171.96,95.72 167.39,95.72 166.58,94.91 162.33,94.91 161.79,95.45 159.24,95.45 157.53,97.16 153.58,97.16 152.86,96.45 152.86,94.69 152.66,94.49 151.85,94.49 150.52,95.81 150.52,96.45 150.02,96.96 146.82,96.96 146.55,97.23 145.65,97.23 145.08,97.79 141.7,97.79 v2(141.28,97.38)
  BOTTOM w0.079: U400.CR8 138.82,97.86 140.09,97.86 140.18,97.77 140.88,97.77 141.27,97.38 v2(141.28,97.38)
  BOTTOM w0.102: v2(190.54,15.83) 191.45,14.92 192.25,14.92 194.46,12.71 197.64,12.71 198.21,12.13 201.09,12.13 203.39,14.43 R4303.1
DEVSLP2: length 162
  IN1 w0.114: v2(189.9,15.83) 191.15,17.07 193.22,17.07 193.49,17.34 194.53,17.34 200.08,22.89 200.08,35.56 200.21,35.69 200.21,42.51 199.36,43.36 199.36,45.28 197.61,47.04 197.61,48.16 195.87,49.9 193.92,49.9 193.17,50.65 190.53,50.65 188.27,52.92 187.49,52.92 182.08,58.33 182.08,62.8 180.87,64.01 180.87,67.66 182.11,68.9 182.49,68.9 183.62,70.03 183.62,71.43 182.99,72.07 182.99,72.75 183.51,73.27 183.51,79.19 181.92,80.78 181.92,84.6 182.39,85.07 182.39,86.51 181.47,87.43 181.47,89.18 180.92,89.73 179.42,89.73 178.93,90.22 177.94,90.22 174.5,93.67 172.69,93.67 v2(172.14,94.21)
  IN2 w0.114: v2(140.62,97.38) 140.62,97.29 141.04,96.87 141.54,96.87 142.23,97.57 144.99,97.57 145.56,97 146.45,97 147.27,96.18 148.66,96.18 149.23,95.61 149.49,95.61 150.11,95 151.01,95 151.75,94.26 152.86,94.26 153.15,94.54 153.15,94.93 154.8,96.58 155.69,96.58 156.57,95.69 158.1,95.69 158.79,94.99 159.45,94.99 160.14,94.3 161.05,94.3 161.19,94.45 166.77,94.45 167.53,95.21 171.14,95.21 v2(172.14,94.21)
  BOTTOM w0.079: v2(140.62,97.38) 140.34,97.38 140.02,97.69 139.06,97.69 138.91,97.55 137.16,97.55 U400.CM8
  BOTTOM w0.102: v2(189.9,15.83) 191.07,14.66 192.22,14.66 194.37,12.51 197.55,12.51 198.13,11.93 201.17,11.93 202.29,13.05 203.4,13.05 R4301.1
DEVSLP2_R: length 4.7
  BOTTOM w0.102: R4303.2 203.98,15.24 R4301.2 ; R4301.2 204.72,14.4 204.92,14.59 CN4300.38 ; R4301.2 v2(203.1,13.52)
DGPU_HOLD_RST#: length 21
  TOP w0.102: R558.2 154.32,100.32 R559.1 153.11,100.85 v2(152.49,100.23) 152,99.74 150.03,99.74 149.77,99.48 148.03,99.48 147.71,99.8 146.35,99.8 145.98,99.43 143.82,99.43 142.87,100.38 141.69,100.38 141.59,100.48 139.07,100.48 137.55,98.96 v1(136.33,98.96)
  BOTTOM w0.079: U400.CK6 136.22,98.86 v1(136.33,98.96)
DGPU_PRSNT#: length 26.4
  TOP w0.102: R560.2 156.55,98.66 156.45,98.75 R561.2 v2(156.45,100.27) 156.45,100.73 154,103.18 150.1,103.18 149.08,102.16 149.08,101.28 148.57,100.77 147.68,100.77 147.26,100.34 144.9,100.34 144.48,100.76 139.02,100.76 137.81,99.55 v1(136.36,99.55)
  BOTTOM w0.079: U400.CK5 136.31,99.51 v1(136.36,99.55)
DGPU_PWR_EN: length 23.6
  TOP w0.102: v1(136.33,97.35) 136.59,97.35 139.27,100.02 141.43,100.02 141.52,99.94 142.69,99.94 143.62,99 146.36,99 146.43,99.07 150.06,99.07 150.31,99.32 151.82,99.32 152.16,98.98 152.58,98.98 152.78,98.78 153.28,98.78 v2(153.66,98.4) 153.66,98.26 154.26,97.66 156.43,97.66 R556.2
  BOTTOM w0.079: U400.CK8 136.12,97.56 v1(136.33,97.35)
DIGITAL_CLK: length 333.9
  TOP w0.102: R3607.2 213.39,14.61 213.7,14.61 214.1,15.02 C3613.2 214.32,15.02 215.14,15.83 v2(215.16,15.83) ; L3401.1 38.62,127.77 v2(39.12,127.26)
  IN2 w0.127: v2(215.16,15.83) 215.1,15.83 213.97,14.71 213.97,13.34 213.36,12.73 213.36,11.54 212.65,10.82 212.65,9.88 212.26,9.49 211.41,9.49 210.56,8.64 209.8,8.64 209.29,8.13 207.4,8.13 207.02,8.51 204.99,8.51 204.76,8.74 201.9,8.74 201.05,9.59 199.24,9.59 198.52,8.87 188.35,8.87 186.07,11.15 173.27,11.15 172.01,9.89 171.72,9.89 170.07,8.24 166.84,8.24 166.42,8.66 164.43,8.66 164.1,8.33 159.86,8.33 158.67,7.14 151.5,7.14 149.68,8.96 148.24,8.96 146.45,10.75 144.14,10.75 143.77,11.12 134.96,11.12 134,10.16 131.38,10.16 131.04,10.5 128.76,10.5 128.46,10.8 128.28,10.8 124.88,14.2 124.88,18.91 122.49,21.31 118.46,21.31 114.35,25.42 112.15,25.42 111.14,24.41 109.32,24.41 107.14,26.59 103.76,26.59 101.26,29.09 99.7,29.09 98.25,27.64 86.04,27.64 85.18,28.5 81.22,28.5 80.3,29.42 79.09,29.42 76.89,27.22 71.37,27.22 70.27,26.12 68.62,26.12 66.93,24.43 65.7,24.43 64.43,25.7 61.45,25.7 60.07,24.31 57.13,24.31 56.19,23.37 54.34,23.37 53.07,24.64 50.73,24.64 48.45,22.36 44.61,22.36 42.53,24.44 42.53,24.95 42.89,25.31 42.89,28.4 42.36,28.93 42.36,32.58 38.57,36.37 38.57,44.33 38.47,44.43 38.47,47.94 38.57,48.04 38.57,56.83 39.47,57.73 39.47,58.29 39.99,58.81 39.99,61.03 39.58,61.44 39.58,62.19 40.19,62.79 41.15,62.79 45.04,66.68 45.04,69.75 42.86,71.94 42.86,74.91 40.05,77.72 40.05,78.1 39.61,78.54 39.23,78.54 37.19,80.57 34.96,80.57 24.62,90.91 24.62,93.5 v2(26.07,94.95)
  BOTTOM w0.102: v2(39.12,127.26) 36.6,124.73 33.93,124.73 30.72,121.52 30.72,118.42 28.58,116.28 28.58,114.83 27.25,113.51 27.25,104.38 25.51,102.64 25.51,96.87 25.1,96.46 25.1,95.23 25.38,94.95 v2(26.07,94.95)
DIGITAL_CLK_L: length 6.6
  TOP w0.102: v2(37.22,127.84) 37.44,127.63 38.03,127.63 38.21,127.81 38.21,128.36 L3401.2 38.51,128.87 38.51,130.34 C3412.1 39.27,131.1 39.31,131.1 v2(39.58,131.37)
  BOTTOM w0.102: v2(39.58,131.37) 39.65,131.44 CN3400.8
DIGITAL_D1: length 331.5
  TOP w0.102: v2(215.16,14.75) 214.86,14.75 214.53,14.43 213.93,14.43 213.64,14.14 R3606.2 ; v2(39.76,127.21) 39.63,127.34 L3402.1
  IN2 w0.127: v2(215.16,14.75) 215.1,14.75 214.31,13.97 214.31,13.2 213.7,12.59 213.7,11.39 212.99,10.68 212.99,9.74 212.4,9.15 211.54,9.15 210.69,8.3 209.97,8.3 209.46,7.79 207.26,7.79 206.88,8.17 204.84,8.17 204.61,8.39 201.76,8.39 200.91,9.24 199.37,9.24 198.66,8.54 188.15,8.54 185.87,10.82 173.41,10.82 172.15,9.56 171.85,9.56 170.2,7.91 166.7,7.91 166.28,8.33 164.56,8.33 164.24,8 160.01,8 158.82,6.81 151.36,6.81 149.7,8.48 148.25,8.48 146.31,10.42 143.93,10.42 143.56,10.79 135.12,10.79 134.14,9.82 131.23,9.82 130.88,10.17 128.62,10.17 128.32,10.47 128.09,10.47 124.55,14.01 124.55,18.77 122.35,20.98 118.28,20.98 114.17,25.09 112.28,25.09 111.28,24.08 109.18,24.08 108.76,24.5 107.02,26.24 103.62,26.24 101.1,28.76 99.86,28.76 98.41,27.31 85.89,27.31 85.03,28.17 81.07,28.17 80.15,29.08 79.24,29.08 77.03,26.88 71.5,26.88 70.4,25.79 68.77,25.79 67.07,24.08 65.57,24.08 64.3,25.35 61.58,25.35 60.21,23.98 57.27,23.98 56.33,23.04 54.2,23.04 52.93,24.31 50.87,24.31 48.59,22.03 44.43,22.03 42.15,24.31 42.15,25.08 42.53,25.46 42.53,28.25 42,28.78 42,32.46 38.09,36.37 38.09,44.02 37.85,44.26 37.85,48.06 38.24,48.45 38.24,56.97 39.14,57.87 39.14,62.23 40.04,63.13 41.01,63.13 44.7,66.82 44.7,69.61 42.53,71.78 42.53,74.61 39.73,77.4 39.1,77.4 38.84,77.65 38.84,78.29 37.07,80.07 35,80.07 24.29,90.77 24.29,94.39 v2(25.51,95.61)
  BOTTOM w0.102: v2(39.76,127.21) 36.98,124.43 34.05,124.43 31.02,121.4 31.02,118.29 28.88,116.15 28.88,114.71 27.56,113.38 27.56,104.26 25.92,102.62 25.92,96.35 25.51,95.94 v2(25.51,95.61)
DIGITAL_D1_L: length 4.3
  TOP w0.102: L3402.2 39.45,128.94 39.45,129.49 39.35,129.6 39.35,130.19 C3411.1 40.22,131.05 v2(40.22,131.37)
  BOTTOM w0.102: v2(40.22,131.37) 40.15,131.44 CN3400.7
DPB_DDCCLK: length 111.7
  TOP w0.102: U3501.31 212.97,92.95 212.87,93.04 212.87,93.19 R3512.2 213.19,93.79 212.99,93.99 212.99,94.26 213.18,94.46 213.18,95.09 212.93,95.34 211.02,95.34 210.6,95.76 210.6,98.2 208.97,99.83 208.37,99.83 v2(208.11,100.08)
  IN1 w0.079: v1(131.71,97.11) 131.71,97.26 131.62,97.35 131.51,97.35 131.16,97.7 131.16,99.17 130.98,99.35 130.98,100.13 130.93,100.19 130.93,100.21
  IN1 w0.127: 130.93,100.21 130.93,101.99 129.57,103.34 129.57,107.64 129.99,108.06 132.2,108.06 132.66,108.51 140.09,108.51 143.25,111.68 155.97,111.68 156.89,110.75 158.82,110.75 162.63,106.94 163.57,106.94 165.05,105.47 166.98,105.47 167.66,104.78 177.15,104.78 177.79,104.14 183.81,104.14 184.86,105.19 189.69,105.19 190.41,104.48 194.84,104.48 197.53,101.78 201,101.78 201.96,102.75 205.29,102.75 205.98,102.06 205.98,100.39 206.48,99.88 207.91,99.88 v2(208.11,100.08)
  BOTTOM w0.079: U400.CC8 v1(131.71,97.11)
DPB_DDCDATA: length 110.9
  TOP w0.102: v2(208.11,99.45) 208.28,99.61 208.88,99.61 210.38,98.11 210.38,95.67 210.93,95.13 212.84,95.13 212.96,95 212.96,94.55 212.77,94.35 212.77,93.97 212.58,93.79 R3513.2 212.66,93.53 212.66,93.07 212.57,92.98 U3501.32
  IN1 w0.079: v1(132.52,97.24) 132.09,97.24 131.81,97.52 131.58,97.52 131.33,97.77 131.33,99.24 131.15,99.42 131.15,100.13 131.2,100.19 131.2,100.21
  IN1 w0.127: 131.2,100.21 131.2,102.11 129.85,103.46 129.85,107.52 130.11,107.78 132.32,107.78 132.77,108.23 140.21,108.23 143.37,111.4 155.85,111.4 156.78,110.47 158.71,110.47 162.52,106.66 163.46,106.66 164.93,105.19 166.86,105.19 167.55,104.5 177.03,104.5 177.67,103.86 183.92,103.86 184.98,104.91 189.57,104.91 190.29,104.2 194.72,104.2 197.42,101.5 201.11,101.5 202.08,102.47 205.18,102.47 205.7,101.95 205.7,100.27 206.37,99.6 207.96,99.6 v2(208.11,99.45)
  BOTTOM w0.079: U400.CC9 132.19,96.91 v1(132.52,97.24)
DPC_DDCCLK: length 6.5
  BOTTOM w0.079: R526.1 137,104.21 136.57,104.21 134.49,102.14 134.49,100.87 134.76,100.6 U400.CH4
DPC_DDCDATA: length 6.2
  BOTTOM w0.079: R528.1 137.6,104.05 136.64,104.05 134.76,102.16 U400.CH3
DPWROK: length 274.7
  TOP w0.079: 126.86,81.64 127.25,82.03 127.25,83.15 v1(126.91,83.5)
  TOP w0.102: U4701.E7 203.6,52.96 v3(203.28,52.63) ; v2(53.83,51.92) 54,51.75 57.95,51.75 59.13,50.56 102.82,50.56 104.87,48.51 116.95,48.51 117.8,47.66 143.78,47.66 144.54,48.41 170.25,48.41 177.69,55.85 v2(177.84,55.85) 179.5,57.5 185.34,57.5 v2(185.51,57.33) ; 126.86,81.64 126.58,81.35 126.58,80.18 126.74,80.02 126.74,76.98 127.08,76.64 127.08,75.45 126.95,75.32 126.95,74.54 127.03,74.46 R464.2 127.54,74.46 127.85,74.15 127.85,72.65 127.44,72.25 127.44,70.06 128.77,68.73 128.96,68.54 128.96,67.66 129.68,66.95 131.03,66.95 134.12,63.86 148.86,63.86 149.56,64.57 155.7,64.57 155.99,64.85 167.47,64.85 167.64,65.02 167.64,65.66 167.97,66 168.41,66 168.61,65.79 168.61,65 168.76,64.85 169.57,64.85 v2(169.77,64.65) ; v2(40.88,77.53) 41.26,77.91 42.91,77.91 43.3,78.3 PR8122.1 43.3,79.8 42.03,81.07 PU8102.4
  IN1 w0.076: v3(203.28,52.63) 203.08,52.63 202.75,52.96 202.5,52.96 202.3,53.17 202.3,53.42 202.29,53.42 202.1,53.62 201.67,53.62 201.31,53.97 201.31,54.5 200.63,55.18 200.03,55.18 199.82,54.96 199.38,54.96 198.97,55.38 198.51,55.38 198.46,55.33 197.14,55.33
  IN1 w0.114: v2(185.51,57.33) 185.89,57.33 186.32,56.9 187.16,56.9 188.91,58.66 190.89,58.66 194.22,55.33 197.14,55.33
  BOTTOM w0.102: v2(40.88,77.53) 41.26,77.15 42.85,77.15 49.34,70.66 49.34,62.92 49.89,62.36 49.89,60.86 50.33,60.43 50.33,59.37 51.68,58.02 51.68,56.6 52.46,55.82 52.46,54.51 53.83,53.14 v2(53.83,51.92) ; v2(177.84,55.85) 177.84,56.37 172.48,61.73 171.82,61.73 170.37,63.18 170.37,64.11 169.83,64.65 v2(169.77,64.65) ; U400.BP30 126.53,83.87 v1(126.91,83.5)
DSR: length 2.1
  TOP w0.102: R7501.2 v2(51.87,59.24) U7500.4
EC_PECI: length 193.5
  TOP w0.102: v2(217.5,53.16) 216.86,52.51 215.32,52.51 214.98,52.17 214.04,52.17 R4714.1
  IN2 w0.127: v2(220.96,64.09) 220.3,64.09 213.17,71.22 213.17,77.71 210.98,79.89 210.98,82.58 210.19,83.37 210.19,85.78 210.75,86.34 210.75,87.23 212.05,88.52 212.05,89.5 212.35,89.8 212.35,92.74 212.04,93.05 212.04,94.66 209.87,96.83 209.87,97.08 207.96,98.99 203.86,98.99 202.31,100.54 201.32,101.53 200.89,101.53 199.57,102.85 198.82,102.85 196.5,105.16 196.5,106.79 195.53,107.76 193.4,107.76 191.52,109.63 191.52,111.33 191.4,111.46 186.3,111.46 185.12,112.64 176.91,112.64 175.72,111.46 172.29,111.46 171.56,112.18 168.85,112.18 165.05,115.98 163.13,115.98 157.64,121.47 155.71,121.47 155.43,121.75 151.93,121.75 151.37,121.19 143.69,121.19 142.72,120.22 141.6,120.22 141.14,120.68 132.11,120.68 131.34,121.45 126.58,121.45 126.01,120.88 121.69,120.88 118.08,117.27 115.72,117.27 115.43,116.98 110.36,116.98 v2(108.52,115.14)
  BOTTOM w0.079: U400.AR1 114.67,103.3 114.15,103.82 114.15,105.65 114.03,105.77 114.03,106.89 114.41,107.27 114.67,107.27 114.77,107.38
  BOTTOM w0.102: 114.77,107.38 114.77,111.91 114.59,112.09 114.59,113.11 113.7,114 109.66,114 v2(108.52,115.14) ; v2(217.5,53.16) 217.76,53.16 218.23,53.63 218.39,53.63 220.84,56.07 220.84,63.96 v2(220.96,64.09)
EC_PECI_R: length 7.5
  TOP w0.076: v2(214.64,52.6) 214.38,52.86 213.33,52.86 R4714.2 212.78,52.48 212.04,53.22 211.58,53.22 C4723.2 210.63,53.2 208.4,53.2 U4701.M7
EC_SLP_LAN#: length 24
  TOP w0.102: v2(199.47,48.65) 199.07,48.65 198.71,49 198.71,49.41 198.48,49.64 197.24,49.64 197.11,49.51 195.64,49.51 194.9,50.25 R4767.2 ; v3(203.28,54.59) 202.96,54.91 U4701.D10
  IN2 w0.076: v3(205.88,50.03) 205.88,50.15 206.2,50.47 206.2,51.63 205.97,51.86 205.56,51.86 205.02,52.4 205.02,52.75 204.81,52.96 204.38,52.96 204.25,53.09 204.25,54.74 204.09,54.9 203.68,54.9 203.36,54.59 v3(203.28,54.59)
  BOTTOM w0.076: 204.77,49.5 204.99,49.71 205.56,49.71 v3(205.88,50.03)
  BOTTOM w0.102: v2(199.47,48.65) 199.75,48.37 199.75,46.99 199.84,46.9 201.26,46.9 201.46,47.1 201.46,47.93 202.6,49.08 204.35,49.08 204.77,49.5
EDIDCLK_R: length 6.4
  TOP w0.097: v2(32.95,129.89) 33.21,129.62 33.21,128.86 R3413.2 33.04,128.42 33.29,128.17 33.29,127.88 C3419.1
  BOTTOM w0.097: v2(32.95,129.89) 33.16,130.1 33.16,130.44 33.85,131.14 33.85,131.64 33.65,131.84 CN3400.20
EDIDDATA_R: length 6.4
  TOP w0.097: v2(33.67,129.89) 33.41,129.63 33.41,128.93 R3412.2 33.73,128.42 33.49,128.17 33.49,127.88 C3418.1
  BOTTOM w0.097: CN3400.19 34.15,131.87 34.05,131.77 34.05,131.06 33.35,130.36 33.35,130 33.47,129.89 v2(33.67,129.89)
EDP_DISP_UTIL: length 10.9
  BOTTOM w0.079: 112.07,107.38 112.07,107.32 112.38,107.02 112.38,104.83 112.76,104.45 112.76,101.66 112.5,101.4 112.5,100.44 113.15,99.79 113.15,99.4 113.4,99.15 113.4,98.66 112.94,98.21 U400.AM7
  BOTTOM w0.102: TP417.1 112.07,107.38
EDP_RCOMP: length 8.3
  BOTTOM w0.079: U400.AM6 112.64,98.86 112.25,99.24 112.25,99.62 111.93,99.95 111.93,101.71 112.1,101.88 112.38,101.88 112.5,102.01 112.5,102.92 112.51,102.93 112.51,103.13 112.43,103.21
  BOTTOM w0.254: R543.2 v2(111.87,105.14) 111.87,103.77 112.43,103.21
EDRAM_OPIO_RCOMP: length 13.3
  BOTTOM w0.079: 95.16,104.02 95.31,104.02 95.78,103.55 96.26,103.55 96.53,103.28 96.53,102.49 96.64,102.38 96.64,100.53 97.2,99.97 98.11,99.97 98.28,99.8 99.15,99.8 99.19,99.76 99.56,99.76 U400.L5
  BOTTOM w0.102: 95.16,104.02 94.85,104.02 94.13,104.74 94.13,107.87 TP400.1
EMU_LID: length 325
  TOP w0.076: U4701.G2 v3(205.23,50.03)
  TOP w0.102: R3402.2 25.79,122.77 25.31,122.29 25.31,120.9 20.15,115.74 20.15,114.07 18.8,112.73 18.8,104.68 20.18,103.31 20.18,92.38 30.72,81.84 30.72,79.69 33.13,77.27 36.3,77.27 37.19,76.38 42.27,76.38 42.53,76.64 44.61,76.64 v2(44.84,76.41)
  IN1 w0.114: v2(44.84,76.41) 44.83,76.4 44.83,66.88 44.31,66.36 44.31,59.89 43.56,59.14 43.56,55.12 43.23,54.79 43.23,50.42 43.81,49.83 43.81,47.4 43.34,46.93 43.34,44.85 43.95,44.24 43.95,38.81 48.37,34.39 48.37,31.98 50.22,30.13 51.65,30.13 52.41,30.89 54.17,30.89 54.72,30.34 58.56,30.34 58.64,30.25 60.59,30.25 61.66,31.32 66.59,31.32 67.12,31.85 82.29,31.85 82.68,31.46 87.36,31.46 87.99,32.08 101.39,32.08 102.02,32.71 103,32.71 103.25,32.47 113.23,32.47 113.68,32.02 118.85,32.02 120.56,30.3 127.08,30.3 128,29.38 128.71,29.38 129.03,29.06 129.72,29.06 131.04,27.74 131.04,22.45 132.12,21.37 133.73,21.37 136.69,18.41 136.69,17.43 138.67,15.45 142.41,15.45 143.44,14.42 153.28,14.42 154.83,12.86 162.6,12.86 163.91,14.17 186.71,14.17 188.81,12.07 v2(189.57,12.07)
  IN2 w0.076: v3(205.23,50.03) 205.35,50.03 205.77,49.61 205.77,48.85 206.61,48.01 206.61,47.74 207.04,47.31 207.04,46.63 206.98,46.58 206.98,46.44
  IN2 w0.114: 206.98,46.44 206.98,40.86 205.55,39.42 205.55,33.72 203.77,31.95 203.77,19.17 202.69,18.09 202.69,14.87 201.25,13.42 200.77,13.42 199.08,11.73 195.38,11.73 194.73,11.09 193.8,11.09 193.58,11.31 190.33,11.31 v2(189.57,12.07)
EN_1V0A: length 5.3
  TOP w0.102: R3309.2 125.81,121.91 126.66,121.06 R3310.2 127.02,121.33 C3301.1 127.02,122.29 v2(127.47,122.74)
  BOTTOM w0.102: v2(127.47,122.74) 127.63,122.9 PR9207.2
EN_1V8: length 2.1
  BOTTOM w0.102: v2(154.54,21.22) 154.79,21.48 R3307.2
  BOTTOM w0.203: PR9305.1 155.63,21.65 R3307.2
EN_3V: length 3.7
  BOTTOM w0.102: PR8602.1 174.93,23.92 174.53,24.31 174.53,25.01 174.26,25.29 R3305.2 173.81,25.29 173.22,24.7 v2(173.22,24.46)
EN_5V: length 2.1
  BOTTOM w0.102: PR8628.1 196.78,22.37 R3304.2 197.67,22.37 v2(197.98,22.68)
EN_5V_3V: length 335
  TOP w0.102: v2(43.61,75.68) 36.42,75.68 35.98,75.24 33.6,75.24 29.7,79.14 29.7,81.85 17.2,94.35 17.2,96.29 14.72,98.78 R3300.2 ; v2(177.29,19.81) 178.11,19 183,19 183.43,19.42 183.91,19.42 184.4,18.93 191.62,18.93 196.18,23.48 v2(196.18,23.57) ; v2(49.34,62.06) 51.13,62.06 R7500.2 R7508.1
  IN2 w0.114: v2(177.29,19.81) 174.92,19.81 174.69,19.57 171.02,19.57 170.74,19.85 167.96,19.85 166.91,18.81 156.74,18.81 156.41,18.48 155.65,18.48 v2(155.43,18.7) 155.21,18.48 149.55,18.48 149,19.02 143.87,19.02 140.76,22.14 139.35,22.14 137.77,23.72 136.14,23.72 135.42,24.44 135.3,24.44 134.51,25.23 134.51,27.56 133.62,28.45 132.21,28.45 130.25,30.41 130.25,30.67 129.43,31.49 127.95,31.49 126.29,33.15 122.12,33.15 118.07,37.2 114.51,37.2 113.99,36.68 108.13,36.68 107.57,37.25 84.76,37.25 83.9,36.38 67.93,36.38 64.81,33.26 61.96,33.26 61.24,33.97 60.5,33.97 59.8,34.68 51.84,34.68 51.35,35.16 49.83,35.16 45.47,39.52 45.47,43.28 49.17,46.98 49.17,48.61 48.83,48.95 48.83,53.97 49.94,55.08 51.61,55.08 v2(51.61,55.08) ; v2(43.61,75.68) 43.61,75.84 44.97,77.2 51.37,77.2 v2(53.63,79.45)
  BOTTOM w0.102: R3304.1 196.96,23.35 196.39,23.35 v2(196.18,23.57) ; R3305.1 173.77,24.23 173.77,23.36 174.6,22.53 174.6,21.2 174.71,21.09 174.71,20.65 174.91,20.44 174.91,19.93 175.35,19.49 176.98,19.49 v2(177.29,19.81) ; v2(51.61,55.08) 51.41,55.28 51.41,58 50.13,59.28 50.13,60.34 49.34,61.13 v2(49.34,62.06) 49.13,62.26 49.13,70.58 44.03,75.68 v2(43.61,75.68) ; U5401.3 37.53,114.62 37.35,114.43 36.51,114.43 36.18,114.76 R5404.2 35.7,114.4 35.7,112.37 36.23,111.84 37.76,111.84 38.12,111.48 38.74,111.48 39.09,111.84 40.39,111.84 41.54,110.7 41.54,109.33 41.89,108.97 41.89,106.1 44.52,103.47 44.52,97.35 47.78,94.09 47.78,92 48.48,91.3 50,91.3 51.6,92.89 53.92,92.89 54.49,92.33 54.49,80.31 v2(53.63,79.45) ; v2(155.43,18.7) 155.43,19.89 155.46,19.92 R3307.1
EN_VRPVDDQ: length 6.6
  BOTTOM w0.102: R3303.1 PR8701.1 146.52,11.47 146.3,11.24 145.42,11.24 145.24,11.07 145.24,10.66 146.71,9.19 D3300.2 146.71,7.84 v2(146.77,7.79)
EN_VRPVTT: length 2.7
  BOTTOM w0.102: PR8703.1 148.45,12.76 149.23,11.97 R3306.2 149.95,11.72 v2(150.04,11.64)
EOPIO_RCOMP: length 12.3
  BOTTOM w0.079: 95.11,104.22 95.44,104.22 95.92,103.74 96.45,103.74 97.28,102.91 97.28,100.73 97.47,100.55 97.77,100.55 98.35,99.97 99.22,99.97 99.26,99.93 100.32,99.93 U400.N5
  BOTTOM w0.102: 95.11,104.22 94.98,104.22 94.42,104.78 94.42,106.86 TP402.1
EQ: length 4
  TOP w0.102: R3507.1 213.35,83.5 213.35,84.29 213.37,84.31 R3508.1 213.7,85.02 213.71,85.02 213.83,85.14 213.83,85.86 213.7,85.98 213.26,85.98 212.97,86.28 U3501.13
ESDIO_RCOMP: length 10.4
  TOP w0.254: v1(136.2,81.31) 136.2,80.93 138.29,78.84 140.36,78.84 140.68,78.52 142.93,78.52 v2(143.09,78.36)
  BOTTOM w0.254: v2(143.09,78.36) 143.27,78.54 R575.1 ; 136.22,81.31 136.24,81.29 136.61,81.29 U400.CM34 ; 136.22,81.31 135.95,81.57 U400.CK33 ; 136.22,81.31 v1(136.2,81.31)
