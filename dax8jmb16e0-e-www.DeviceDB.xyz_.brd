# Allegro board dax8jmb16e0-e-www.DeviceDB.xyz_.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
THERMDA_1: length 60.4
  TOP w0.102: C5406.1 170.62,99.24 174.35,95.52 174.46,95.52 175.18,94.79 v2(175.18,94.37) ; v2(182.57,81.06) 182.57,80.55 181.96,79.94 180.08,79.94 179.08,78.95 179.08,77.71 179.57,77.22 179.57,74.99 178.52,73.94 178.52,70.65 179.08,70.08 179.08,69.38 178.94,69.24 177.98,69.24 176.56,67.83 176.56,66.6 174.34,64.38 174.34,62.85 173.82,62.33 173.82,61.63 173.46,61.27 Q5401.3 171.53,61.27 Q5401.2
  TOP w0.114: C5406.1 170.09,98.83 169.47,98.83 169.12,99.19 169.12,99.7 168.29,100.53 168.29,100.86 168.08,101.08 U5400.2
  IN1 w0.114: v2(175.18,94.37) 175.5,94.37 176.93,92.94 179.36,92.94 181.14,91.17 181.14,90.51 181.95,89.69 181.95,88.09 184.08,85.96 184.08,85.53 183.85,85.3 183.85,82.25 183.14,81.54 183.05,81.54 v2(182.57,81.06)
THERMDC_1: length 61.9
  TOP w0.102: v2(183.03,80.61) 182.15,79.74 180.16,79.74 179.29,78.86 179.29,77.79 179.77,77.31 179.77,74.91 178.72,73.85 178.72,70.73 179.28,70.17 179.28,69.27 179.05,69.04 178.06,69.04 176.77,67.75 176.77,66.52 176.73,66.49 175.78,65.53 175.48,65.23 175.26,65.02 175.26,63.49 174.02,62.25 174.02,61.33 173.75,61.06 173.02,60.33 172.46,60.33 172.26,60.53 170.79,60.53 Q5401.1 ; v2(176.14,94.38) 176.14,94.9 175.25,95.8 174.6,95.8 170.67,99.73 170.2,99.73 C5406.2 169.4,99.57 169.4,99.72 168.5,100.62 168.5,101.49 168.26,101.73 U5400.3
  IN1 w0.114: v2(183.03,80.61) 183.22,80.61 184.11,81.5 184.11,85.23 184.34,85.46 184.34,86.05 182.19,88.19 182.19,89.79 181.38,90.61 181.38,91.27 179.43,93.21 177.83,93.21 177.69,93.35 177.17,93.35 v2(176.14,94.38)
TLS_ENCRYPTION: length 16.1
  TOP w0.102: R424.2 149.44,93.52 v2(145.5,93.52) 144.9,92.92 144.41,92.92 144.25,93.08 143.66,93.08 143.19,92.61 142.39,92.61 142.15,92.85 140.91,92.85 140.54,92.48 138.11,92.48 137.52,93.07 136.13,93.07 v1(135.8,92.74)
  BOTTOM w0.079: v1(135.8,92.74) 135.51,93.02 U400.CJ15
TOUCH_INT#: length 228.1
  TOP w0.102: v2(25.81,126.38) 25.81,127.17 24.57,128.41 R3420.2
  IN1 w0.114: v2(25.81,126.38) 25.86,126.33 26.45,126.33 26.58,126.19 27.3,126.19 28.08,125.41 28.33,125.41 29.15,124.59 32.47,124.59 33.19,125.3 36.48,125.3 36.5,125.32 42.08,125.32 42.5,124.9 46.59,124.9 48.03,126.34 51.3,126.34 51.91,126.95 56.93,126.95 57.56,127.58 71.11,127.58 72.5,126.2 73.37,126.2 73.57,125.99 77.13,125.99 78.96,124.15 81.34,124.15 84.37,121.13 107.21,121.13 108.37,119.97 111.34,119.97 112.09,120.73 113.05,120.73 114.41,122.08 115.16,122.08 115.91,121.33 119.03,121.33 119.63,121.94 125.9,121.94 127.3,123.33 129.1,123.33 129.28,123.15 132.16,123.15 132.4,123.38 133.4,123.38 135.44,121.34 141.28,121.34 141.96,122.02 142.71,122.02 144.08,120.65 148.61,120.65 151.34,123.37 157.92,123.37 160.26,121.03 160.26,119.66 160.95,118.96 160.95,117.05 161.26,116.74 161.26,113.6 166.2,108.66 168.99,108.66 v2(169.19,108.46)
  IN2 w0.114: v2(169.4,92.51) 168.24,92.51 167.68,91.95 162.7,91.95 162.06,91.32 160.38,91.32 160.05,91.65 158.13,91.65 157.67,92.11 156.83,92.11 155.67,93.27 154.9,93.27 154.29,92.66 151.96,92.66 151.85,92.55 150.28,92.55 149.11,93.72 147.07,93.72 146.21,94.58 145.71,94.58 144.37,95.92 143.55,95.92 143.3,95.66 143.3,95.44 142.21,94.35 142.21,94.17 v2(141.94,93.9)
  BOTTOM w0.079: v2(141.94,93.9) 141.85,93.9 141.35,94.39 141.01,94.39 140.97,94.43 140.02,94.43 139.94,94.5 138.94,94.5 138.92,94.48 138.59,94.48 138.5,94.43 138.46,94.39 138.46,94.39 138.38,94.32 137.16,94.32 U400.CM14
  BOTTOM w0.102: v2(25.81,126.38) 24.37,127.83 24.37,130.23 24.15,130.44 24.15,130.77 24,130.92 24,131.73 24.15,131.88 CN3400.39 ; v2(169.19,108.46) 169.17,108.45 169.17,106.55 170.79,104.93 170.79,98.02 169.65,96.88 169.65,94.53 169.85,94.33 169.85,93.66 169.4,93.2 v2(169.4,92.51)
TOUCH_RST#: length 279.7
  TOP w0.079: v1(134.37,93.76) 134.37,93.82 134.96,94.4 136.86,94.4 137.14,94.68
  TOP w0.102: R3428.2 30.45,130.73 30.04,130.31 v2(30.04,128.85) ; v2(153.35,96.1) 152.99,96.1 152.57,96.52 152.13,96.52 151.7,96.96 149.93,96.96 149.93,96.96 148.92,96.96 148.89,97 145.74,97 145.31,97.42 141.93,97.42 141.45,96.94 140.76,96.94 140.66,96.83 139.8,96.83 139,96.03 138.49,96.03 137.14,94.68 ; v2(149.73,122.57) 149.95,122.36 149.95,121.87 155.09,116.73 155.09,115.33 159.3,111.11 164.01,111.11 171.44,103.68 172.91,103.68 178.16,98.44 181.26,98.44 182.64,97.05 185.14,97.05 190.47,91.72 190.47,90.17 190.74,89.9 190.74,87.85 v2(190.53,87.65)
  IN1 w0.114: v2(88.37,135.6) 87.95,135.17 87.95,133.83 88.12,133.66 88.37,133.66 88.62,133.41 88.62,132.06 88.56,131.99 88.56,130.4 84.9,126.75 81.12,126.75 78.71,129.15 75.31,129.15 75.22,129.07 74.22,129.07 73.62,129.67 72.78,129.67 72.31,129.19 58.39,129.19 57.88,129.7 52.07,129.7 51.75,129.38 41.76,129.38 41.11,130.03 39.59,130.03 39.41,129.85 35.47,129.85 33.99,128.37 31.76,128.37 31.22,128.91 30.09,128.91 v2(30.04,128.85)
  IN2 w0.114: v2(190.53,87.65) 191.34,88.45 191.34,89.48 190.87,89.95 190.5,90.31 189.61,90.31 184.97,94.95 174.32,94.95 173.92,94.55 173.92,94.01 173.67,93.76 173.1,93.76 172.68,94.18 172.68,94.49 171.73,95.44 167.44,95.44 166.67,94.68 162.24,94.68 161.69,95.22 159.15,95.22 157.44,96.93 154.18,96.93 v2(153.35,96.1) ; v2(149.73,122.57) 149.73,122.61 149.28,123.07 149.28,123.66 148.89,124.05 147.84,124.05 146.83,123.04 133.77,123.04 133.11,122.38 132.63,122.38 132.03,122.99 129.28,122.99 128.59,123.68 127.16,123.68 126.48,123 121.1,123 117.28,119.18 114.92,119.18 114.64,118.9 106.88,118.9 106.35,119.43 104.83,119.43 100.32,123.95 91.88,123.95 90.98,124.84 90.98,126.78 89.04,128.72 89.04,134.93 v2(88.37,135.6)
  BOTTOM w0.079: U400.CG14 134.21,93.92 v1(134.37,93.76)
  BOTTOM w0.102: CN3400.26 30.65,131.84 30.49,131.68 30.49,131.53 30.34,131.37 30.34,129.15 v2(30.04,128.85)
TP_SCAN_DISABLE#: length 208
  TOP w0.102: U4701.D8 202.96,53.61 v3(203.28,53.28)
  IN1 w0.114: v2(190.21,12.92) 189.77,13.36 188.61,13.36 187.1,14.86 163,14.86 162.42,14.28 160.48,14.28 159.76,13.56 155.12,13.56 153.57,15.12 143.73,15.12 142.7,16.15 139.6,16.15 133.92,21.83 132.31,21.83 131.5,22.64 131.5,27.93 129.91,29.52 129.22,29.52 128.7,30.03 128.7,30.21 128.16,30.76 120.75,30.76 119.04,32.47 113.87,32.47 113.41,32.93 103.44,32.93 103.19,33.17 101.83,33.17 101.2,32.54 87.8,32.54 87.17,31.91 82.89,31.91 82.49,32.31 66.93,32.31 66.4,31.78 60.19,31.78 v2(59.32,30.91)
  IN2 w0.076: 205.28,46.44 205.25,46.47 204.78,46.47 204.4,46.85 204.4,48.29 203.64,49.05 203.64,50.52 203.61,50.55 203.61,52.75 203.28,53.08 v3(203.28,53.28)
  IN2 w0.114: v2(190.21,12.92) 190.44,12.92 191.35,12.01 192.77,12.01 193.19,12.43 197.62,12.43 200.13,14.94 200.13,15.52 201.88,17.27 201.88,18.25 203.06,19.44 203.06,32.21 204.86,34 204.86,39.72 206.3,41.16 206.3,45.42 205.28,46.44
  BOTTOM w0.102: v2(59.32,30.91) 57.87,29.46 D6200.2 57.87,27.97 58.02,27.82 58.4,27.82 58.66,28.07 58.66,29.21 58.91,29.46 R6213.2 59.45,29.46 60.51,28.4 CN6200.8
TPCLK-1: length 5.7
  BOTTOM w0.102: R6211.2 61.43,31.58 61.43,30.76 C6202.1 61.58,30.65 61.8,30.87 v2(62.2,30.87) 62.2,30.47 61.78,30.05 61.78,28.61 61.51,28.33 CN6200.6
TPDATA-1: length 4.7
  BOTTOM w0.102: R6212.2 62.72,31.03 C6203.1 62.58,30.12 62.58,29.87 v2(62.28,29.58) 62.15,29.45 62.15,28.44 62.01,28.3 CN6200.5
TPM_PIRQ#: length 81.9
  TOP w0.102: U5100.18 173.42,70.23 173.74,69.91 173.74,69.6 173.22,69.08 173.22,68.2 R5100.2 173.26,67.43 173.26,66.51 v2(173.23,66.47) ; v2(161.85,87.72) 161.85,88.28 161.45,88.68 161.45,89.02 161.22,89.25 159.62,89.25 159.3,89.57 159.17,89.57 158.79,89.95 158.2,89.95 155.51,87.25 152.36,87.25 151.71,87.9 150.72,87.9 150.47,87.66 147.08,87.66 145.96,88.78 143.7,88.78 v2(143.13,88.2) 142.97,88.05 140.42,88.05 140.12,87.76 138.24,87.76 137.31,88.68 135.41,88.68 135.17,88.92 134.18,88.92 133.27,88 133.27,87.33 133.6,87 134.15,87 v1(134.58,86.58)
  IN1 w0.114: v2(161.85,87.72) 161.93,87.64 161.93,86.28 162.71,85.5 165.84,85.5 166.12,85.22 167.42,85.22 167.88,85.68 168.69,85.68 169.06,86.05 171.03,86.05 171.99,85.1 171.99,81.84 173.78,80.05 176.69,80.05 178.14,78.6 178.14,77.74 177.63,77.23 177.63,73.06 177.02,72.45 176,72.45 175.37,71.81 174.9,71.81 174.63,71.54 174.63,70.75 175.64,69.74 175.64,67.61 174.84,66.81 174.25,66.81 174.1,66.96 173.72,66.96 v2(173.23,66.47)
  BOTTOM w0.079: v1(134.58,86.58) 134.58,86.59 U400.CG25
TPM_PLTRST#: length 7.7
  TOP w0.114: Q5100.3 170.2,67.64 170.42,67.42 170.42,67.24 170.54,67.11 170.54,66.86 170.85,66.55 R5103.1 R5106.2 170.97,67.61 171.84,68.48 172.69,68.48 172.91,68.7 172.91,69.35 v2(173.3,69.74) 172.74,69.74 172.73,69.73 U5100.17
TPM_PP: length 3.3
  TOP w0.102: R5105.1 166.16,70.88 R5107.1 166.88,70.23 U5100.7
TRA_V_DAC: length 5.9
  BOTTOM w0.508: U4001.1 211.1,65.17 210.55,65.72 v2(210.55,65.82) ; U4001.4 210.9,68.17 v2(210.52,68.55) ; v2(210.51,70.75) 210.93,71.17 U4001.7 ; U4001.10 v2(210.56,74.17)
TX0_HDMI+: length 37.9
  TOP w0.097: CN3500.7 231.16,72.73 231.07,72.73 230.95,72.85 230.95,76.18 230.21,76.91 229.53,76.91 229.31,77.13 229.31,77.69 R3502.1 229.29,78.25 229.29,79.71 229.02,79.99 229.02,84.56 227.97,85.6 227.97,87.51 228.51,88.05 v2(228.51,88.05) 227.95,88.61 227.95,89.6 227,90.55 227,92.06 226.57,92.49 225.44,92.49 224.76,91.81 224.76,90.87 224.26,90.38 222.67,90.38 222.2,90.85 222.2,91.15 221.91,91.44 220.13,91.44 219.33,90.64 219.14,90.64 218.99,90.49 218.41,90.49 218.12,90.2 217.34,90.2 216.64,89.5 215.4,89.5 215.28,89.62 U3501.22
TX0_HDMI-: length 37.9
  TOP w0.097: U3501.21 215.32,89.22 215.4,89.3 216.72,89.3 217.42,90 218.2,90 218.49,90.29 219.08,90.29 219.22,90.44 219.41,90.44 220.21,91.24 221.83,91.24 222,91.07 222,90.77 222.58,90.18 224.35,90.18 224.96,90.79 224.96,91.73 225.52,92.3 226.48,92.3 226.8,91.98 226.8,90.47 227.75,89.52 227.75,88.57 227.24,88.06 v2(227.24,88.05) 227.78,87.51 227.78,85.52 228.82,84.48 228.82,79.91 229.1,79.63 229.1,78.25 R3502.2 229.12,77.64 229.12,77.04 229.45,76.71 230.13,76.71 230.75,76.09 230.75,72.77 230.99,72.53 231.14,72.53 CN3500.9
TX1_HDMI+: length 47.2
  TOP w0.097: U3501.24 215.29,90.42 215.37,90.34 216.81,90.34 217.19,90.72 217.79,90.72 217.96,90.89 217.96,91.01 v2(217.84,91.14)
  BOTTOM w0.097: CN3500.4 230,74.59 229.63,74.22 229.53,74.22 229.4,74.35 229.4,74.96 228.63,75.73 228.15,75.73 R3501.1 227.61,75.69 227.24,75.69 226.16,76.77 226.16,82.87 225.25,83.78 225.25,85.94 223.14,88.05 223.14,90.06 221.2,92 220.52,92 220.12,91.61 220.12,90.4 218.68,88.96 218.68,88.64 218.48,88.45 218.21,88.45 218.02,88.64 218.02,89.11 217.69,89.44 217.12,89.44 216.8,89.12 216.8,87.03 216.62,86.85 216.37,86.85 216.19,87.03 216.19,89.87 216.37,90.05 218.96,90.05 219.63,90.73 219.63,91.78 219.32,92.1 218.67,92.1 218.11,91.54 218.11,91.26 217.99,91.14 v2(217.84,91.14)
TX1_HDMI-: length 47.2
  TOP w0.097: U3501.23 215.29,90.02 215.41,90.14 216.89,90.14 217.27,90.52 217.87,90.52 v2(218.5,91.14)
  BOTTOM w0.097: CN3500.6 229.6,74.02 229.45,74.02 229.2,74.27 229.2,74.88 228.54,75.53 228.22,75.53 R3501.2 227.61,75.5 227.15,75.5 225.97,76.68 225.97,82.78 225.05,83.7 225.05,85.86 222.94,87.96 222.94,89.98 221.12,91.81 220.6,91.81 220.32,91.53 220.32,90.32 218.88,88.87 218.88,88.56 218.57,88.25 218.13,88.25 217.82,88.56 217.82,89.03 217.61,89.24 217.2,89.24 217,89.04 217,86.94 216.71,86.65 216.29,86.65 215.99,86.94 215.99,89.95 216.29,90.25 218.87,90.25 219.44,90.81 219.44,91.7 219.23,91.9 218.75,91.9 218.31,91.46 218.31,91.33 v2(218.5,91.14)
TX2_HDMI+: length 49.2
  TOP w0.097: U3501.27 215.43,91.62 215.7,91.89 217.67,91.89 217.94,92.16 217.94,92.3 v2(217.71,92.52)
  BOTTOM w0.097: CN3500.1 231.12,75.69 230.82,75.69 230.79,75.73 230.79,76.71 230.05,77.45 228.19,77.45 R3500.1 227.61,77.45 227.04,77.45 226.91,77.58 226.91,78.17 227,78.27 229.68,78.27 229.97,78.56 229.97,78.98 229.68,79.27 227,79.27 226.91,79.37 226.91,79.78 227,79.87 228.18,79.87 228.47,80.17 228.47,80.58 228.18,80.87 227,80.87 226.91,80.97 226.91,83.09 227.06,83.24 227.52,83.24 227.78,83.5 227.78,83.87 227.52,84.14 226.07,84.14 225.93,84.28 225.93,84.47 226.07,84.61 227.53,84.61 227.79,84.87 227.79,85.23 227.53,85.49 226.07,85.49 225.93,85.63 225.93,85.83 226.07,85.96 227.53,85.96 227.84,86.28 227.84,86.73 227.53,87.05 225.1,87.05 223.85,88.29 223.85,90.31 220.94,93.22 218.22,93.22 218.02,93.03 218.02,92.83 v2(217.71,92.52)
TX2_HDMI-: length 49.2
  TOP w0.097: v2(218.37,92.52) 218.14,92.29 218.14,92.08 217.75,91.69 215.78,91.69 215.31,91.22 U3501.26
  BOTTOM w0.097: v2(218.37,92.52) 218.22,92.68 218.22,92.94 218.3,93.03 220.86,93.03 223.66,90.22 223.66,88.21 225.02,86.85 227.44,86.85 227.64,86.65 227.64,86.36 227.44,86.16 225.98,86.16 225.73,85.91 225.73,85.55 225.98,85.29 227.45,85.29 227.59,85.15 227.59,84.95 227.45,84.81 225.98,84.81 225.73,84.56 225.73,84.19 225.98,83.94 227.43,83.94 227.58,83.79 227.58,83.59 227.43,83.44 226.98,83.44 226.71,83.17 226.71,80.89 226.92,80.68 228.09,80.68 228.27,80.5 228.27,80.25 228.09,80.07 226.92,80.07 226.71,79.86 226.71,79.28 226.92,79.07 229.59,79.07 229.77,78.89 229.77,78.64 229.59,78.47 226.92,78.47 226.71,78.25 226.71,77.49 226.95,77.25 227.61,77.25 R3500.2 228.19,77.25 229.97,77.25 230.59,76.63 230.59,75.65 230.74,75.49 231.17,75.49 CN3500.3
TXC_HDMI+: length 41.2
  TOP w0.097: v2(220.84,90.65) 220.57,90.38 220.35,90.38 219.9,89.92 218.6,89.92 218.3,89.62 217.67,89.62 216.62,88.57 216.23,88.57 215.98,88.32 215.36,88.32 215.26,88.42 U3501.19
  BOTTOM w0.097: v2(220.84,90.65) 221.14,90.35 221.9,90.35 222.41,89.84 222.41,88.32 221.58,87.49 218.99,87.49 217.73,86.23 217.73,84.09 218.94,82.88 221.21,82.88 221.47,83.14 224.6,83.14 225.17,82.56 225.17,76.72 227.31,74.59 227.31,74.05 227.44,73.92 227.61,73.92 R3503.1 228.19,73.92 228.76,73.92 229.37,73.31 229.37,71.35 229.5,71.22 229.6,71.22 CN3500.10
TXC_HDMI-: length 41.2
  TOP w0.097: v2(220.84,89.89) 220.55,90.18 220.44,90.18 219.98,89.72 218.68,89.72 218.38,89.42 217.75,89.42 216.7,88.37 216.31,88.37 216.06,88.12 215.35,88.12 215.26,88.02 U3501.18
  BOTTOM w0.097: v2(220.84,89.89) 221.09,90.15 221.82,90.15 222.21,89.76 222.21,88.4 221.5,87.69 218.91,87.69 217.53,86.31 217.53,84 218.86,82.68 221.29,82.68 221.55,82.94 224.51,82.94 224.98,82.48 224.98,76.64 227.11,74.5 227.11,73.97 227.36,73.72 227.61,73.72 R3503.2 228.19,73.72 228.68,73.72 229.17,73.23 229.17,71.27 229.42,71.02 229.6,71.02 CN3500.12
TXLOUT0+: length 2.6
  TOP w0.097: C3416.1 37.64,130.6 37.56,130.68 37.56,131.11 v2(37.65,131.21)
  BOTTOM w0.097: CN3400.13 37.15,131.65 37.6,131.21 v2(37.65,131.21)
TXLOUT0-: length 2.6
  TOP w0.097: v2(37.02,131.22) 37.36,130.88 37.36,130.7 37.25,130.6 C3417.1
  BOTTOM w0.097: CN3400.14 36.65,131.87 37.02,131.51 v2(37.02,131.22)
TXLOUT1+: length 2.4
  TOP w0.097: C3414.1 35.52,130.93 35.52,131.13 v2(35.69,131.31)
  BOTTOM w0.097: CN3400.16 35.65,131.84 35.47,131.65 35.47,131.53 v2(35.69,131.31)
TXLOUT1-: length 2.5
  TOP w0.097: v2(35.01,131.31) 35.32,131 35.32,130.93 C3415.1
  BOTTOM w0.097: CN3400.17 35.15,131.77 35.27,131.65 35.27,131.56 v2(35.01,131.31)
TYPEC1_USB0: length 69.9
  TOP w0.127: PQ8008.3 199.07,86.47 199.12,86.52 v2(199.6,86.52) ; PR8246.2 192.42,97.01 v2(192.46,97.05)
  BOTTOM w0.127: v2(199.6,86.52) 199.73,86.52 200.26,87.05 201.91,87.05 202.55,87.69 205.29,87.69 205.9,87.08 205.9,85.48 207.7,83.67 210.83,83.67 211.26,83.24 212.99,83.24 215.38,85.63 215.38,92.54 216.98,94.14 217.79,94.14 v2(218.58,94.92) ; v2(192.46,97.05) 192.46,96.78 195.21,94.04 198.23,94.04 199.68,95.48 202.9,95.48 204.22,96.8 208.97,96.8 212.28,100.11 218.3,100.11 219.31,99.09 221.29,99.09 222.26,100.06 223.91,100.06 224.21,99.75 v2(224.39,99.75)
TYPEC3_RX1N: length 2.6
  TOP w0.097: U5800.31 208.98,108.38 210.07,107.29 210.18,107.29 210.32,107.42 C5828.1
TYPEC3_RX1N_C: length 41.2
  TOP w0.097: CN6300.B10 235.9,117.22 234.74,117.22 234.48,116.95 234.48,114.7 232.61,112.83 231.55,112.83 231.51,112.79 231.51,112.24 231.05,111.77 230.78,111.77 R6330.1 230.53,111.69 230.17,111.69 229.52,112.35 228.77,112.35 228.71,112.28 U6303.9 U6303.2 227.13,112.28 227.03,112.38 226.58,112.83 226.26,112.83 224.51,114.57 223.19,114.57 222.97,114.35 222.97,113.69 223.07,113.59 v2(223.2,113.59) ; C5828.2 211.1,107.22 211.23,107.09 211.66,107.09 212.05,107.48 v2(212.05,107.63)
  IN2 w0.114: v2(223.2,113.59) 223.15,113.59 222.98,113.75 222.98,114.09 222.64,114.43 219.42,114.43 218.98,113.98 218.11,113.98 217.63,114.46 215.72,114.46 215.37,114.11 212.05,114.11 210.41,112.46 210.41,110.43 212.09,108.75 212.09,107.67 v2(212.05,107.63)
TYPEC3_RX1P: length 2.6
  TOP w0.097: C5827.1 209.88,106.93 209.86,106.93 208.81,107.98 U5800.30
TYPEC3_RX1P_C: length 41.2
  TOP w0.097: C5827.2 211.29,106.69 211.82,106.69 v2(212.76,107.63) ; CN6300.B11 235.96,117.72 235.85,117.62 234.57,117.62 234.08,117.12 234.08,114.87 232.44,113.23 231.39,113.23 231.11,112.96 231.11,112.41 230.88,112.18 R6329.1 230.61,112.18 230.53,112.09 230.34,112.09 229.69,112.75 228.78,112.75 228.75,112.78 U6303.10 U6303.1 227.2,112.78 226.75,113.23 226.42,113.23 224.68,114.97 223.02,114.97 222.57,114.52 222.57,113.72 v2(222.44,113.59)
  IN2 w0.114: v2(212.76,107.63) 212.41,107.98 212.41,108.88 210.73,110.56 210.73,112.33 212.18,113.79 215.5,113.79 215.86,114.15 217.49,114.15 217.98,113.67 219.11,113.67 219.56,114.11 222.51,114.11 222.67,113.96 222.67,113.81 v2(222.44,113.59)
TYPEC3_RX2N: length 2.3
  TOP w0.097: C5830.1 209.77,112.55 209.67,112.55 209.54,112.42 209.54,111.97 209.15,111.58 208.33,111.58 U5800.39
TYPEC3_RX2N_C: length 32.9
  TOP w0.097: v2(220.3,113.59) 220.54,113.83 220.54,114.67 220.22,114.99 217.24,114.99 215.23,112.98 212.26,112.98 R6331.1 211.86,112.75 211.1,112.75 C5830.2
  BOTTOM w0.097: v2(220.3,113.59) 220.43,113.72 220.43,114.34 220.89,114.79 224.09,114.79 224.64,114.24 224.64,113.54 225.1,113.09 225.1,111.54 226.8,109.85 229.13,109.85 229.23,109.94 229.35,109.94 229.61,110.2 U6301.2 U6301.9 231.21,110.2 231.25,110.16 231.59,110.16 232.25,110.81 232.25,111.85 232.46,112.07 232.46,112.72 233.33,113.59 CN6300.A10
TYPEC3_RX2P: length 2.4
  TOP w0.097: U5800.40 208.96,111.98 209.14,112.16 209.14,112.58 C5829.1
TYPEC3_RX2P_C: length 32.9
  TOP w0.097: v2(221.06,113.59) 220.94,113.71 220.94,114.83 220.38,115.39 217.08,115.39 215.07,113.38 212.17,113.38 R6332.1 211.49,113.15 210.96,113.15 C5829.2
  BOTTOM w0.097: CN6300.A11 233.4,113.09 232.87,112.55 232.87,111.91 232.65,111.69 232.65,110.65 231.76,109.76 231.25,109.76 231.19,109.7 U6301.10 U6301.1 229.67,109.7 229.52,109.54 229.4,109.54 229.3,109.44 226.63,109.44 224.7,111.38 224.7,112.92 224.24,113.38 224.24,114.07 223.92,114.39 221.06,114.39 220.84,114.17 220.84,113.82 v2(221.06,113.59)
TYPEC3_TX1N: length 2.5
  TOP w0.097: U5800.34 208.74,109.58 208.97,109.81 210.34,109.81 210.41,109.74 210.41,109.56 C5816.2
TYPEC3_TX1N_C: length 39.2
  TOP w0.097: v2(213.05,109.59) 213.05,109.41 212.98,109.34 212.07,109.34 R6325.1 211.97,109.38 211.68,109.09 211.62,109.09 211.42,108.89 210.92,108.89 210.83,108.98 210.83,109.2 C5816.1
  BOTTOM w0.097: CN6300.A3 233.76,117.09 233.44,117.4 232.51,117.4 231.95,116.84 231.95,116.61 231.33,115.99 230.98,115.99 230.27,115.27 230.27,113.49 231.5,112.26 231.5,111.68 231.02,111.2 U6301.7 U6301.4 229.81,111.2 229.69,111.08 229.33,111.08 229.12,110.87 226.71,110.87 225.71,111.87 225.71,113.42 225.28,113.85 225.28,114.48 224.37,115.4 218.04,115.4 215.28,112.63 215.28,111.54 215.12,111.38 215.12,110.91 214.78,110.57 213.19,110.57 212.48,109.86 212.48,109.61 212.75,109.33 212.9,109.33 213.05,109.48 v2(213.05,109.59)
TYPEC3_TX1P: length 2.5
  TOP w0.097: C5815.2 210.31,108.6 209.85,109.06 209.5,109.41 209.13,109.41 208.91,109.18 U5800.33
TYPEC3_TX1P_C: length 39.2
  TOP w0.097: C5815.1 211.58,108.49 211.78,108.69 R6326.1 212.28,108.94 213.04,108.94 v2(213.05,108.93)
  BOTTOM w0.097: v2(213.05,108.93) 212.59,108.93 212.08,109.44 212.08,110.03 213.02,110.97 214.61,110.97 214.72,111.08 214.72,111.55 214.88,111.71 214.88,112.8 217.88,115.8 224.53,115.8 225.68,114.65 225.68,114.01 226.11,113.59 226.11,112.04 226.87,111.27 228.95,111.27 229.17,111.48 229.53,111.48 229.64,111.6 229.74,111.7 U6301.5 U6301.6 230.95,111.7 231.1,111.84 231.1,112.1 229.87,113.32 229.87,115.44 230.82,116.39 231.16,116.39 231.55,116.78 231.55,117.01 232.35,117.8 233.61,117.8 233.82,117.59 CN6300.A2
TYPEC3_TX2N: length 2.2
  TOP w0.097: C5820.2 210.03,110.7 209.27,110.7 208.95,110.38 U5800.36
TYPEC3_TX2N_C: length 32.2
  TOP w0.097: C5820.1 211.29,110.65 211.55,110.65 212.02,111.11 v2(212.55,111.11) ; v2(223.85,113.17) 223.94,113.17 224.22,113.46 224.76,113.46 225.5,112.73 225.5,112.69 226.91,111.28 U6303.4 U6303.7 228.65,111.28 228.7,111.24 229.28,111.24 229.72,110.8 229.88,110.8 R6328.1 229.96,110.72 231.73,110.72 232.1,111.09 232.1,111.68 233.95,113.53 235.97,113.53 CN6300.B3
  IN2 w0.114: v2(223.85,113.17) 223.85,113.03 223.54,112.73 222.26,112.73 221.95,113.04 217.89,113.04 217.31,113.61 216.07,113.61 215.72,113.26 212.36,113.26 211.64,112.53 211.64,111.59 212.01,111.22 212.44,111.22 v2(212.55,111.11)
TYPEC3_TX2P: length 2.2
  TOP w0.097: U5800.37 208.78,110.78 209.1,111.1 210,111.1 C5819.2
TYPEC3_TX2P_C: length 32.1
  TOP w0.097: v2(212.55,111.88) 212.55,111.72 212.34,111.52 211.85,111.52 211.39,111.05 211.16,111.05 211.07,111.14 C5819.1 ; v2(224.3,112.72) 224.23,112.79 224.23,112.9 224.39,113.06 224.6,113.06 225.1,112.56 225.1,112.53 226.74,110.88 227.47,110.88 U6303.5 U6303.6 228.64,110.78 228.69,110.84 229.12,110.84 229.58,110.37 229.75,110.37 R6327.1 229.96,110.32 231.89,110.32 232.5,110.93 232.5,111.51 234.12,113.13 235.78,113.13 CN6300.B2
  IN2 w0.114: v2(212.55,111.88) 212.55,111.61 212.48,111.54 212.14,111.54 211.95,111.72 211.95,112.4 212.49,112.94 215.85,112.94 216.2,113.3 217.18,113.3 217.76,112.72 221.82,112.72 222.13,112.41 223.68,112.41 224.07,112.8 224.22,112.8 v2(224.3,112.72)
TYPEC_CC1: length 70
  TOP w0.254: 185.07,107.9 185.33,107.9 185.46,108.03 U6100.9
  TOP w0.381: v2(228.13,117.05) 227.69,116.61 227.69,115.86 228.05,115.5 230.57,115.5 231.36,116.28 232.98,116.28 233.04,116.34 D6303.1 233.56,115.88 233.32,115.64 v2(233.02,115.64)
  TOP w0.508: v2(185.1,107.08) 184.3,107.08 C6105.2 184.23,107.24 184.89,107.9 185.07,107.9
  IN2 w0.508: v2(204.4,106.02) 205.11,106.74 206.13,106.74 207.27,105.59 210.9,105.59 212.04,106.73 213.27,106.73 213.92,107.38 215.67,107.38 216.61,108.32 223.97,108.32 227.48,111.83 227.48,116.41 v2(228.13,117.05)
  BOTTOM w0.203: v2(233.02,115.64) 233.21,115.83 233.53,115.83 233.69,115.99 233.69,116 233.78,116.09 CN6300.A5
  BOTTOM w0.508: v2(204.4,106.02) 203.89,105.52 202.7,105.52 197.47,110.75 192.18,110.75 191.32,111.61 187.89,111.61 186.7,110.42 186.7,109.13 185.1,107.53 v2(185.1,107.08)
TYPEC_CC2: length 80.9
  TOP w0.254: U6100.7 185.16,109.03
  TOP w0.508: v2(229.15,116.9) 229.23,116.82 229.68,116.82 230.01,116.5 D6304.1 230.34,116.16 v2(230.97,116.79) ; v2(183.94,108.31) 184.13,108.51 C6104.2 184.2,109.03 185.16,109.03
  IN1 w0.178: 235.39,117.37 235.6,117.15 235.6,116.84 235.65,116.8 235.65,116.43 235.6,116.38 235.6,115.99 236.07,115.52 CN6300.B5
  IN1 w0.381: v2(230.97,116.79) 231.72,117.54 235.21,117.54 235.39,117.37
  IN2 w0.178: 235.39,117.37 235.6,117.15 235.6,116.84 235.65,116.8 235.65,116.43 235.6,116.38 235.6,115.99 236.07,115.52 CN6300.B5
  IN2 w0.381: v2(230.97,116.79) 231.72,117.54 235.21,117.54 235.39,117.37
  IN2 w0.508: v2(229.15,116.9) 229.15,116.09 228.52,115.46 228.52,111.43 224.39,107.31 217.17,107.31 215.58,105.72 212.48,105.72 211.16,104.4 204.58,104.4 203.35,105.63 v2(203.35,106.56)
  BOTTOM w0.508: v2(203.35,106.56) 203.1,106.56 197.89,111.77 192.6,111.77 191.74,112.63 187.47,112.63 185.68,110.84 185.68,109.56 184.44,108.31 v2(183.94,108.31)
TYPEC_P_EN: length 55.8
  TOP w0.102: v2(226.53,102.34) 226.53,101.5 Q6301.2 ; R6116.2 185.59,103.75 185.81,103.97 185.81,104.22 186.24,104.65 186.24,105 v2(186.98,105.74) 186.98,106.01 186.86,106.13 U6100.11
  BOTTOM w0.102: v2(226.53,102.34) 226.53,102.44 224.47,104.5 222.92,104.5 221.65,103.23 221.65,102.19 220.91,101.45 211.87,101.45 211.36,101.96 207.42,101.96 205.44,99.98 202.51,99.98 199.64,102.85 196.27,102.85 193.52,105.61 193.52,107.14 193.26,107.4 192.31,107.4 191.87,106.95 191.87,106.09 190.36,104.58 188,104.58 186.98,105.6 v2(186.98,105.74)
TYPEC_SBU1: length 50.9
  TOP w0.097: v2(226.09,114.25) 226.32,114.48 226.64,114.48 226.97,114.15 227.98,114.15 R6300.2 228.78,114.07 230.37,114.07 D6301.1 230.86,113.94 230.99,114.07 231.3,114.07 v2(231.6,113.77) ; U6100.35 189.36,113.5 189.51,113.65 189.51,114.43 190.16,115.07 190.16,115.34 v2(189.94,115.56)
  IN2 w0.114: v2(189.94,115.56) 190.14,115.36 190.14,115.05 190.5,114.69 198.76,114.69 198.94,114.86 209.38,114.86 210.6,116.08 212.06,116.08 212.58,115.57 223.68,115.57 224.8,114.45 225.89,114.45 v2(226.09,114.25)
  BOTTOM w0.097: CN6300.A8 233.79,114.59 233.61,114.76 232.8,114.76 232.43,114.39 232.22,114.39 v2(231.6,113.77)
TYPEC_SBU2: length 56.4
  TOP w0.097: v2(190.57,115.56) 190.36,115.35 190.36,114.99 189.71,114.35 189.71,113.65 189.86,113.5 U6100.34 ; v2(231.6,114.41) 231.46,114.26 231.02,114.26 230.86,114.43 D6302.1 230.32,114.26 228.93,114.26 R6301.2 227.99,114.35 227.05,114.35 226.72,114.68 226.3,114.68 v2(226.09,114.88) ; v2(231.98,112.41) 232.5,112.41 234.57,114.48 235.39,114.48 235.82,114.91 235.82,115.35 236.07,115.6 CN6300.B8
  IN2 w0.114: v2(226.09,114.88) 225.89,114.68 224.9,114.68 223.77,115.8 212.67,115.8 212.16,116.31 210.51,116.31 209.29,115.09 198.85,115.09 198.67,114.91 190.6,114.91 190.37,115.14 190.37,115.36 v2(190.57,115.56)
  BOTTOM w0.097: v2(231.6,114.41) 231.17,113.98 231.17,113.22 v2(231.98,112.41)
TYPEC_VBUS: length 62.9
  TOP w0.127: v2(206.83,100.46) 206.83,99.41 207.75,98.48 208.6,98.48 209.38,97.7 209.38,95.63 PR8005.2 209.26,95.18 PC8003.1 207.72,93.63 207.72,92.74 207.48,92.5 PC8004.1 206.95,92.31 PR8003.2 206.95,90.97 206.71,90.73 204.94,90.73 PQ8003.1 203.28,91.72 203.28,90.2 202.42,89.34 202.07,89.34 PR8007.1
  TOP w0.508: v2(192.42,106.52) 192.42,106.06 192.75,105.73 192.79,105.73 192.8,105.71 R6111.2
  BOTTOM w0.508: v2(192.42,106.52) 192.42,104.87 195,102.29 199.32,102.29 200.06,101.55 200.06,100.59 201.23,99.42 205.79,99.42 v2(206.83,100.46) 207.77,101.4 211.13,101.4 211.67,100.87 218.83,100.87 219.74,99.95 220.8,99.95 222.37,101.53 222.37,102.81 222.99,103.43 v2(224.26,103.43)
  vias: v2(222.36,105.34) v2(222.99,105.34) v2(223.47,96.48) v2(223.53,95.79) v2(223.63,105.34) v2(224.11,96.48) v2(224.16,95.79) v2(224.26,104.96) v2(224.26,104.07) v2(224.75,96.48) v2(224.8,95.76)
TYPEC_VBUS_C: length 8.9
  IN1 w0.508: CN6300.B9 233.62,116.64 ; CN6300.B4 233.68,114.04 233.66,114.03
  BOTTOM w0.178: CN6300.B4 235.13,114.09 CN6300.A9 233.78,114.09 233.58,113.89 233.21,113.89 232.91,113.59 232.42,113.59 v2(232.31,113.7) ; CN6300.B9 235.13,116.59 CN6300.A4 233.79,116.59 233.38,117 232.79,117 v2(232.7,116.91)
  vias: v2(227.62,105.24) v2(227.62,104.58) v2(227.59,103.94) v2(227.92,103.38) v2(228.25,105.21) v2(228.25,104.58) v2(228.25,103.94) v2(228.58,103.38) v2(228.89,105.21) v2(228.89,104.58) v2(228.89,103.94) v2(231.25,108.46) v2(232.62,109.99)
UART0_RXD: length 40.7
  IN2 w0.114: v2(158.19,92.26) 158.11,92.34 156.93,92.34 155.74,93.53 154.84,93.53 154.19,92.89 151.86,92.89 151.75,92.77 150.37,92.77 149.2,93.95 147.32,93.95 146.45,94.81 145.8,94.81 144.47,96.15 143.46,96.15 143.07,95.76 143.07,95.56 141.96,94.45 141.12,94.45 140.65,93.99 v2(140.65,93.86)
  BOTTOM w0.079: U400.CR14 138.97,94.06 139.08,94.17 139.8,94.17 140.11,93.86 v2(140.65,93.86)
  BOTTOM w0.102: R7709.2 157.66,78.36 R7713.1 157.01,78.77 157.22,78.97 157.22,79.3 157.04,79.48 156.35,79.48 155.81,80.02 155.81,80.45 156.24,80.88 156.24,83.85 v2(155.93,84.17) 155.48,84.61 155.48,85.88 156.55,86.95 156.55,86.95 156.88,87.28 156.88,89.64 158.24,91 158.24,92.21 v2(158.19,92.26)
UART0_RXD_R: length 7.1
  BOTTOM w0.102: v2(155.94,79.3) 155.81,79.18 155.81,78.03 155.94,77.91 157.08,77.91 157.42,77.57 R7703.1 158.69,78.67 R7709.1 159.03,78.38 CN7701.17
UART0_TXD: length 42.4
  IN2 w0.114: v2(157.61,91.57) 157.3,91.88 156.74,91.88 155.6,93.02 154.97,93.02 154.38,92.43 152.15,92.43 151.37,91.65 150.84,91.65 149,93.49 145.56,93.49 144.78,92.71 142.56,92.71 141.81,93.46 141.59,93.46 141.29,93.76 v2(141.29,93.86)
  BOTTOM w0.079: U400.CP14 138.37,94.06 138.57,94.26 138.65,94.32 138.99,94.32 139.01,94.34 139.87,94.34 139.95,94.26 140.88,94.26 v2(141.29,93.86)
  BOTTOM w0.102: R7707.2 154.28,76.38 153.4,76.38 153.15,76.64 153.02,76.64 152.76,76.89 152.76,77.41 R7714.1 153.91,78.55 153.91,80.19 v2(154.16,80.45) 154.44,80.73 155.48,80.73 155.84,81.08 155.84,82.91 155.08,83.67 155.08,86.08 156.47,87.48 156.47,89.87 157.61,91.01 v2(157.61,91.57)
UART0_TXD_R: length 7
  BOTTOM w0.102: R7707.1 154.97,75.18 R7705.1 155.47,75.24 155.91,75.24 156.19,75.52 156.19,76.41 156.6,76.81 157.56,76.81 158.17,76.21 158.4,76.21 158.53,76.34 CN7701.16
UIM_CLK: length 26.2
  IN2 w0.127: v2(205.56,65.42) 205.56,65.75 205.47,65.85 205.47,67.48 202.55,70.4 202.55,71.03 201.25,72.32 200.31,72.32 197.83,74.8 197.83,75.68 196.54,76.97 196.54,80.74 196.38,80.9 v2(196.38,81.09)
  BOTTOM w0.102: CN4201.3 207.36,62.25 207.07,62.54 207.02,62.54 v2(205.27,64.29) 205.27,65.03 205.56,65.33 v2(205.56,65.42) ; v2(196.38,81.09) 196.2,80.92 CN4200.32
UIM_DATA: length 28.5
  IN2 w0.127: v2(204.89,65.44) 204.95,65.5 204.95,67.27 202.03,70.2 202.03,70.83 201.04,71.81 200.08,71.81 197.32,74.58 197.32,75.47 196.03,76.76 196.03,80.51 195.79,80.76 195.79,81.24 196.26,81.71 v2(196.53,81.71)
  BOTTOM w0.102: CN4201.7 206.09,62.05 204.78,63.35 204.78,65.33 v2(204.89,65.44) 204.73,65.44 204.32,65.85 R4222.1 ; CN4200.34 196.7,80.62 196.78,80.7 196.78,81.45 v2(196.53,81.71)
UIM_RESET: length 31.1
  IN2 w0.114: v2(210.2,62.65) 210.2,62.8 206.77,66.24 206.77,67.72 206.1,68.38 205.27,68.38 203.06,70.6 203.06,71.3 201.53,72.83 200.52,72.83 198.33,75.01 198.33,75.89 197.04,77.18 197.04,81.19 v2(197.65,81.79)
  BOTTOM w0.102: CN4200.30 195.7,81.37 196.07,81.74 196.07,81.85 196.33,82.11 196.7,82.11 197.02,81.79 v2(197.65,81.79) ; v2(210.2,62.65) 209.9,62.35 CN4201.2
UIM_VPP: length 2.1
  BOTTOM w0.102: CN4201.6 208.63,62.33 207.75,63.2 TP4200.1
ULT_EDP_HPD: length 279.9
  TOP w0.102: v2(43.38,123.86) 43.99,123.25 45.86,123.25 48.83,126.22 48.83,128.4 49.89,129.47 64.71,129.47 69.94,124.24 73.48,124.24 74.08,123.63 78.66,123.63 79.93,124.91 85.36,124.91 89.11,128.66 89.11,130.2 90.54,131.63 91.71,131.63 92.42,130.92 93.73,130.92 94.13,130.51 v2(94.64,130.51) ; v2(169.27,77.68) 169.27,78.85 172.01,81.59 172.65,81.59 173.51,82.45 175.16,82.45 175.75,83.04 181.59,83.04 182.15,83.6 182.15,84.31 182.91,85.06 v2(183.32,85.06)
  IN1 w0.114: v2(169.27,77.68) 169.08,77.68 168.19,76.79 164.97,76.79 164.71,76.53 159.37,76.53 157.96,75.11 155.23,75.11 154.45,75.9 v2(153.67,75.9)
  IN2 w0.114: v2(158.89,129.49) 158,128.61 156.61,128.61 155.53,129.7 133.03,129.7 131.42,128.09 122.64,128.09 121.03,129.7 113.45,129.7 113.45,129.7 101.25,129.7 101.25,129.7 95.33,129.7 94.64,130.39 v2(94.64,130.51)
  BOTTOM w0.079: 144.71,96.63 143.16,96.63 142.41,97.38 142.41,97.77 141.71,98.47 141.37,98.47 141.22,98.61 140.53,98.61 140.39,98.75 138.9,98.75 138.75,98.82 138.66,98.86 138.61,98.87 138.61,98.88 138.28,98.88 137.87,98.71 137.4,98.71 U400.CM7
  BOTTOM w0.102: v2(183.32,85.06) 183.09,85.29 183.09,86.86 182.93,87.03 182.93,89 184.34,90.41 184.34,93.4 183.85,93.88 183.85,96.09 179.21,100.74 179.21,106.43 174.71,110.93 167.7,110.93 163.13,115.5 163.13,116.25 159.01,120.37 159.01,124.96 157.59,126.38 157.59,128.2 v2(158.89,129.49) ; CN3400.10 38.65,131.7 38.9,131.46 38.9,131.01 39.34,130.56 40.92,130.56 41.35,130.13 41.35,125.82 43.32,123.86 v2(43.38,123.86) ; v2(153.67,75.9) 153.6,75.9 153.06,76.43 152.79,76.43 152.18,77.04 152.18,82.62 154.87,85.32 154.87,86.24 156.27,87.64 156.27,89.97 157.17,90.87 157.17,92.11 156.66,92.62 156.66,93.35 156.04,93.97 154.77,93.97 154.24,94.5 153.37,94.5 152.15,95.72 151.65,95.72 151.57,95.64 149.81,95.64 149.67,95.78 148.37,95.78 R542.1 147.87,96.09 R541.1 147.07,96.33 146.96,96.45 146.38,96.45 146.2,96.63 144.71,96.63
USB2_ID: length 28.2
  TOP w0.079: v1(133.51,97.31) 134.09,96.73 134.09,96.45 134.4,96.15 135.34,96.15 135.77,96.58 135.77,99.86 136.09,100.18 136.71,100.18
  TOP w0.102: 136.71,100.18 137.33,100.18 139.15,102 144.04,102 144.48,101.56 144.84,101.56 145.51,100.89 147.23,100.89 147.68,101.34 147.68,101.53 148.19,102.04 148.38,102.04 151.37,105.03 v2(152.95,105.03) 153.14,104.85 R563.1
  BOTTOM w0.079: U400.CE8 133.27,97.56 v1(133.51,97.31)
USB2_VBUSSENSE: length 21.6
  TOP w0.079: 133.18,100.61 133.18,99.06 v1(132.62,98.51)
  TOP w0.102: 133.18,100.61 133.18,101.26 133.58,101.66 135.06,101.66 136.34,102.95 136.34,103.71 137.37,104.74 140.25,104.74 141.2,105.69 141.2,106.77 141.2,106.77 141.2,109.04 143.06,110.9 R564.2 143.31,110.98 143.5,111.17 143.5,111.8 v2(143.19,112.11)
  BOTTOM w0.079: v1(132.62,98.51) 132.27,98.86 U400.CC6
USB30_RX1+: length 147.6
  IN1 w0.079: v1(131.71,98.48) 131.89,98.66 132.1,98.66 132.28,98.84 132.28,99.23 132.92,99.87 132.92,102.26 133.31,102.65 133.31,103.21 133.34,103.24 133.34,103.26
  IN1 w0.114: v2(217.64,51) 217.3,51.35 216.6,51.35 216.04,51.91 216.04,55.15 214.24,56.96 213.49,56.96 213.17,57.27 211.77,57.27 211.07,57.97 209.3,57.97 206.8,60.48 205.34,60.48 203.01,62.81 203.01,63.54 202.62,63.93 201.89,63.93 200.8,65.03 200.8,66.99 201.04,67.23 201.04,67.74 199.52,69.26 199.08,69.26 196.56,71.78 196.04,71.78 194.98,72.84 194.98,74.36 194.52,74.81 194.52,75.25 193.54,76.23 193.54,79.46 193.04,79.95 193.04,82.37 192.87,82.54 192.87,84.03 193.71,84.87 193.71,91.93 188.2,97.44 186.65,97.44 183.21,100.88 176.5,100.88 175.93,101.45 168.92,101.45 168.49,101.02 165.94,101.02 164.36,99.45 163.69,99.45 163.23,99.91 163.23,100.16 162.75,100.64 162.75,101.12 157.56,106.3 155.74,106.3 154.38,107.66 145.2,107.66 141.79,104.25 134.32,104.25 133.34,103.27 133.34,103.26
  BOTTOM w0.079: v1(131.71,98.48) 131.33,98.86 U400.CB6
  BOTTOM w0.097: v2(217.64,51) 217.99,51.34 218.29,51.34 218.41,51.22 219.56,51.22 220.48,52.14 223.68,52.14 223.83,51.99 U5702.9 U5702.2 225.12,51.99 225.27,52.14 225.5,52.14 225.77,52.41 226.65,52.41 227.97,53.73 228.26,53.73 228.99,54.46 229.32,54.46 229.54,54.24 CN5701.6
USB30_RX1-: length 147.6
  IN1 w0.079: 133.11,103.26 133.11,103.24 133.14,103.21 133.14,102.72 132.75,102.33 132.75,99.94 132.11,99.3 132.11,98.91 132.03,98.83 131.95,98.83 v1(131.71,99.07)
  IN1 w0.114: v2(217.64,51.76) 217.45,51.57 216.7,51.57 216.27,52 216.27,55.25 214.33,57.19 213.58,57.19 213.27,57.5 211.86,57.5 211.16,58.2 209.4,58.2 206.89,60.7 205.44,60.7 203.24,62.91 203.24,63.63 202.71,64.16 201.99,64.16 201.02,65.12 201.02,66.89 201.27,67.13 201.27,67.83 199.61,69.49 199.17,69.49 196.66,72.01 196.14,72.01 195.21,72.94 195.21,74.45 194.75,74.91 194.75,75.34 193.77,76.33 193.77,79.55 193.27,80.05 193.27,82.47 193.1,82.64 193.1,83.94 193.94,84.77 193.94,92.03 188.3,97.67 186.75,97.67 183.31,101.11 176.6,101.11 176.02,101.68 168.82,101.68 168.39,101.25 165.85,101.25 164.27,99.67 163.79,99.67 163.46,100.01 163.46,100.25 162.97,100.73 162.97,101.21 157.65,106.53 155.83,106.53 154.48,107.89 145.11,107.89 141.7,104.48 134.22,104.48 133.11,103.36 133.11,103.26
  BOTTOM w0.079: v1(131.71,99.07) 131.27,99.51 U400.CB5
  BOTTOM w0.097: CN5701.5 229.54,54.89 229.31,54.66 228.91,54.66 228.18,53.93 227.89,53.93 226.57,52.61 225.69,52.61 225.42,52.34 225.24,52.34 225.09,52.49 U5702.1 U5702.10 223.82,52.49 223.66,52.34 220.4,52.34 219.48,51.42 218.49,51.42 218.37,51.54 217.86,51.54 v2(217.64,51.76)
USB30_RX3+: length 159.6
  TOP w0.097: CN5700.6 229.54,35.1 229.29,35.34 229.02,35.34 228.44,34.76 227.42,34.76 225.61,32.95 225.61,31.65 225.41,31.45 U5700.9 U5700.2 223.93,31.45 223.78,31.6 223.03,31.6 222.85,31.43 219.84,31.43 218.93,32.34 218.45,32.34 217.73,31.62 217.25,31.62 216.8,32.08 216.8,33.03 216.17,33.65 215.76,33.65 v2(215.47,33.36)
  IN1 w0.079: v1(130.84,97.24) 130.87,97.24 131.13,96.97 131.13,96.71 131.64,96.2 133.96,96.2 134.24,95.93 134.61,95.93 134.82,96.13 137.41,96.13 137.88,96.61 139.81,96.61 139.84,96.58 139.86,96.58
  IN1 w0.114: 139.86,96.58 143.77,96.58 145.55,98.35 145.8,98.35 146.13,98.68 149.69,98.68 150.43,99.41 150.78,99.41 151,99.2 153.01,99.2 153.37,98.84 154.14,98.84 154.6,99.3 155.33,99.3 156,98.63 157.01,98.63 157.27,98.37 158.02,98.37 158.54,97.85 159.6,97.85 159.81,97.64 160.97,97.64 162.37,96.25 172.19,96.25 172.43,96.49 174.2,96.49 174.55,96.13 179.3,96.13 179.77,95.66 182.51,95.66 188.7,89.47 188.7,86.17 189.31,85.56 189.31,84.48 188.84,84.01 188.84,79.78 189.49,79.13 189.49,75.26 189.14,74.9 189.14,74.2 188.91,73.97 188.91,72.68 190.75,70.83 191.78,70.83 192.87,69.74 192.87,69.25 192.24,68.61 192.24,65.89 193.47,64.65 195.61,64.65 196.34,63.93 196.34,63.12 197.46,62 197.46,60.94 198.42,59.99 198.92,59.48 202.46,59.48 205.83,56.11 206.46,56.11 207.34,55.23 209.62,55.23 210.4,54.46 210.4,53.33 210.98,52.75 210.98,47.57 214.64,43.92 214.64,35.64 214.33,35.34 214.33,34.13 214.89,33.57 215.26,33.57 v2(215.47,33.36)
  BOTTOM w0.079: U400.BY9 130.51,96.91 v1(130.84,97.24)
USB30_RX3-: length 159.7
  TOP w0.097: v2(215.47,34.12) 215.74,33.85 216.25,33.85 216.99,33.11 216.99,32.16 217.33,31.82 217.65,31.82 218.37,32.54 219.01,32.54 219.92,31.63 222.77,31.63 222.94,31.8 223.78,31.8 223.93,31.95 U5700.1 U5700.10 225.29,31.95 225.41,32.08 225.41,33.03 227.34,34.96 228.35,34.96 228.94,35.54 229.29,35.54 229.54,35.79 CN5700.5
  IN1 w0.079: v1(130.69,97.82) 130.78,97.82 131.3,97.31 131.3,96.78 131.71,96.37 134.03,96.37 134.31,96.09 134.54,96.09 134.75,96.3 137.34,96.3 137.81,96.77 139.81,96.77 139.84,96.8 139.86,96.8
  IN1 w0.114: v2(215.47,34.12) 215.15,33.8 214.98,33.8 214.56,34.22 214.56,35.24 214.87,35.55 214.87,44.01 211.21,47.67 211.21,52.84 210.63,53.42 210.63,54.55 209.72,55.46 207.44,55.46 206.55,56.34 205.92,56.34 202.56,59.71 199.02,59.71 198.65,60.08 197.69,61.04 197.69,62.09 196.57,63.21 196.57,64.02 195.71,64.88 193.57,64.88 192.46,65.99 192.46,68.52 193.1,69.15 193.1,69.83 191.87,71.06 190.85,71.06 189.14,72.77 189.14,73.88 189.37,74.1 189.37,74.81 189.72,75.16 189.72,79.23 189.07,79.88 189.07,83.91 189.54,84.38 189.54,85.65 188.93,86.26 188.93,89.56 182.6,95.89 179.86,95.89 179.39,96.36 174.65,96.36 174.29,96.72 172.33,96.72 172.09,96.47 162.46,96.47 161.07,97.87 159.9,97.87 159.7,98.07 158.63,98.07 158.11,98.6 157.37,98.6 157.1,98.86 156.09,98.86 155.43,99.53 154.5,99.53 154.05,99.07 153.46,99.07 153.11,99.43 151.09,99.43 150.88,99.64 150.33,99.64 149.6,98.91 146.03,98.91 145.71,98.58 145.46,98.58 143.68,96.8 139.86,96.8
  BOTTOM w0.079: v1(130.69,97.82) 130.43,97.56 U400.BY8
USB30_RX4+: length 101.2
  TOP w0.097: C5813.1 206.46,115.08 206.56,115.17 206.56,115.38 206.34,115.6 201.28,115.6 196.63,110.95 196.63,108.95 195.99,108.31 195.41,108.31 195,107.9 195,106.99 195.1,106.89 195.34,106.89 195.44,106.99 v2(195.44,107.23)
  IN1 w0.114: v1(129.83,99.83) 130.01,100.01 130.01,101.46 128.84,102.62 128.84,107.95 129.77,108.88 131.97,108.88 132.39,109.3 139.01,109.3 141.12,111.41 141.91,111.41 142.95,112.45 156.26,112.45 157.12,111.59 159.03,111.59 162.94,107.68 164.13,107.68 165.53,106.28 167.21,106.28 167.92,105.57 177.44,105.57 177.95,105.06 181.36,105.06 182.28,105.97 184.77,105.97 185.83,107.04 191.79,107.04 192.09,107.35 194.52,107.35 194.98,106.89 195.32,106.89 195.44,107 v2(195.44,107.23)
  BOTTOM w0.079: v1(129.83,99.83) 129.7,99.95 129.35,99.95 129.2,99.8 129.2,99.69 U400.BW5
USB30_RX4+_C: length 1.9
  TOP w0.097: U5800.5 206.16,113.22 206.33,113.39 206.33,114.2 206.24,114.3 C5813.2
USB30_RX4-: length 101.3
  TOP w0.097: C5814.1 206.76,115.34 206.76,115.46 206.42,115.8 201.2,115.8 196.43,111.03 196.43,109.03 195.91,108.51 195.33,108.51 194.8,107.98 194.8,106.91 195.02,106.69 195.22,106.69 v2(195.44,106.47)
  IN1 w0.114: v1(129.83,99.17) 130.23,99.57 130.23,101.56 129.07,102.72 129.07,107.86 129.87,108.65 132.07,108.65 132.49,109.07 139.1,109.07 141.21,111.18 142,111.18 143.04,112.22 156.17,112.22 157.03,111.36 158.93,111.36 162.84,107.45 164.04,107.45 165.44,106.05 167.11,106.05 167.83,105.34 177.35,105.34 177.86,104.83 181.46,104.83 182.37,105.75 184.86,105.75 185.93,106.81 191.88,106.81 192.18,107.12 194.43,107.12 194.88,106.66 195.25,106.66 v2(195.44,106.47)
  BOTTOM w0.079: v1(129.83,99.17) 129.52,98.86 U400.BW6
USB30_RX4-_C: length 1.9
  TOP w0.097: C5814.2 206.76,114.3 206.53,114.07 206.53,113.32 206.56,113.29 U5800.4
USB30_TX1+: length 138.5
  IN1 w0.114: v2(217.53,49.71) 217.73,49.92 218.06,49.92 218.39,50.25 218.39,52.42 218.22,52.6 218.22,54.32 217.03,55.52 217.03,56.11 214.51,58.63 213.11,58.63 212.74,58.27 212.12,58.27 211.46,58.93 209.75,58.93 207.26,61.43 206.51,61.43 202.62,65.32 202.04,65.32 201.75,65.61 201.75,66.59 201.99,66.83 201.99,68.13 199.91,70.21 199.47,70.21 196.93,72.75 196.93,73.74 196.53,74.15 196.53,75.59 194.93,77.18 194.93,80.03 193.99,80.97 193.99,82.77 193.84,82.92 193.84,83.65 194.7,84.51 194.7,92.29 188.28,98.71 186.73,98.71 183.59,101.86 176.87,101.86 176.31,102.42 166.87,102.42 166.39,102.9 163.41,102.9 157.89,108.41 156,108.41 155.08,109.33 144.09,109.33 140.68,105.92 133.59,105.92 131.96,104.3 131.56,104.3 v2(131.3,104.55)
  BOTTOM w0.079: U400.CA3 130.69,101.43 130.71,101.51 130.71,101.61 130.64,101.76 130.64,101.92 130.68,102.07 130.71,102.2 130.71,104.09 130.92,104.29 131.03,104.29 v2(131.3,104.55)
  BOTTOM w0.097: v2(217.53,49.71) 217.66,49.85 217.67,49.85 217.77,49.95 218.33,49.95 218.78,50.4 220.07,50.4 220.32,50.65 220.61,50.65 C5712.1
USB30_TX1+_C: length 10.2
  BOTTOM w0.097: CN5701.9 229.54,48.22 229.32,48.44 229.06,48.44 228.3,49.21 226.91,49.21 225.51,50.6 225.28,50.6 225.17,50.49 U5702.5 U5702.6 223.77,50.49 223.62,50.64 223.49,50.64 v2(222.92,50.07) 222.35,50.64 222.18,50.64 C5712.2
USB30_TX1-: length 138.6
  IN1 w0.114: v2(217.53,50.35) 217.53,50.26 217.64,50.14 217.97,50.14 218.16,50.34 218.16,52.33 217.99,52.5 217.99,54.23 216.8,55.42 216.8,56.02 214.42,58.4 213.2,58.4 212.84,58.04 212.03,58.04 211.36,58.7 209.66,58.7 207.16,61.2 206.41,61.2 202.52,65.09 201.95,65.09 201.52,65.51 201.52,66.69 201.76,66.93 201.76,68.04 199.82,69.98 199.38,69.98 196.71,72.66 196.71,73.65 196.3,74.06 196.3,75.49 194.7,77.09 194.7,79.94 193.76,80.87 193.76,82.67 193.61,82.83 193.61,83.74 194.47,84.61 194.47,92.2 188.19,98.48 186.64,98.48 183.49,101.63 176.77,101.63 176.22,102.19 166.78,102.19 166.29,102.67 163.31,102.67 157.8,108.18 155.9,108.18 154.98,109.11 144.19,109.11 140.77,105.69 133.68,105.69 132.06,104.07 131.42,104.07 131.3,103.95 v2(131.3,103.8)
  BOTTOM w0.079: U400.CA4 130.71,100.6 130.75,101.18 130.84,101.37 130.88,101.48 130.88,101.65 130.8,101.8 130.8,101.89 130.84,102.02 130.88,102.17 130.88,104.02 130.98,104.12 131.2,104.12 131.3,104.02 v2(131.3,103.8)
  BOTTOM w0.097: C5711.1 220.61,50.84 220.24,50.84 219.99,50.6 218.7,50.6 218.25,50.14 217.62,50.14 217.53,50.24 v2(217.53,50.35)
USB30_TX1-_C: length 10.1
  BOTTOM w0.097: C5711.2 222.18,50.84 222.42,50.84 v2(222.92,51.34) 223.42,50.84 223.61,50.84 223.76,50.99 U5702.7 U5702.4 225.17,50.99 225.36,50.8 225.59,50.8 226.99,49.4 228.38,49.4 229.14,48.64 229.31,48.64 229.54,48.87 CN5701.8
USB30_TX3+: length 159.9
  TOP w0.097: C5704.1 222.52,29.84 222.52,30.18 222.4,30.29 221.52,30.29 221.21,30.6 219.43,30.6 219.24,30.79 219.02,30.79 v2(218.81,30.57)
  IN1 w0.114: v2(218.81,30.57) 218.6,30.78 218.36,30.78 218.02,31.13 218.02,32.34 218.84,33.17 218.84,35.43 216.85,37.43 216.85,46.18 218.89,48.21 218.89,54.51 217.69,55.71 217.69,56.8 216.49,57.99 215.86,57.99 214.59,59.26 211.92,59.26 211.3,59.87 210.55,59.87 210.24,60.18 209.31,60.18 207.56,61.92 206.71,61.92 202.6,66.04 202.6,68.22 200.11,70.72 199.67,70.72 197.49,72.89 197.49,74 197.17,74.33 197.17,75.64 195.59,77.22 195.59,80.07 195.23,80.44 195.23,82.4 195.56,82.73 195.56,92.13 188.09,99.6 186.55,99.6 183.78,102.37 177.06,102.37 176.5,102.93 167.06,102.93 166.43,103.56 164.49,103.56 162.87,105.19 161.86,105.19 158.14,108.91 156.2,108.91 155.18,109.94 143.99,109.94 140.83,106.78 133.49,106.78 132.49,105.77 132.09,105.77 131.96,105.64 131.96,105.54 v2(132.09,105.42)
  BOTTOM w0.079: U400.CA1 130.31,102.33 130.31,102.48 130.45,102.62 130.45,104.36 131.16,105.07 131.19,105.07 131.74,105.62 131.99,105.62 132.09,105.52 v2(132.09,105.42)
USB30_TX3+_C: length 8.5
  TOP w0.097: CN5700.9 229.54,29.3 229.36,29.48 228.98,29.48 228.32,30.13 227.1,30.13 v2(226.57,29.6) 226.57,29.99 226.38,30.18 225.56,30.18 225.33,29.95 U5700.6 U5700.5 224.01,29.95 223.92,30.04 223.5,30.04 C5704.2
USB30_TX3-: length 159.9
  TOP w0.097: C5703.1 222.16,30.49 221.6,30.49 221.29,30.8 219.51,30.8 219.32,30.99 219.17,30.99 v2(218.88,31.28)
  IN1 w0.114: v2(131.66,106) 132.39,106 133.4,107.01 140.74,107.01 143.9,110.17 155.27,110.17 156.3,109.14 158.24,109.14 161.96,105.42 162.96,105.42 164.59,103.79 166.52,103.79 167.16,103.15 176.6,103.15 177.16,102.6 183.87,102.6 186.64,99.83 188.19,99.83 195.79,92.23 195.79,82.63 195.46,82.3 195.46,80.53 195.82,80.17 195.82,77.32 197.4,75.74 197.4,74.42 197.72,74.1 197.72,72.99 199.76,70.95 200.2,70.95 202.83,68.32 202.83,66.13 206.81,62.15 207.66,62.15 209.4,60.41 210.33,60.41 210.64,60.1 211.39,60.1 212.01,59.49 214.69,59.49 215.95,58.22 216.59,58.22 217.91,56.89 217.91,55.81 219.12,54.61 219.12,48.12 217.08,46.08 217.08,37.52 219.07,35.53 219.07,33.07 218.25,32.25 218.25,31.22 218.46,31.01 218.6,31.01 v2(218.88,31.28)
  BOTTOM w0.079: U400.CA2 130.14,101.85 130.14,102.55 130.28,102.69 130.28,104.43 131.09,105.24 131.12,105.24 131.66,105.77 v2(131.66,106)
USB30_TX3-_C: length 8.5
  TOP w0.097: C5703.2 223.14,30.35 223.25,30.24 223.69,30.24 223.91,30.45 U5700.4 U5700.7 225.42,30.45 225.49,30.38 226.44,30.38 226.57,30.51 v2(226.57,30.87) 227.11,30.33 228.41,30.33 229.06,29.68 229.35,29.68 229.54,29.87 CN5700.8
USB30_TX4+: length 115.2
  TOP w0.097: v2(127.93,117.28) 128.31,116.9 128.31,116.78 128.52,116.57 130.98,116.57 131.96,117.55 131.96,117.78 133.14,118.96 143.38,118.96 148.35,123.94 151.28,123.94 151.75,123.47 157.16,123.47 158.83,121.8 158.83,120.84 164.25,115.42 165.62,115.42 168.81,112.24 170.42,112.24 173.42,109.24 173.99,109.24 174.65,108.58 175.1,108.58 177.24,106.44 178.17,106.44 181.75,102.85 182.86,102.85 184.42,101.29 191.67,101.29 196.24,105.86 196.24,107.42 197.63,108.81 197.63,110.68 201.49,114.54 203.64,114.54 203.73,114.44 C5817.1
  BOTTOM w0.079: U400.BW1 129.4,102.29 129.4,102.86 129.51,102.97 129.51,103.99 128.81,104.69 128.81,107.25 129.38,107.82 130.12,107.82 130.45,108.15 130.45,108.61 130.44,108.63 130.44,108.65
  BOTTOM w0.097: 130.44,108.65 130.44,110.85 129.5,111.79 129.5,113.55 130.04,114.09 130.04,114.87 128.28,116.62 128.28,116.93 v2(127.93,117.28)
USB30_TX4+_C: length 2.8
  TOP w0.097: C5817.2 204.51,114.37 204.73,114.58 204.95,114.58 205.16,114.38 205.16,113.44 204.96,113.24 U5800.8
USB30_TX4-: length 115.3
  TOP w0.097: v2(128.57,117.28) 128.51,117.22 128.51,116.87 128.6,116.77 130.9,116.77 131.76,117.63 131.76,117.86 133.06,119.16 143.29,119.16 148.27,124.14 151.37,124.14 151.83,123.67 157.24,123.67 159.03,121.88 159.03,120.92 164.33,115.62 165.7,115.62 168.89,112.44 170.5,112.44 173.5,109.44 174.07,109.44 174.73,108.77 175.19,108.77 177.33,106.63 178.25,106.63 181.83,103.05 182.94,103.05 184.5,101.49 191.59,101.49 196.04,105.94 196.04,107.5 197.43,108.89 197.43,110.76 201.4,114.74 203.64,114.74 203.73,114.83 C5818.1
  BOTTOM w0.079: U400.BW2 129.57,101.81 129.57,102.79 129.68,102.9 129.68,104.06 128.98,104.76 128.98,107.18 129.45,107.65 130.19,107.65 130.62,108.08 130.62,108.61 130.64,108.63 130.64,108.65
  BOTTOM w0.097: 130.64,108.65 130.64,110.93 129.7,111.87 129.7,113.47 130.23,114.01 130.23,114.95 128.48,116.71 128.48,117.19 v2(128.57,117.28)
USB30_TX4-_C: length 2.8
  TOP w0.097: U5800.7 205.36,114.46 205.03,114.78 204.8,114.78 C5818.2
USB_BIAS: length 18.8
  TOP w0.079: 132.93,100.64 132.93,100.46 132.98,100.41 132.98,99.42 v1(132.65,99.09)
  TOP w0.102: 132.93,100.64 132.93,101.38 133.41,101.87 134.96,101.87 136.14,103.05 136.14,103.8 137.28,104.94 140.17,104.94 140.99,105.77 140.99,106.69 140.99,109.45 v2(141.42,109.87) 142.17,110.63 R566.1
  BOTTOM w0.079: U400.CC5 132.23,99.51 v1(132.65,99.09)
USB_C_INT#: length 6.2
  TOP w0.102: U4701.A11 200.9,55.45 200.21,55.45 199.95,55.71 199.95,55.87 199.78,56.04 199.21,56.04 198.83,55.66 197.01,55.66 196.73,55.94 v2(196.49,55.94) 195.65,55.94 R4715.1
USB_CYPRESS_BOT_DN: length 35.4
  TOP w0.097: R6318.2 218.06,110.93 217.95,110.82 217.43,110.82 217.35,110.74 217.34,110.74 217.32,110.72 217.2,110.72 v2(216.91,111.01) ; U6100.25 192.72,109.53 192.85,109.66 193,109.66 193.18,109.84 193.93,109.84 194.04,109.73 194.04,109.48 v2(193.84,109.28)
  BOTTOM w0.097: v2(193.84,109.28) 194.04,109.07 194.04,108.84 194.9,107.99 197.54,107.99 201.98,103.54 205,103.54 206.51,105.05 212.22,105.05 214.2,107.03 214.2,107.84 214.74,108.38 214.74,108.57 215.24,109.08 215.73,109.08 216.16,109.5 217.17,109.5 217.73,110.07 217.73,110.5 217.46,110.77 217.15,110.77 v2(216.91,111.01)
USB_CYPRESS_BOT_DP: length 35.4
  TOP w0.097: R6317.2 218.06,109.91 217.95,110.02 217.5,110.02 217.38,110.14 217.38,110.39 217.25,110.52 217.05,110.52 216.91,110.38 v2(216.91,110.25) ; U6100.26 192.67,110.03 192.85,109.86 192.92,109.86 193.1,110.04 194.01,110.04 194.24,109.81 194.24,109.35 194.32,109.28 v2(194.5,109.28)
  BOTTOM w0.097: v2(216.91,110.25) 217.23,110.57 217.38,110.57 217.53,110.42 217.53,110.15 217.09,109.7 216.08,109.7 215.65,109.27 215.16,109.27 214.54,108.65 214.54,108.46 214,107.92 214,107.12 212.14,105.25 206.43,105.25 204.91,103.74 202.07,103.74 197.62,108.18 194.98,108.18 194.24,108.93 194.24,109.17 194.34,109.28 v2(194.5,109.28)
USB_CYPRESS_BOT_L_DN: length 25.1
  TOP w0.097: v2(229.22,107.69) 229,107.47 228.89,107.47 228.15,108.21 228.15,108.89 227.72,109.33 226.43,109.33 224.7,111.05 223.35,111.05 223.06,111.34 222.92,111.34 222.77,111.49 U6300.2 U6300.9 221.35,111.49 221.22,111.36 220.95,111.36 220.74,111.15 220.74,110.7 220.55,110.52 220.43,110.52 220.13,110.82 219.65,110.82 219.55,110.93 R6318.1
  IN2 w0.114: CN6300.B7 234.91,115.47 234.46,115.47 233.87,114.88 233.87,113.46 232.18,111.77 232.18,110.67 231.97,110.46 231.97,108.54 231.46,108.03 230.18,108.03 229.6,107.45 229.46,107.45 v2(229.22,107.69)
