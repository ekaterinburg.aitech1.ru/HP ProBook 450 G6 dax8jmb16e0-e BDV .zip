# Allegro board dax8jmb16e0-e-www.DeviceDB.xyz_.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
INT_EDP_TXN0: length 96
  TOP w0.097: v2(36.91,128.73) 37.12,128.94 37.12,129.12 37.35,129.34 37.35,129.41 C3417.2
  IN2 w0.114: v2(100.92,116.06) 101.1,116.23 101.1,118.14 98.38,120.86 90.57,120.86 88.51,122.92 86.03,122.92 83.45,125.5 79.5,125.5 77.21,127.79 74.91,127.79 74.53,127.41 73.7,127.41 73.57,127.54 72.28,127.54 71.44,128.38 59.3,128.38 58.25,127.34 49.09,127.34 48.28,128.15 41.54,128.15 41.23,128.45 39.24,128.45 38.23,127.44 37.5,127.44 37.12,127.82 37.12,128.52 v2(36.91,128.73)
  BOTTOM w0.079: 109.14,107.38 109.14,107.36 109.16,107.34 109.16,106.98 109.66,106.47 109.66,102.72 109.34,102.39 109.34,102.13 109.4,101.98 109.44,101.88 109.44,101.85 109.36,101.7 109.36,101.46 109.4,101.33 109.51,101.09 109.5,100.62 U400.AG4
  BOTTOM w0.097: 109.14,107.38 109.14,110.23 105.69,113.69 102.88,113.69 101.13,115.44 101.13,115.85 v2(100.92,116.06)
INT_EDP_TXN1: length 96.4
  TOP w0.097: v2(35.51,128.6) 35.7,128.79 35.7,128.88 35.19,129.39 35.19,129.46 C3415.2
  IN2 w0.114: v2(35.51,128.6) 35.71,128.8 35.71,129.47 36.15,129.92 39.68,129.92 39.79,130.03 41.37,130.03 42.37,129.04 52.64,129.04 52.93,129.32 72.4,129.32 73.03,128.68 73.52,128.68 73.7,128.86 78.52,128.86 80.98,126.4 86.27,126.4 90.75,121.92 99.23,121.92 103.56,117.58 103.56,116.18 v2(103.74,116)
  BOTTOM w0.079: U400.AG2 110.17,101.94 110.17,102.49 110.31,102.64 110.31,106.84 110.01,107.14 110.01,107.36 110.02,107.37 110.02,107.38
  BOTTOM w0.097: 110.02,107.38 110.02,110.6 106.05,114.56 104.17,114.56 103.56,115.17 103.56,115.82 v2(103.74,116)
INT_EDP_TXP0: length 96
  TOP w0.097: v2(37.68,128.73) 37.47,128.73 37.32,128.88 37.32,129.04 37.54,129.26 37.54,129.4 C3416.2
  IN2 w0.114: v2(37.68,128.73) 37.49,128.73 37.35,128.59 37.35,127.92 37.59,127.67 38.14,127.67 39.15,128.68 41.33,128.68 41.63,128.38 48.37,128.38 49.18,127.56 58.16,127.56 59.2,128.61 71.53,128.61 72.38,127.77 73.67,127.77 73.8,127.64 74.43,127.64 74.81,128.02 77.31,128.02 79.6,125.73 83.54,125.73 86.12,123.15 88.6,123.15 90.67,121.09 98.48,121.09 101.33,118.24 101.33,116.26 101.53,116.06 v2(101.69,116.06)
  BOTTOM w0.079: U400.AG3 109.55,101.38 109.53,101.48 109.53,101.66 109.61,101.81 109.61,101.92 109.56,102.04 109.51,102.16 109.51,102.33 109.83,102.65 109.83,106.54 109.32,107.05 109.32,107.34 109.34,107.36 109.34,107.38
  BOTTOM w0.097: v2(101.69,116.06) 101.42,116.06 101.33,115.96 101.33,115.53 102.96,113.89 105.77,113.89 109.34,110.32 109.34,107.38
INT_EDP_TXP1: length 96.4
  TOP w0.097: v2(36.28,128.6) 36.01,128.6 35.89,128.72 35.89,128.97 35.39,129.47 35.39,129.77 35.47,129.85 35.81,129.85 C3414.2
  IN2 w0.114: v2(36.28,128.6) 36.04,128.6 35.93,128.71 35.93,129.38 36.25,129.69 39.77,129.69 39.89,129.8 41.28,129.8 42.27,128.81 52.74,128.81 53.02,129.09 72.3,129.09 72.94,128.45 73.62,128.45 73.8,128.63 78.42,128.63 80.88,126.17 86.17,126.17 90.66,121.69 99.13,121.69 103.33,117.49 103.33,116.13 103.21,116 v2(102.98,116)
  BOTTOM w0.079: 109.82,107.38 109.82,107.37 109.84,107.35 109.84,107.07 110.14,106.77 110.14,102.71 110,102.56 110,102.25 109.95,102.2 U400.AG1
  BOTTOM w0.097: v2(102.98,116) 103.21,116 103.36,115.85 103.36,115.09 104.09,114.37 105.97,114.37 109.82,110.51 109.82,107.38
INT_RF_OFF#: length 15.4
  TOP w0.102: R4107.2 171.84,89.19 171.84,87.59 v2(171.51,87.26) 171.26,87 171.26,86.97 170.26,85.98 170.26,85.56 169.98,85.27 168.82,85.27 168.72,85.37 168.29,85.37 168.08,85.16 168.08,84.59 168.46,84.21 168.46,83.01 168.61,82.86 Q4103.3
  BOTTOM w0.102: v2(171.51,87.26) 171.66,87.4 171.66,87.73 171.76,87.84 171.76,88.52 172.36,89.12 173.83,89.12 174.45,89.74 CN4100.56
INTLWAKE#: length 10.4
  TOP w0.102: v1(127.8,82.33) 127.8,81.81 127.64,81.65 127.15,81.16 127.15,77.69 127.75,77.09 127.75,76.46 128.33,75.88 128.33,75.36 128.62,75.06 128.62,74.47 128.25,74.1 R455.1
  BOTTOM w0.079: v1(127.8,82.33) 128.04,82.57 U400.BU32
IOT_I2C_EN_EC: length 10.4
  TOP w0.102: U4202.2 207.01,72.07 207.12,71.95 v2(207.12,70.58) 207.12,66.29 R4249.2 207.57,66.1 208.31,65.37 208.31,64.78 208.54,64.55 208.54,63.71 208.73,63.52 Q4202.3
IOT_I2C_EN_WWAN: length 21.7
  TOP w0.102: U4202.4 204.75,72.72 206.14,74.1 206.87,74.1 207.13,73.83 v2(207.13,73.61) 207.13,73.06 207.53,72.66 207.53,66.43 208.51,65.45 208.51,64.86 209.6,63.78 209.6,63.03 209.43,62.87 Q4202.2 208.44,62.87 208.29,62.72 208.29,61.91 207.91,61.52 207.4,61.52 207.2,61.32 207.2,60.36 ; Q4201.5 207.04,60.2 207.2,60.36 ; 207.2,60.36 207.35,60.2 Q4201.2
ISH_ACCEL_INT1#: length 235.9
  TOP w0.102: v2(171.33,53.65) 171.62,53.65 176.08,58.11 176.08,59.43 176.73,60.08 176.73,61.1 181.03,65.4 181.03,69.32 179.33,71.03 179.33,73.16 v2(179.75,73.58)
  IN1 w0.114: v2(154.92,68.93) 156.28,70.29 158.86,70.29 160.13,69.02 160.13,64.7 161.4,63.43 164.83,63.43 165.97,62.29 165.97,61.52 171.33,56.17 v2(171.33,53.65)
  IN2 w0.114: v2(90.24,134.44) 90.67,134.44 94.13,130.98 94.13,129.84 94.5,129.47 101.35,129.47 101.35,129.47 113.35,129.47 113.35,129.47 120.94,129.47 122.55,127.86 131.52,127.86 133.12,129.47 155.43,129.47 155.85,129.05 155.85,126.33 v2(157.8,124.39)
  BOTTOM w0.079: 133.88,76.17 133.37,76.68 131.51,76.68 129.43,78.76 129.43,79.3 129.42,79.58 129.42,79.66 129.46,79.78 129.46,79.89 129.46,80.02 129.42,80.14 129.42,80.29 129.45,80.37 129.5,80.47 U400.BW35
  BOTTOM w0.102: v2(179.75,73.58) 179.67,73.66 179.67,76.05 180.19,76.56 181.38,76.56 182.06,77.25 182.06,82.62 181.69,82.99 181.69,84.56 182.08,84.94 182.08,86.44 181.91,86.6 181.91,89.42 183.19,90.7 183.19,91.22 182.84,91.58 182.25,91.58 181.44,92.38 181.44,93.93 176.23,99.14 176.23,102.6 169.53,109.3 167.03,109.3 163.15,113.19 159.65,113.19 156.56,116.27 156.56,116.61 156.83,116.87 156.83,118.4 156.38,118.85 156.38,121.35 157.97,122.94 157.97,124.21 v2(157.8,124.39) ; 133.88,76.17 134.68,75.37 135.49,75.37 136.13,74.73 136.13,74.15 135.99,74.02 135.99,73.42 136.25,73.16 136.84,73.16 137.4,72.6 137.98,72.6 R492.1 138.85,72.09 139.05,71.89 139.05,71.25 138.86,71.07 138.86,69.52 139.41,68.98 141.48,68.98 142.71,67.74 144.83,67.74 145.22,67.35 150.77,67.35 151.97,68.56 154.55,68.56 v2(154.92,68.93) ; v2(90.24,134.44) 90.24,133.7 90.84,133.1 Q7602.6
ISH_ACCEL_INT1#_S: length 33.5
  TOP w0.102: v2(94.59,133.34) 93.76,132.52 89.42,132.52 88.16,131.25 88.16,129.64 87.71,129.19 87.71,128.43 85,125.72 79.59,125.72 78.56,124.68 v2(77.51,124.68)
  BOTTOM w0.102: v2(77.51,124.68) 77.69,124.86 R7629.2 77.44,125.68 v2(76.86,126.26) 76.56,126.55 76.56,127.49 77.22,128.15 77.22,132.3 76.83,132.69 CN7602.8 ; Q7602.1 94.34,133.1 v2(94.59,133.34)
ISH_ACCEL_INT2#: length 235.5
  TOP w0.102: v2(170.88,54.11) 170.88,53.52 171.16,53.24 171.5,53.24 176.28,58.03 176.28,59.34 176.94,59.99 176.94,61.02 181.24,65.32 181.24,69.75 v2(179.94,71.05)
  IN1 w0.114: v2(170.88,54.11) 171.05,54.28 171.05,56.07 165.72,61.4 165.72,62.06 164.68,63.1 161.22,63.1 159.88,64.45 159.88,68.76 158.61,70.03 156.67,70.03 v2(155.57,68.93)
  IN2 w0.114: v2(157.16,124.43) 155.62,125.96 155.62,128.96 155.36,129.22 133.19,129.22 131.61,127.63 122.45,127.63 120.85,129.24 93.9,129.24 93.45,129.69 93.45,130.43 v2(93.5,130.48)
  BOTTOM w0.079: U400.BW34 129.42,80.96 129.35,80.55 129.29,80.44 129.25,80.32 129.25,80.11 129.29,79.99 129.29,79.89 129.29,79.81 129.24,79.66 129.24,78.57 131.3,76.51 133.23,76.51 133.76,75.98
  BOTTOM w0.102: Q7602.3 93.29,131.8 93.21,131.71 93.21,130.78 v2(93.5,130.48) ; v2(157.16,124.43) 157.26,124.32 157.26,122.52 156.17,121.43 156.17,118.77 156.55,118.39 156.55,116.88 156.32,116.65 156.32,116.22 159.56,112.98 163.03,112.98 166.91,109.1 169.44,109.1 176.03,102.51 176.03,99.06 181.24,93.85 181.24,92.3 182.16,91.38 182.75,91.38 182.99,91.14 182.99,90.78 181.71,89.5 181.71,87.03 181.01,86.33 181.01,85.47 181.26,85.22 181.26,84.63 181.3,84.6 181.3,83.05 181.86,82.49 181.86,77.33 181.29,76.77 179.91,76.77 178.09,74.94 178.09,74.53 178.83,73.78 178.83,73.43 180.16,72.1 180.16,71.28 v2(179.94,71.05) ; 133.76,75.98 134.67,75.07 135.2,75.07 135.78,74.5 135.78,73.25 136.24,72.79 136.9,72.79 137.38,72.31 137.53,72.31 R493.1 137.55,72.09 137.35,71.89 137.35,69.55 136.54,68.74 136.54,68.38 138.16,66.76 144.53,66.76 144.83,66.46 150.18,66.46 152.06,68.34 154.98,68.34 v2(155.57,68.93)
ISH_ACCEL_INT2#_S: length 42.4
  TOP w0.102: v2(74.68,124.44) 75.29,123.84 78.57,123.84 79.85,125.11 85.25,125.11 88.33,128.19 88.33,128.88 88.88,129.42 88.88,130.7 90.04,131.87 92.05,131.87 v2(92.51,131.41)
  BOTTOM w0.102: R7630.2 71.36,124.77 73.77,124.77 74.13,124.41 74.65,124.41 v2(74.68,124.44) 75.19,123.93 77.74,123.93 77.96,124.15 77.96,125.37 78.05,125.46 78.05,127.83 77.43,128.45 77.43,132.38 76.62,133.19 CN7602.9 ; v2(92.51,131.41) 92.12,131.8 Q7602.4
ISH_GP6: length 95.9
  TOP w0.102: v2(201.99,78.73) 202.49,78.24 Q4200.1 203.4,77.76 204.33,77.76 R4242.2
  IN2 w0.114: v2(177.99,64.65) 177.62,65.01 177.62,65.78 177,66.41 174.57,66.41 173.98,66.99 169.05,66.99 168.75,67.29 157.53,67.29 156.31,68.51 154.27,68.51 153.21,69.56 v2(152.09,69.56)
  BOTTOM w0.079: 135.99,75.23 135.55,75.66 134.67,75.66 133.43,76.89 131.55,76.89 129.69,78.76 U400.BW37
  BOTTOM w0.102: v2(201.99,78.73) 201.42,78.16 200.92,78.16 200.41,77.65 196.01,77.65 194.44,76.08 189.31,76.08 188.63,75.4 187.14,75.4 185.93,74.19 185.93,73.87 v2(185.28,73.22) 185.12,73.06 185.12,66.96 182.81,64.65 v2(177.99,64.65) ; 135.99,75.23 R494.1 136.92,74.55 137.07,74.4 137.07,73.3 137.55,72.81 138.15,72.81 138.37,72.59 138.75,72.59 139.26,72.08 139.26,71.16 139.08,70.98 139.08,69.61 139.5,69.19 141.57,69.19 142.8,67.96 144.92,67.96 145.31,67.57 150.1,67.57 v2(152.09,69.56)
ISH_I2C1_SCL: length 191.1
  TOP w0.102: v2(78.85,127.08) 77.76,125.99 R626.1
  IN2 w0.114: v1(135.92,87.57) 135.52,87.97 133.48,87.97 132.32,89.13 131.21,89.13 130.78,89.57 124.91,89.57 124.19,90.29 123.29,90.29 121.91,91.66 117.36,91.66 116.76,92.26 105.69,92.26 105.08,92.87 105.08,93.61 104.53,94.16 100.27,94.16 99.56,94.87 91.92,94.87 90.95,95.83 81.61,95.83 73.48,87.71 71.73,87.71 68.86,84.84 64.02,84.84 59.82,80.64 57.78,80.64 56.69,79.56 55.03,79.56 v2(54.92,79.45)
  BOTTOM w0.102: CN7602.11 76.9,134.19 77.91,133.18 77.91,132.75 77.63,132.47 77.63,128.56 78.85,127.33 v2(78.85,127.08) 78.85,126.37 78.25,125.77 78.25,125.37 78.17,125.29 78.17,124.07 77.82,123.73 74.52,123.73 73.68,124.56 70.54,124.56 69.28,123.29 67.47,123.29 66.89,123.88 66.89,127.47 65.87,128.49 58.16,128.49 57.57,127.9 57.57,126.02 55.12,123.58 50.83,123.58 48.96,121.71 48.96,105.5 48.65,105.18 48.65,100.17 50.43,98.39 50.43,97.4 54.21,93.61 54.21,93.31 54.69,92.83 54.69,79.68 v2(54.92,79.45) ; U400.CJ22 135.85,88.7 135.85,87.64 v1(135.92,87.57)
ISH_I2C1_SDA: length 190.5
  TOP w0.102: R625.1 78.52,125.91 79.26,126.65 v2(79.32,126.65)
  IN2 w0.114: v2(54.97,78.82) 55.48,79.33 56.79,79.33 57.87,80.42 59.92,80.42 64.11,84.61 68.96,84.61 71.82,87.48 73.57,87.48 81.7,95.6 90.88,95.6 91.83,94.65 99.42,94.65 100.13,93.94 104.33,93.94 104.79,93.49 104.79,92.73 105.56,91.96 116.74,91.96 117.29,91.41 121.78,91.41 123.12,90.07 124.1,90.07 124.83,89.34 130.7,89.34 131.15,88.89 132.25,88.89 133.63,87.51 v1(133.63,87.49)
  BOTTOM w0.102: v1(133.63,87.49) 133.92,87.77 133.92,88.3 134.65,89.03 U400.CH22 ; CN7602.12 76.69,134.69 78.11,133.26 78.11,132.66 77.83,132.38 77.83,128.68 79.32,127.2 v2(79.32,126.65) 79.32,126.33 78.45,125.46 78.45,125.29 78.37,125.21 78.37,123.98 77.91,123.52 74.43,123.52 73.61,124.35 70.62,124.35 69.36,123.09 67.38,123.09 66.68,123.79 66.68,127.39 65.79,128.28 58.25,128.28 57.77,127.81 57.77,125.94 55.21,123.37 50.92,123.37 49.17,121.62 49.17,105.42 48.85,105.1 48.85,100.25 50.63,98.47 50.63,97.48 54.42,93.7 54.42,93.39 54.89,92.92 54.89,88.07 55.33,87.64 55.33,79.18 v2(54.97,78.82)
ISOLATEB: length 8.5
  TOP w0.102: U4000.20 192.19,67.31 192.11,67.39 192.11,67.68 191.38,68.41 190.76,68.41 190.48,68.13 189.36,68.13 R4004.2 188.32,68.56 187.49,67.72 R4001.2 v2(186.43,66.85)
ITP_PMODE: length 117.1
  TOP w0.102: R7723.1 31.33,106.93 25.54,101.13 25.54,96.89 24.9,96.26 24.9,93.56 27.22,91.24 41.39,91.24 v2(42.43,90.2)
  IN2 w0.114: v2(42.43,90.2) 42.73,89.91 57.5,89.91 57.75,90.16 60.53,92.94 60.81,93.22 65.65,93.22 68.33,95.9 70.08,95.9 78.21,104.02 78.56,104.02 84.55,110.01 95.06,110.01 95.54,109.53 101,109.53 101.64,108.89 102.42,108.89 105.04,106.27 v2(105.04,105.05)
  BOTTOM w0.079: v2(105.04,105.05) 105.04,105.41 R604.1 105.52,105.43 105.52,103.82 105.33,103.62 105.33,101.68 105.21,101.56 105.21,101.37 105.21,101.37 105.21,101.08 105.21,101.08 105.21,100.75 104.9,100.44 U400.W4
JTAGX_PCH: length 14.4
  IN2 w0.079: 102.88,99.68 102.99,99.57 103.1,99.57 103.34,99.34 103.34,98.98 103.01,98.65 v2(103.01,98.58)
  IN2 w0.114: 102.88,99.68 102.78,99.78 102.78,100.2 102.97,100.39 102.97,103.18 103.82,104.04 103.82,105.4 102.78,106.43 102.09,106.43 v2(101.05,107.47)
  BOTTOM w0.102: R402.2 100.53,106.96 v2(101.05,107.47) ; v2(103.01,98.58) 102.94,98.5 102.25,98.5 101.9,98.86 U400.P6
KBC_PWR_ON: length 547.2
  TOP w0.102: v2(64.24,62.85) 64.24,61.09 66.05,59.28 110.65,59.28 111.49,60.13 112.35,60.13 112.66,59.82 112.66,58.63 113.09,58.2 115.37,58.2 PR9613.2 ; U4701.G7 205.11,52.96 205.44,52.63 v3(205.88,52.63) ; v2(125.08,121.46) 125.08,122.12 125.36,122.41 R3309.1 ; R4728.1 v2(213.47,54.89) ; PR9515.2 151.94,28.57 152.1,28.74 152.69,28.74 v2(152.96,29) ; v2(57.77,52.18) 57.8,52.18 59.22,50.77 102.9,50.77 104.96,48.71 117.04,48.71 117.89,47.86 143.7,47.86 144.46,48.62 170.03,48.62 177.67,56.26 177.96,56.26 178.94,57.24 179.44,57.74 186.09,57.74 v2(186.22,57.61) ; v2(172.73,29.39) 172.47,29.65 PR9513.2
  IN1 w0.076: 198.68,55.58 198.99,55.58 199.34,55.22 199.76,55.22 199.98,55.43 200.68,55.43 201.81,54.31 202.24,54.31 202.31,54.24 202.31,53.71 202.4,53.62 204.18,53.62 204.19,53.61 204.7,53.61 205.68,52.63 v3(205.88,52.63)
  IN1 w0.114: v2(172.73,29.39) 168.96,29.39 168.12,30.23 167.94,30.23 167.17,29.46 165.44,29.46 162.59,32.31 152.89,32.31 152.38,31.81 152.38,29.32 152.7,29 v2(152.96,29) ; 198.68,55.58 194.3,55.58 190.99,58.89 188.82,58.89 187.09,57.16 186.67,57.16 v2(186.22,57.61) ; v2(172.43,23.65) 174.62,25.85 v2(174.66,25.85)
  IN2 w0.076: v3(205.88,52.63) 206.21,52.96 206.76,52.96 207.58,52.15 207.58,50.2 208.24,49.54 208.24,46.44
  IN2 w0.114: v2(125.08,121.46) 121.46,121.46 117.84,117.85 115.48,117.85 115.19,117.56 110.02,117.56 108.04,115.58 95.16,115.58 94.59,116.15 90.44,116.15 87.45,119.14 85.33,119.14 82.14,122.34 77.07,122.34 76.88,122.53 71.95,122.53 69.93,124.55 60.81,124.55 60.08,123.82 49.97,123.82 49.8,123.65 45.78,123.65 45.55,123.42 39.13,123.42 38.43,122.72 38.43,121.53 37.91,121.01 37.91,120.05 31.89,114.03 31.89,109.39 30.37,107.87 30.37,105.34 29.47,104.44 29.47,95.83 28.56,94.92 28.56,90.31 35.7,83.16 55.78,83.16 v2(55.98,82.97) ; 208.24,46.44 208.24,46.35 208.72,45.87 208.72,44.64 208.17,44.09 208.17,35.7 204.23,31.76 204.23,18.97 203.15,17.89 203.15,14.6 199.17,10.62 198.31,10.62 197.33,9.65 193.37,9.65 v2(192.64,10.37)
  BOTTOM w0.076: v3(205.88,52.63) 205.52,52.99 205.52,53.45 205.67,53.6 207.45,53.6 207.63,53.78 207.63,54.38 208.55,55.3 208.85,55.3
  BOTTOM w0.102: v2(172.43,23.65) 173.74,22.34 173.74,21.71 173.93,21.52 173.93,21.01 174.1,20.84 174.1,20.39 174.31,20.19 174.31,19.68 175.1,18.88 177.38,18.88 178,18.26 182.67,18.26 189.37,11.56 191.98,11.56 192.64,10.9 v2(192.64,10.37) ; v2(174.66,25.85) 175.07,26.25 175.07,28.91 174.58,29.39 v2(172.73,29.39) ; v2(57.77,52.18) 60.31,54.72 60.31,54.78 64.24,58.71 v2(64.24,62.85) 64.24,64.44 64.6,64.79 64.6,66.54 64.94,66.88 64.94,70.04 61.83,73.15 58.74,73.15 55.98,75.91 v2(55.98,82.97) ; 208.85,55.3 210.8,55.3 211.06,55.05 212.41,55.05 212.62,55.25 213.11,55.25 v2(213.47,54.89)
KBC_PWR_ON_3: length 4
  TOP w0.102: v2(171.92,31.18) 171.92,30.96 171.69,30.73 PR9513.1 171.9,30.12 PC9530.1 171.62,29.29 171.49,29.41 170.05,29.41 PR9504.1
KBL_DET#: length 191.2
  TOP w0.102: v2(162.31,66.11) 162.31,67.03 161.96,67.38 160.32,67.38 159.43,66.49 154.32,66.49 153.02,67.79 149.09,67.79 148.16,66.86 146.5,66.86 145.68,66.04 136.98,66.04 135.08,67.93 134.34,67.93 133.66,68.61 133.66,69.46 133.23,69.89 R415.1 133.59,70.38 133.59,71.17 133.51,71.25 133.51,75.87 v2(130.76,78.62)
  IN2 w0.114: v2(173.25,21.44) 173.34,21.35 175.2,21.35 176.08,20.47 178.37,20.47 178.72,20.12 178.72,19.55 178.85,19.42 181.06,19.42 181.3,19.66 181.3,21.23 181.03,21.51 181.03,23.63 183.22,25.81 183.22,36.25 184.01,37.04 187.96,37.04 188.61,36.38 191.05,36.38 193.27,38.6 193.27,40.31 192.84,40.75 192.84,44.28 191.14,45.97 191.14,48.4 187.47,52.07 186.19,52.07 180.79,57.47 180.79,60.08 177.46,63.41 177.46,64.18 176.37,65.26 172.42,65.26 171.38,66.31 168.76,66.31 168.47,66.6 162.79,66.6 v2(162.31,66.11)
  BOTTOM w0.079: U400.CB34 130.78,81.2 130.59,81 130.59,79.49 130.76,79.32 v2(130.76,78.62)
  BOTTOM w0.102: CN5001.3 139.95,14.06 139.58,13.7 139.58,13.11 140.09,12.6 142.05,12.6 142.66,11.99 143.03,11.99 145.4,9.62 145.4,7.95 146.57,6.78 148.06,6.78 148.99,7.71 150.15,7.71 150.48,7.37 151.76,7.37 152.89,8.5 154.47,8.5 157.74,11.77 157.74,15.25 158.39,15.91 159.58,15.91 159.85,15.64 159.85,14.58 159.62,14.35 159.62,13.39 160.42,12.59 162.59,12.59 167.73,17.73 168.36,17.73 169.24,18.61 169.24,22.8 169.68,23.24 172.55,23.24 173.25,22.54 v2(173.25,21.44)
KSI0: length 239.6
  TOP w0.102: 45.41,49.54 D5000.6 ; 45.41,49.54 45.03,49.92 44.36,49.92 44.14,49.7 42.66,49.7 42.44,49.92 41.16,49.92 40.84,49.6 38.63,49.6 37.99,48.96 37.99,43.2 38.57,42.63 R5016.1 ; 45.41,49.54 45.84,49.97 46.4,49.97 46.69,49.69 47.43,49.69 47.98,49.14 v2(47.98,48.83) ; v2(200.37,49.28) 200.67,49.59 200.88,49.59 U4701.A2
  IN2 w0.076: 199.87,47.73 199.87,48.78 v2(200.37,49.28)
  IN2 w0.114: 199.87,47.73 199.87,44.93 200.81,43.99 200.81,43.05 201.51,42.36 201.51,35.18 199.86,33.53 199.86,23.35 199.23,22.72 199.23,20.8 194.7,16.26 189.67,16.26 189.04,15.63 185.39,15.63 184.03,14.27 163.17,14.27 162.28,13.37 143.53,13.37 143.33,13.37 142.82,13.89 141.87,13.89 141.81,13.95 141.34,13.95 140.32,14.97 139.06,14.97 137.25,16.79 136.67,16.79 135.73,17.73 134.05,17.73 131.93,19.86 130.73,19.86 130.19,20.4 130.19,21.15 129.57,21.77 129.57,25.09 128.67,25.99 126.56,25.99 123.67,28.88 120.01,28.88 117.56,31.34 112.64,31.34 111.57,32.42 104.28,32.42 103.73,32.97 98.32,32.97 97.55,32.21 95.96,32.21 95.65,31.91 91.95,31.91 91.78,32.07 82.88,32.07 81.84,33.11 71.2,33.11 68.07,29.99 63.7,29.99 63.43,29.72 60.96,29.72 60.76,29.52 55.06,29.52 53.43,31.15 v2(53.43,31.87)
  BOTTOM w0.102: v2(53.43,31.87) 53.76,31.87 54.37,32.47 C5015.2 54.11,33.33 53.32,33.33 53.07,33.58 53.07,34.09 52.76,34.4 52.15,34.4 51.2,33.44 50,33.44 49.18,34.27 48.56,34.27 47.06,35.77 47.06,38.44 45.82,39.68 45.82,42.34 46.99,43.5 46.99,46.47 47.95,47.44 47.95,48.47 47.98,48.5 v2(47.98,48.83)
KSI1: length 241.9
  TOP w0.102: v2(42.44,39.86) 40.9,39.86 40.62,40.14 39.94,40.14 39.2,40.87 R5016.2 ; v2(198.92,50.6) 199.53,49.99 200.54,49.99 200.91,50.36 U4701.A3 ; D5000.3 46.71,46.21 46.7,46.2 C5016.2 46.83,45.88 48.41,47.46 v2(48.41,48.26)
  IN2 w0.114: v2(198.92,50.6) 198.92,49.93 198.44,49.46 198.44,47.36 199.04,46.76 199.04,44.34 199.47,43.92 199.47,43.43 200.8,42.09 200.8,35.44 198.76,33.4 198.76,30.53 198.52,30.29 198.52,21.18 194.29,16.94 189.38,16.94 188.75,16.32 183.69,16.32 182.34,14.96 160.29,14.96 159.41,14.08 143.62,14.08 142.28,15.42 140.87,15.42 140.61,15.68 140.29,15.68 137.53,18.44 134.34,18.44 132.13,20.65 131.82,20.65 130.27,22.2 130.27,25.36 128.93,26.7 126.84,26.7 123.96,29.58 120.3,29.58 117.85,32.04 112.94,32.04 111.86,33.12 104.58,33.12 104.02,33.68 98.02,33.68 97.26,32.92 95.66,32.92 95.34,32.59 92.24,32.59 92.07,32.76 83.19,32.76 82.14,33.82 70.83,33.82 68.6,31.59 67.51,31.59 66.62,30.69 63.26,30.69 62.97,30.41 60.56,30.41 60.38,30.22 55.36,30.22 54.32,31.26 54.32,33.6 53.7,34.22 51.65,34.22 51.16,34.7 49.64,34.7 45.01,39.33 45.01,43.47 48.41,46.86 v2(48.41,48.26) 48.11,47.96 47.04,47.96 46.13,48.87 44.62,48.87 44.31,48.55 44.31,47.66 43.47,46.82 43.47,40.89 v2(42.44,39.86)
KSI2: length 230.7
  TOP w0.102: v2(45.09,44.97) 45.11,44.95 45.11,44.34 44.2,43.44 44.2,41.86 44,41.66 44,40.62 ; v2(56.04,28.83) 54.44,30.43 52.41,30.43 51.14,31.7 51.14,32.31 50.94,32.52 49.88,32.52 47.71,34.7 47.71,35.34 44.18,38.87 44.18,40.44 44,40.62 ; D5001.6 41.71,44.59 41.5,44.8 41.5,46.16 41.59,46.24 42.51,46.24 43.46,47.19 44.48,47.19 44.88,46.8 44.88,45.96 v2(44.85,45.93) ; v2(200.19,50.6) 200.5,50.6 200.91,51.01 U4701.A4 ; 44,40.62 43.74,40.36 42.1,40.36 41.48,40.97 C5017.2 40.55,40.97 39.84,41.69 R5016.3
  IN1 w0.114: v2(45.09,44.97) 44.85,45.21 v2(44.85,45.93)
  IN2 w0.076: v2(200.19,50.6) 200.19,49.99 200.78,49.4 200.78,49.17 200.1,48.5 200.1,47.66
  IN2 w0.114: 200.1,47.66 200.1,45.02 201.04,44.08 201.04,43.14 201.74,42.45 201.74,35.09 200.09,33.44 200.09,23.25 199.47,22.63 199.47,20.7 194.79,16.02 193.24,16.02 192.62,15.4 185.49,15.4 184.13,14.04 163.27,14.04 162.37,13.14 143.6,13.14 143.33,12.87 138.7,12.87 138.16,13.41 138.16,14.9 137.01,16.05 134.09,16.05 131.84,18.3 129.66,18.3 127.77,20.19 127.77,21.13 125.97,22.93 125.97,26.25 124.2,28.02 120.54,28.02 117.46,31.1 112.55,31.1 111.47,32.18 104.19,32.18 103.63,32.74 98.41,32.74 97.65,31.98 96.05,31.98 95.75,31.68 91.86,31.68 91.69,31.85 82.78,31.85 81.75,32.88 71.3,32.88 68.17,29.76 63.84,29.76 63.58,29.49 61.06,29.49 60.85,29.29 56.49,29.29 v2(56.04,28.83)
KSI3: length 225.6
  TOP w0.102: R5016.4 40.47,41.61 40.67,41.41 41.36,41.41 41.49,41.54 41.49,42.31 41.68,42.5 41.88,42.5 42.06,42.68 42.56,42.68 42.91,43.03 42.91,43.72 43.06,43.87 43.06,45.32 43.64,45.89 D5001.3 44.21,45.89 44.72,45.38 45.27,45.38 45.57,45.08 45.57,44.5 44.41,43.34 44.41,38.95 47.91,35.45 47.91,34.78 49.97,32.72 52.89,32.72 52.99,32.62 C5018.2 53.24,32.51 v2(53.64,32.51) ; U4701.B3 201.47,50.36 201.14,50.04 200.87,50.04 200.63,49.79 199.52,49.79 199.1,49.37 v2(199.1,49.23)
  IN2 w0.114: v2(199.1,49.23) 198.91,49.04 198.91,47.56 199.63,46.84 199.63,44.83 200.59,43.87 200.59,42.95 201.27,42.28 201.27,35.26 199.22,33.21 199.22,30.26 198.99,30.03 198.99,20.88 194.59,16.49 189.57,16.49 188.94,15.86 185.29,15.86 183.94,14.51 160.48,14.51 159.59,13.62 143.43,13.62 142.92,14.13 141.97,14.13 141.88,14.22 141.41,14.22 140.42,15.21 139.16,15.21 137.36,17.02 136.76,17.02 135.81,17.98 134.15,17.98 132.03,20.1 130.83,20.1 130.43,20.5 130.43,21.25 129.81,21.87 129.81,25.17 128.75,26.23 126.66,26.23 123.77,29.12 120.11,29.12 117.66,31.58 112.74,31.58 111.67,32.66 104.38,32.66 103.83,33.22 98.22,33.22 97.45,32.45 95.86,32.45 95.54,32.14 92.05,32.14 91.88,32.3 83,32.3 81.94,33.36 71.1,33.36 67.97,30.23 63.56,30.23 63.28,29.95 60.87,29.95 60.68,29.76 55.16,29.76 53.86,31.07 53.86,32.3 v2(53.64,32.51)
KSI4: length 240.3
  TOP w0.102: v2(53.58,33.74) 53.04,34.27 C5019.2 ; U4701.B4 201.33,50.69 200.87,50.69 200.38,50.2 199.96,50.2 v2(199.55,50.6) ; v2(44.63,49.39) 44.33,49.39 43.22,48.28 41.6,48.28 D5002.6 40.86,48.28 39.78,49.37 38.68,49.37 38.19,48.88 38.19,46.79 38.47,46.51 39.4,46.51 39.66,46.26 39.66,45.75 40.01,45.4 40.01,44.81 39.84,44.63 R5016.8
  IN2 w0.076: 198.67,48.9 198.67,49.32 199.55,50.2 v2(199.55,50.6)
  IN2 w0.114: v2(53.58,33.74) 54.09,33.22 54.09,31.17 55.26,30 60.53,30 60.71,30.18 63.13,30.18 63.41,30.47 67.88,30.47 71,33.59 82.04,33.59 83.1,32.53 91.97,32.53 92.14,32.36 95.43,32.36 95.76,32.69 97.36,32.69 98.12,33.45 103.92,33.45 104.48,32.89 111.76,32.89 112.84,31.81 117.75,31.81 120.21,29.36 123.86,29.36 126.75,26.47 128.84,26.47 130.04,25.26 130.04,21.97 130.66,21.35 130.66,20.6 130.91,20.35 132.1,20.35 134.24,18.21 137.43,18.21 140.2,15.45 140.51,15.45 140.77,15.19 142.19,15.19 143.53,13.85 159.5,13.85 160.39,14.74 183.85,14.74 185.2,16.09 188.84,16.09 189.47,16.72 194.44,16.72 198.76,21.03 198.76,30.17 198.99,30.4 198.99,33.3 201.03,35.35 201.03,42.19 200.36,42.86 200.36,43.78 199.39,44.74 199.39,46.74 198.67,47.46 198.67,48.9
  BOTTOM w0.102: v2(53.58,33.74) 53.58,33.97 52.94,34.6 52.05,34.6 51.1,33.65 50.09,33.65 49.26,34.47 48.65,34.47 47.26,35.86 47.26,38.53 46.03,39.76 46.03,42.25 47.19,43.42 47.19,46.39 48.82,48.02 48.82,48.8 48.11,49.51 45.43,49.51 45.3,49.39 v2(44.63,49.39)
KSI5: length 245.8
  TOP w0.102: v2(135.13,12.81) 136.14,12.81 137.19,11.76 143.15,11.76 146.65,8.26 150.09,8.26 v2(150.84,9.01) ; U4701.C3 v3(201.98,50.68) ; v2(44.83,48.35) 44.04,48.35 42.34,46.65 41.26,46.65 41.09,46.48 41.09,45.92 40.85,45.68 40.52,45.68 40.28,45.92 40.28,46.29 40.48,46.5 40.48,46.86 40.36,46.98 D5002.3 39.86,46.84 39.86,45.93 40.23,45.56 40.23,45.18 40.47,44.94 R5016.7
  IN2 w0.076: 201.9,47.68 201.9,47.99 202.42,48.51 202.42,49.73 201.98,50.17 v3(201.98,50.68)
  IN2 w0.114: v2(150.84,9.01) 151.99,10.17 155.3,10.17 155.69,9.78 159.62,9.78 160.79,10.95 162.77,10.95 164.03,12.21 185.17,12.21 186.15,13.19 188.86,13.19 189.25,13.57 197,13.57 197.98,14.55 197.98,16.34 201.3,19.66 201.3,21.87 201.92,22.49 201.92,32.68 203.57,34.33 203.57,40.05 203.95,40.43 203.95,45.2 202.61,46.54 202.16,46.54 201.9,46.8 201.9,47.68 ; v2(50.73,32.11) 50.92,31.93 50.92,31.69 51.83,30.77 51.83,27.6 53.23,26.2 54.65,26.2 54.77,26.08 55.53,26.08 56.19,26.73 59.61,26.73 59.9,27.02 65,27.02 65.32,26.69 67.7,26.69 69.95,28.94 75.32,28.94 77.43,31.05 80.99,31.05 82.02,30.02 90.93,30.02 92.11,28.84 95.5,28.84 96.09,29.42 96.81,30.15 98.55,30.15 98.74,30.34 101.51,30.34 104.2,27.65 109.6,27.65 111.22,26.02 114.78,26.02 117.47,23.32 121.97,23.32 126.71,18.58 126.71,17.04 125.94,16.27 125.94,14.64 128.72,11.86 128.9,11.86 129.2,11.56 132.06,11.56 133.46,12.96 134.97,12.96 v2(135.13,12.81)
  BOTTOM w0.102: v2(50.73,32.11) 50.96,32.11 51.45,32.6 C5020.2 51.24,33.03 49.85,33.03 49.03,33.84 48.42,33.84 46.65,35.6 46.65,38.27 45.42,39.51 45.42,42.51 46.58,43.67 46.58,47.15 45.38,48.35 v2(44.83,48.35)
KSI6: length 261.4
  TOP w0.102: v2(42.63,37.33) 40.96,37.33 40.48,37.81 D5003.6 ; v2(134.52,13.39) 134.69,13.21 136.02,13.21 137.27,11.96 143.24,11.96 146.15,9.05 v2(150.2,9.05) ; U4701.C4 202.3,51.01 v3(201.98,51.33) ; v2(45.51,45.93) 45.08,46.37 45.08,46.88 44.48,47.48 43.45,47.48 42.42,46.45 41.5,46.45 41.3,46.24 41.3,45.57 41.11,45.38 R5016.6
  IN2 w0.076: v3(201.98,51.33) 201.66,51.02 201.66,50.16 202.17,49.65 202.17,48.54 201.71,48.09 201.71,47.63
  IN2 w0.114: v2(150.2,9.05) 151.55,10.39 155.39,10.39 155.78,10 159.53,10 160.7,11.17 162.67,11.17 163.93,12.44 184.9,12.44 186.03,13.57 188.83,13.57 189.06,13.8 195.45,13.8 195.97,14.32 195.97,14.84 201.07,19.94 201.07,21.96 201.69,22.59 201.69,32.77 203.34,34.42 203.34,40.14 203.72,40.52 203.72,45.08 203.11,45.69 202.23,45.69 201.71,46.21 201.71,47.63 ; v2(45.51,45.93) 45.51,45.7 45.24,45.42 44.46,45.42 44.1,45.06 44.1,39.58 43.12,38.6 42.37,38.6 42.15,38.38 42.15,37.82 v2(42.63,37.33) ; v2(52.18,31.81) 52.18,31.5 52.06,31.38 52.06,27.69 52.66,27.09 54.12,27.09 54.9,26.31 55.44,26.31 56.09,26.96 59.52,26.96 59.8,27.25 65.1,27.25 65.42,26.92 67.6,26.92 69.85,29.17 75.23,29.17 77.33,31.28 81.08,31.28 82.12,30.25 91.03,30.25 91.19,30.08 92.13,30.08 92.93,29.29 95.63,29.29 96.72,30.38 98.46,30.38 98.65,30.57 101.6,30.57 104.3,27.88 109.69,27.88 111.32,26.25 114.9,26.25 117.59,23.55 122.06,23.55 126.94,18.68 126.94,13.97 128.82,12.09 128.99,12.09 129.29,11.79 131.96,11.79 133.56,13.39 v2(134.52,13.39)
  BOTTOM w0.102: v2(52.18,31.81) 52.91,32.54 C5021.2 52.91,33.23 52.81,33.33 52.81,33.97 52.59,34.19 52.25,34.19 51.29,33.23 49.93,33.23 49.09,34.07 48.48,34.07 46.85,35.69 46.85,38.36 45.62,39.59 45.62,42.42 46.78,43.58 46.78,47.3 45.32,48.76 44.57,48.76 44.39,48.58 44.39,47.42 44.57,47.24 44.77,47.24 45.51,46.49 v2(45.51,45.93)
KSI7: length 241.6
  TOP w0.102: v2(39.02,46.11) 39.73,45.39 39.73,44.99 39.2,44.46 R5016.9 ; U4701.C5 v3(201.98,51.98)
  IN2 w0.076: 201.48,47.66 201.48,48.16 201.94,48.62 201.94,49.67 201.51,50.09 201.51,51.31 201.98,51.78 v3(201.98,51.98)
  IN2 w0.114: v2(53.53,29.77) 53.53,29.41 52.29,28.17 52.29,27.79 52.76,27.32 54.21,27.32 54.99,26.54 55.34,26.54 56,27.19 59.42,27.19 59.71,27.48 65.4,27.48 66.31,28.38 68.74,28.38 69.76,29.4 75.13,29.4 77.24,31.51 81.18,31.51 82.21,30.47 91.12,30.47 91.29,30.31 92.23,30.31 92.87,29.66 95.68,29.66 96.62,30.61 98.36,30.61 98.55,30.8 101.7,30.8 104.39,28.1 109.78,28.1 111.41,26.48 114.99,26.48 117.69,23.78 122.16,23.78 126.4,19.54 127.17,18.77 127.17,14.06 128.91,12.32 129.09,12.32 129.39,12.02 131.87,12.02 133.56,13.71 133.56,14.49 133.75,14.68 135.62,14.68 135.9,14.41 135.9,13.04 137.44,11.5 144.27,11.5 144.65,11.12 147.4,11.12 148.04,11.77 153.04,11.77 154.19,10.62 155.49,10.62 155.88,10.23 159.43,10.23 160.6,11.4 162.58,11.4 163.84,12.66 184.8,12.66 186.04,13.9 188.7,13.9 188.83,14.03 195.36,14.03 195.74,14.41 195.74,14.94 200.84,20.04 200.84,22.06 201.46,22.68 201.46,32.87 203.11,34.52 203.11,40.24 203.49,40.62 203.49,44.98 203.01,45.46 202.14,45.46 201.48,46.12 201.48,47.66
  BOTTOM w0.102: v2(53.53,29.77) 53.8,30.05 C5022.2 53.8,31.2 53.6,31.4 52,31.4 51.72,31.68 50.29,31.68 46.45,35.52 46.45,38.19 45.21,39.42 45.21,42.68 45.71,43.18 45.71,44.95 45.18,45.48 44.64,45.48 44.03,46.09 44.03,46.6 43.9,46.72 CN5000.23 42.63,46.72 42.53,46.82 40.19,46.82 39.47,46.11 v2(39.02,46.11)
KSI_D_0: length 13.3
  TOP w0.102: v2(42.45,39.23) 43.58,39.23 v2(43.62,39.19) ; v2(44.83,47.71) 45.3,47.71 45.41,47.6 D5000.1
  IN2 w0.114: v2(44.83,47.71) 43.74,46.62 43.74,40.15 42.82,39.23 v2(42.45,39.23)
  BOTTOM w0.102: CN5000.9 42.95,39.72 42.45,39.23 v2(42.45,39.23)
KSI_D_1: length 16
  TOP w0.102: D5000.5 46.06,48.25 46.25,48.06 47.2,48.06 47.5,48.37 v2(47.5,48.41)
  IN2 w0.114: v2(47.5,48.41) 46.92,48.41 45.46,49.87 44.42,49.87 43.91,49.36 43.91,47.59 43.21,46.89 43.21,42.09 v2(42.53,41.41)
  BOTTOM w0.102: v2(42.53,41.41) 42.72,41.22 CN5000.12
KSI_D_2: length 5.6
  TOP w0.102: D5001.1 43.86,44.13 44.02,43.96 44.02,43.55 43.58,43.11 v2(43.58,42.23) 43.58,41.62 42.73,40.77 v2(42.52,40.77)
  BOTTOM w0.102: CN5000.11 42.56,40.72 v2(42.52,40.77)
KSI_D_3: length 6
  TOP w0.102: v2(41.72,42.94) 41.72,43.66 42.26,44.19 42.7,44.19 42.86,44.35 42.86,45.12 42.73,45.24 D5001.5
  BOTTOM w0.102: v2(41.72,42.94) 42.06,42.61 42.51,42.61 42.68,42.44 42.68,42.07 43.03,41.72 CN5000.13
KSI_D_4: length 21.3
  TOP w0.102: D5002.1 39.63,48.28 v2(38.98,47.63)
  BOTTOM w0.102: CN5000.10 42.82,40.22 42.77,40.28 42.31,40.28 42.01,40.57 42.01,41.48 42.46,41.92 42.46,42.29 42.34,42.41 41.64,42.41 41.03,41.79 41.03,39.83 40.46,39.26 39.42,39.26 38.97,39.71 38.97,41.49 39.86,42.38 39.86,45.37 39.58,45.65 38.87,45.65 38.44,46.08 38.44,46.38 38.57,46.51 39.28,46.51 39.43,46.67 39.43,47.18 v2(38.98,47.63)
KSI_D_5: length 5.2
  TOP w0.102: D5002.5 40.95,47.63 40.69,47.36 v2(40.69,46.08)
  BOTTOM w0.102: v2(40.69,46.08) 40.87,46.08 41.24,45.72 CN5000.21
KSI_D_6: length 14.3
  TOP w0.102: D5003.1 40.97,37.81 40.75,38.03 40.75,39.49 40.51,39.73 v2(40.16,39.73) 39.67,39.73 v2(39.44,39.96)
  BOTTOM w0.102: v2(40.16,39.73) 39.62,40.27 39.62,41.22 40.24,41.84 40.24,46.24 40.51,46.51 40.9,46.51 41.1,46.32 42.69,46.32 42.69,46.32 42.79,46.22 CN5000.22
KSI_D_8: length 14.6
  TOP w0.102: v2(47.35,47.41) 46.99,47.78 46.25,47.78 46.06,47.59 D5000.2
  IN2 w0.114: v2(47.35,47.41) 47.35,47.22 46.65,46.52 46.65,45.48 45.87,44.7 45.58,44.7 44.33,43.44 44.33,39.34 43.16,38.18 v2(42.63,38.18)
  BOTTOM w0.102: CN5000.6 42.67,38.22 v2(42.63,38.18)
KSI_D_9: length 7
  TOP w0.102: v2(47.35,49.06) 47.35,49.27 47.13,49.48 46.6,49.48 46.52,49.57 v2(46.23,49.57) 46.23,49.48 46.71,49 D5000.4
  BOTTOM w0.102: CN5000.26 43.88,48.22 44.03,48.37 44.03,48.65 44.35,48.97 45.73,48.97 45.82,48.88 47.17,48.88 v2(47.35,49.06)
KSI_D_10: length 9.6
  TOP w0.102: v2(41.92,41.99) 42.32,41.99 43.16,42.83 43.16,43.36 v2(43.53,43.72) 43.26,43.98 43.26,45.02 43.49,45.24 D5001.2
  BOTTOM w0.102: v2(41.92,41.99) 41.92,41.99 41.81,41.88 41.81,39.2 42.23,38.79 42.59,38.79 43.02,39.22 CN5000.8
KSI_D_11: length 4.6
  TOP w0.102: D5001.4 42.79,45.89 43.66,46.76 v2(43.77,46.76) 44.18,46.76 v2(44.44,46.5)
  BOTTOM w0.102: CN5000.25 44.07,47.72 44.18,47.6 44.18,47.21 44.44,46.95 v2(44.44,46.5)
KSI_D_12: length 18.2
  TOP w0.102: v2(38.82,48.93) 38.4,48.5 38.4,47.44 38.92,46.92 v2(39.02,46.92) 39.02,47.09 39.56,47.63 D5002.2
  BOTTOM w0.102: CN5000.7 42.86,38.72 42.73,38.59 39.81,38.59 38.77,39.63 38.77,41.57 39.66,42.46 39.66,45.29 39.5,45.45 38.79,45.45 38.23,46 38.23,46.47 38.68,46.92 v2(39.02,46.92)
KSI_D_13: length 2.5
  TOP w0.102: v2(42.51,47.68) 42.51,47.38 42.11,46.98 D5002.4
  BOTTOM w0.102: v2(42.51,47.68) 42.97,47.22 CN5000.24
KSI_D_14: length 4.4
  TOP w0.102: v2(44.42,37.64) 44.32,37.74 42.26,37.74 42.17,37.83 42.17,38.13 41.85,38.46 D5003.2
  BOTTOM w0.102: CN5000.5 44.34,37.72 v2(44.42,37.64)
KSO0: length 279.3
  TOP w0.102: v2(198.92,51.57) 199.35,51.14 200.53,51.14 200.72,51.33 201.33,51.33 U4701.B5
  IN2 w0.114: v2(198.92,51.57) 198.7,51.35 197.42,51.35 196.97,50.9 196.97,50.35 197.97,49.35 197.97,47.17 198.57,46.57 198.57,44.17 199.01,43.73 199.01,43.22 200.33,41.9 200.33,35.61 198.28,33.57 198.28,30.74 198.05,30.5 198.05,21.36 194.11,17.42 189.16,17.42 188.51,16.77 183.5,16.77 182.8,16.08 177.25,16.08 176.64,15.47 160.15,15.47 159.24,14.56 143.82,14.56 142.48,15.89 141.07,15.89 140.81,16.15 140.49,16.15 137.73,18.92 134.53,18.92 132.32,21.12 132.02,21.12 130.75,22.39 130.75,25.55 129.14,27.16 127.42,27.16 127.21,27.37 127.21,27.88 125.03,30.06 120.5,30.06 118.05,32.52 113.13,32.52 112.06,33.59 104.78,33.59 104.22,34.16 94.51,34.16 93.57,33.22 83.41,33.22 82.33,34.3 70.54,34.3 68.31,32.06 67.31,32.06 66.42,31.17 61.08,31.17 60.71,31.55 59.68,31.55 59.48,31.35 56.68,31.35 v2(56.45,31.12)
  BOTTOM w0.102: v2(198.92,51.57) 198.36,51.57 197.47,52.45 197.47,52.7 197.48,52.7 197.48,55.43 196.73,56.18 196.31,56.18 195.7,56.8 194.98,56.8 194.12,57.66 192.16,57.66 192.01,57.82 191.14,57.82 190.97,57.64 190.97,57.62 190.37,57.03 189.95,57.03 188.61,55.69 186.74,55.69 186.46,55.41 184.48,55.41 183.14,56.75 179.33,56.75 177.99,55.41 177.71,55.41 177.29,55.83 177.29,56.64 172.4,61.53 171.73,61.53 169.83,63.43 169.83,63.99 169.12,64.71 169.12,65.3 169.11,65.3 169.11,66.88 168.1,67.88 168.1,68.69 167.69,69.1 167.69,76.39 166.49,77.58 164.32,77.58 164.03,77.3 CN7701.27 ; CN5000.2 43.96,36.22 44.08,36.1 44.08,35.21 45.07,34.22 45.42,34.22 49.03,30.61 49.03,29.27 48.34,28.58 48.34,26.37 49,25.71 49.89,25.71 50.27,26.09 51.8,26.09 52.02,26.32 C5003.2 52.05,26.73 52.76,26.01 55.23,26.01 55.99,26.78 55.99,28 55.63,28.35 55.63,29.97 56.45,30.78 v2(56.45,31.12)
KSO1: length 280.4
  TOP w0.102: U4701.B6 201.33,51.99 200.91,51.99 200.86,51.93 200.57,51.93 200.56,51.93 200.15,51.93 199.76,51.54 v2(199.63,51.54)
  IN2 w0.114: v2(54.75,32.06) 54.75,31.17 55.46,30.46 60.23,30.46 60.43,30.66 62.85,30.66 63.11,30.93 66.52,30.93 67.41,31.82 68.45,31.82 70.68,34.05 82.23,34.05 83.3,32.99 92.16,32.99 92.33,32.82 95.24,32.82 95.58,33.15 97.16,33.15 97.93,33.91 104.12,33.91 104.68,33.35 111.96,33.35 113.03,32.28 117.95,32.28 120.4,29.82 124.95,29.82 126.98,27.79 126.98,27.27 127.32,26.93 129.03,26.93 130.51,25.45 130.51,22.29 131.92,20.88 132.22,20.88 134.41,18.69 137.61,18.69 140.39,15.91 140.71,15.91 140.97,15.65 142.38,15.65 143.72,14.31 159.32,14.31 160.23,15.22 176.72,15.22 177.34,15.85 182.9,15.85 183.59,16.54 188.65,16.54 189.29,17.18 194.19,17.18 198.29,21.27 198.29,30.42 198.52,30.65 198.52,33.49 200.57,35.53 200.57,42 199.24,43.33 199.24,43.82 198.81,44.25 198.81,46.67 198.21,47.27 198.21,49.45 197.22,50.45 197.22,50.8 197.52,51.11 199.2,51.11 v2(199.63,51.54)
  BOTTOM w0.102: CN5000.20 44.45,45.22 44.68,44.98 44.68,44.4 45.01,44.07 45.01,39.34 45.84,38.51 46.25,38.11 46.25,35.44 50.2,31.48 51.62,31.48 52.21,30.89 C5004.2 52.21,29.87 52.79,29.29 54.15,29.29 54.23,29.37 54.23,31.55 v2(54.75,32.06) ; v2(199.63,51.54) 199.19,51.98 198.24,51.98 198.09,52.13 197.69,52.53 197.69,55.54 196.83,56.4 196.4,56.4 195.79,57.01 195.07,57.01 194.21,57.87 192.29,57.87 192.14,58.03 191.06,58.03 190.76,57.72 190.76,57.7 190.29,57.24 189.86,57.24 188.53,55.91 186.66,55.91 186.38,55.62 184.57,55.62 183.05,57.14 177.38,57.14 172.57,61.94 171.9,61.94 170.8,63.04 170.8,64.33 169.32,65.81 169.32,66.97 168.31,67.97 168.31,68.77 167.9,69.19 167.9,76.47 166.57,77.79 164.03,77.79 163.54,77.3 CN7701.26
KSO2: length 282.2
  TOP w0.102: v2(200.53,52.52) 200.64,52.63 201.33,52.63 U4701.B7
  IN2 w0.114: v2(56.4,31.78) 56.58,31.59 59.39,31.59 59.6,31.81 60.77,31.81 61.16,31.41 66.32,31.41 67.22,32.31 68.18,32.31 70.4,34.54 82.43,34.54 83.52,33.45 93.32,33.45 94.27,34.4 104.32,34.4 104.88,33.83 112.16,33.83 113.23,32.76 118.15,32.76 120.6,30.3 125.11,30.3 127.44,27.97 127.44,27.46 127.51,27.39 129.24,27.39 131.01,25.62 131.01,22.48 132.12,21.37 132.42,21.37 134.63,19.16 137.83,19.16 140.59,16.39 140.91,16.39 141.17,16.13 142.58,16.13 143.92,14.8 157.09,14.8 158.22,15.93 171.97,15.93 172.19,15.71 176.56,15.71 177.16,16.31 182.71,16.31 183.4,17 188.42,17 189.08,17.66 192.88,17.66 193.73,18.51 194.84,18.51 197.8,21.47 197.8,30.62 198.04,30.85 198.04,33.67 200.08,35.71 200.08,40.44 198.78,41.74 198.78,43.63 198.33,44.09 198.33,46.47 197.73,47.07 197.73,49.25 196.73,50.25 196.73,51.02 197.31,51.59 198.38,51.59 198.82,52.02 200.03,52.02 v2(200.53,52.52)
  BOTTOM w0.102: CN7701.24 162.54,77.65 163.13,78.24 166.7,78.24 168.33,76.61 168.33,74.51 169.13,73.71 169.13,67.77 169.75,67.14 169.75,65.99 171.93,63.81 171.93,63.19 177.56,57.57 183.23,57.57 184.75,56.05 186.2,56.05 186.48,56.34 187.07,56.34 188.04,57.31 188.04,57.8 188.7,58.47 192.27,58.47 192.46,58.27 194.42,58.27 195.25,57.44 196.93,57.44 197.17,57.2 197.17,56.67 198.12,55.71 198.12,52.71 198.42,52.41 199.37,52.41 199.42,52.36 200.37,52.36 v2(200.53,52.52) ; CN5000.3 44.15,36.72 44.36,36.51 44.36,35.26 45.17,34.45 45.51,34.45 49.23,30.72 49.23,29.16 48.55,28.48 48.55,26.55 49,26.09 49.77,26.09 50.91,27.23 52.02,27.23 52.53,26.73 C5005.2 52.59,26.57 52.94,26.22 55.1,26.22 55.79,26.9 55.79,27.57 v2(55.53,27.83) 55.43,27.93 55.43,30.05 56.04,30.66 56.04,31.43 v2(56.4,31.78)
KSO3: length 290.5
  TOP w0.102: U4701.B8 201.31,53.26 200.1,53.26 v2(199.61,52.77)
  IN1 w0.114: v2(49.89,27.86) 50.4,28.37 50.4,28.76 50.19,28.97 48.08,28.97 47.1,29.95 47.1,33.39 45.51,34.98 44.79,34.98 43.01,36.76 42.57,36.76 42.2,37.13 42.2,37.64 41.77,38.07 41.77,41.33 41.4,41.7 41.4,42.24 41.68,42.52 42.06,42.52 42.35,42.81 v2(42.35,43.13)
  IN2 w0.114: v2(199.61,52.77) 199.18,52.34 198.84,52.34 198.33,51.83 197.21,51.83 196.49,51.12 196.49,50.15 197.49,49.15 197.49,46.97 198.08,46.37 198.08,44.01 198.55,43.54 198.55,41.64 199.84,40.35 199.84,35.81 197.8,33.77 197.8,30.97 197.56,30.73 197.56,21.56 194.74,18.74 193.63,18.74 192.79,17.9 189,17.9 188.32,17.23 183.31,17.23 182.61,16.53 177.06,16.53 176.47,15.95 172.31,15.95 172.07,16.19 157.97,16.19 157.65,15.87 154.85,15.87 154.42,15.44 151.69,15.44 151.29,15.04 144.02,15.04 142.68,16.38 141.45,16.38 140.65,17.17 140.65,17.66 138.92,19.39 134.73,19.39 132.52,21.61 132.22,21.61 131.25,22.58 131.25,25.72 129.34,27.63 128.81,27.63 128.14,28.3 127.45,28.3 125.21,30.54 120.7,30.54 118.25,33 113.33,33 112.26,34.07 104.98,34.07 104.42,34.64 89.19,34.64 88.22,33.67 83.64,33.67 82.53,34.78 70.26,34.78 68.05,32.57 67.13,32.57 66.22,31.65 61.25,31.65 60.84,32.06 59.51,32.06 59.29,31.83 57.16,31.83 56.78,32.21 56.22,32.21 55.96,31.96 55.96,31.43 v2(55.53,30.99)
  BOTTOM w0.102: CN5000.14 43.04,42.22 42.88,42.37 42.88,42.6 v2(42.35,43.13) ; v2(199.61,52.77) 199.75,52.91 200.69,52.91 200.92,52.68 200.92,52.36 200.69,52.14 199.34,52.14 199.28,52.2 198.33,52.2 197.91,52.62 197.91,55.62 196.92,56.62 196.49,56.62 195.88,57.23 195.16,57.23 194.31,58.07 192.38,58.07 192.21,58.24 190.06,58.24 187.94,56.12 186.57,56.12 186.29,55.84 184.66,55.84 183.14,57.35 177.47,57.35 172.66,62.16 171.99,62.16 171.02,63.13 171.02,64.42 169.54,65.9 169.54,67.05 168.53,68.06 168.53,68.86 168.11,69.28 168.11,76.54 166.63,78.02 163.6,78.02 163.03,77.46 CN7701.25 ; v2(55.53,30.99) 55.53,30.44 55.18,30.09 55.18,28.03 54.48,27.34 52.58,27.34 52.17,27.74 51.08,27.74 50.47,28.36 C5006.2 49.96,27.86 49.9,27.86 v2(49.89,27.86)
KSO4: length 221.4
  TOP w0.102: U4701.C7 v3(201.98,53.28)
  IN2 w0.076: 201.02,47.76 201.02,48.34 201.49,48.8 201.49,49.62 201.21,49.9 201.21,51.75 201.46,52 201.46,52.76 v3(201.98,53.28)
  IN2 w0.114: 201.02,47.76 201.02,45.91 201.94,44.99 202.7,44.99 202.93,44.76 202.93,40.82 202.66,40.55 202.66,34.71 201,33.06 201,22.87 200.38,22.25 200.38,20.29 195.2,15.11 194.89,15.11 194.27,14.49 185.87,14.49 184.51,13.12 163.65,13.12 162.39,11.86 160.41,11.86 159.63,11.08 154.38,11.08 153.23,12.22 147.85,12.22 147.21,11.58 144.84,11.58 144.46,11.95 138.24,11.95 137.24,12.96 137.24,14.52 136.63,15.14 133.71,15.14 131.46,17.39 129.2,17.39 121.57,25.02 117.12,25.02 115.2,26.93 112.46,26.93 108.25,31.15 101.99,31.15 101.89,31.26 98.36,31.26 98.17,31.06 96.43,31.06 96.13,30.76 91.48,30.76 91.31,30.93 82.4,30.93 81.37,31.96 77.05,31.96 74.94,29.86 69.57,29.86 68.55,28.84 66.12,28.84 65.21,27.93 59.52,27.93 59.27,27.68 55.19,27.68 55.06,27.55 53.28,27.55 v2(52.86,27.97)
  BOTTOM w0.102: CN5000.16 44.06,43.22 44.19,43.08 44.19,38.87 45.19,37.87 45.19,36.47 44.77,36.05 44.77,35.43 45.34,34.85 45.68,34.85 49.64,30.89 49.64,29.52 49.87,29.29 51.68,29.29 52.47,28.5 C5007.2 52.59,28.24 v2(52.86,27.97)
KSO5: length 220.3
  TOP w0.102: U4701.C6 v3(201.98,52.63)
  IN2 w0.076: 201.25,47.71 201.25,48.24 201.71,48.7 201.71,49.61 201.36,49.97 201.36,51.55 201.66,51.85 201.66,52.32 v3(201.98,52.63)
  IN2 w0.114: v2(55.13,27.01) 55.57,27.45 59.36,27.45 59.62,27.7 65.31,27.7 66.21,28.61 68.65,28.61 69.66,29.63 75.04,29.63 77.14,31.74 81.27,31.74 82.31,30.7 91.22,30.7 91.38,30.54 92.65,30.54 93.28,29.91 95.6,29.91 96.53,30.83 98.27,30.83 98.46,31.03 101.79,31.03 104.49,28.33 109.88,28.33 111.51,26.7 115.1,26.7 117.8,24.01 122.25,24.01 129.1,17.16 131.37,17.16 133.62,14.91 136.53,14.91 137.01,14.43 137.01,12.86 138.15,11.73 144.37,11.73 144.74,11.35 147.3,11.35 147.95,12 153.14,12 154.28,10.85 155.62,10.85 156,10.46 159.34,10.46 160.51,11.63 162.48,11.63 163.75,12.89 184.6,12.89 185.97,14.26 195.26,14.26 195.51,14.51 195.51,15.04 200.61,20.14 200.61,22.15 201.23,22.78 201.23,32.96 202.88,34.61 202.88,40.33 203.27,40.71 203.27,44.89 202.92,45.23 202.04,45.23 201.25,46.02 201.25,47.71
  BOTTOM w0.102: CN5000.4 44.08,37.22 44.56,36.73 44.56,35.35 45.26,34.65 45.59,34.65 49.44,30.81 49.44,29.06 48.75,28.38 48.75,26.73 49,26.47 49.77,26.47 50.83,27.54 52.09,27.54 52.52,27.1 54.46,27.1 54.56,26.99 C5008.2 54.85,26.73 v2(55.13,27.01)
KSO6: length 228.7
  TOP w0.102: U4701.C8 v3(202.63,53.93)
  IN1 w0.114: v2(192.4,12.89) 191.62,13.67 188.62,13.67 186.76,15.53 185.16,15.53 184.3,16.38 177.55,16.38 176.27,15.09 162.09,15.09 161.83,14.84 154.24,14.84 152.05,17.02 148.98,17.02 147.67,15.72 144.63,15.72 143.14,17.21 141.2,17.21 135.59,22.81 133.92,22.81 133.62,22.52 132.6,22.52 132.19,22.93 132.19,27.57 130,29.75 129.31,29.75 128.94,30.13 128.94,30.46 128.41,30.99 120.85,30.99 119.13,32.71 113.97,32.71 113.32,33.36 103.99,33.36 103.33,34.02 94.65,34.02 93.51,32.87 87.15,32.87 86.89,32.61 82.75,32.61 82.54,32.82 66.46,32.82 65.65,32.01 57.54,32.01 56.61,32.94 53.37,32.94 52.94,32.51 52.94,31.68 52.64,31.37 51.05,31.37 50.54,30.87 v2(50.54,30.84)
  IN2 w0.076: 203.66,47.47 203.75,47.57 203.75,48.29 203.18,48.86 203.18,49.94 203.15,49.98 203.15,50.81 202.73,51.23 202.73,51.66 202.95,51.89 202.95,53.61 v3(202.63,53.93)
  IN2 w0.114: v2(192.4,12.89) 192.63,13.12 197.29,13.12 198.61,14.43 198.61,16.11 202.38,19.87 202.38,32.49 204.17,34.29 204.17,40 205.61,41.44 205.61,44.96 204.94,45.63 204.59,45.63 203.66,46.57 203.66,47.47
  BOTTOM w0.102: v2(50.54,30.84) 50.3,30.6 C5009.2 50.05,30.29 50.05,31.06 45.84,35.27 45.84,37.8 44.6,39.04 44.6,43.9 44.28,44.22 CN5000.18
KSO7: length 285.4
  TOP w0.102: R4751.2 v2(198.69,54.11) 199,54.42 199.6,54.42 199.92,54.09 199.92,53.99 200.19,53.72 200.69,53.72 200.9,53.93 201.33,53.93 U4701.B9
  IN2 w0.114: v2(198.69,54.11) 197.91,54.11 197.43,54.59 196.4,54.59 195.04,53.23 195.04,50.7 195.85,49.9 197.25,48.49 197.25,46.87 197.85,46.27 197.85,43.91 198.32,43.44 198.32,41.55 199.61,40.26 199.61,35.91 197.56,33.86 197.56,31.06 197.33,30.83 197.33,23.16 195.44,21.27 195.44,19.77 194.64,18.97 193.54,18.97 192.71,18.14 188.91,18.14 188.23,17.46 183.21,17.46 182.52,16.76 176.97,16.76 176.38,16.18 172.53,16.18 172.11,16.59 172.11,16.6 171.84,16.87 169.82,16.87 169.38,16.43 157.84,16.43 157.51,16.1 154.75,16.1 154.32,15.67 151.59,15.67 151.19,15.27 144.12,15.27 142.78,16.61 141.54,16.61 140.88,17.27 140.88,17.76 139.01,19.63 134.82,19.63 132.61,21.84 132.32,21.84 131.49,22.67 131.49,25.82 129.44,27.87 128.91,27.87 128.24,28.54 127.55,28.54 125.31,30.78 120.8,30.78 118.34,33.23 113.43,33.23 112.36,34.31 105.08,34.31 104.51,34.87 89.1,34.87 88.13,33.9 83.74,33.9 82.63,35.01 70.12,35.01 67.92,32.81 67.05,32.81 66.12,31.89 61.33,31.89 60.91,32.31 59.43,32.31 59.19,32.07 57.25,32.07 56.88,32.45 56.12,32.45 55.48,31.81 v2(55.48,31.63)
  BOTTOM w0.102: CN5000.17 44.28,43.72 44.39,43.61 44.39,38.95 45.64,37.71 45.64,35.18 49.84,30.97 49.84,29.95 50.15,29.65 51.61,29.65 52.37,28.89 54.36,28.89 54.56,28.69 C5010.2 54.85,28.79 v2(54.85,30.62) 54.85,30.99 v2(55.48,31.63) ; v2(198.69,54.11) 199.3,54.72 199.3,55.23 198.82,55.71 198.43,55.71 197.39,56.76 197.39,57.76 196.45,58.69 194.53,58.69 194.31,58.48 192.57,58.48 192.36,58.69 188.61,58.69 187.82,57.89 187.82,57.4 186.98,56.55 186.39,56.55 186.11,56.27 184.84,56.27 183.32,57.78 177.65,57.78 172.15,63.28 172.15,65.05 169.34,67.86 169.34,73.8 168.54,74.6 168.54,76.68 166.76,78.46 163.01,78.46 162.03,77.49 CN7701.23
KSO8: length 227.2
  TOP w0.079: v3(201.98,53.93) 202.3,54.26 U4701.C9
  IN1 w0.114: v2(42.42,43.76) 42.29,43.76 41.92,43.39 41.54,43.39 41.13,42.98 41.13,41.59 41.38,41.33 41.38,38.01 41.97,37.43 41.97,37.04 42.5,36.51 42.94,36.51 44.97,34.47 45.7,34.47 46.85,33.32 46.85,29.88 48.04,28.68 49.71,28.68 v2(49.9,28.5)
  IN2 w0.076: v3(201.98,53.93) 201.25,53.21 201.25,52.1 201.02,51.87 201.02,49.8 201.26,49.57 201.26,48.89 200.79,48.42 200.79,47.53
  IN2 w0.114: 200.79,47.53 200.79,45.56 202.43,43.92 202.43,34.8 200.78,33.15 200.78,22.96 200.15,22.34 200.15,20.4 195.1,15.34 194.66,15.34 194.04,14.72 185.78,14.72 184.41,13.35 163.56,13.35 162.29,12.09 160.32,12.09 159.54,11.31 156.75,11.31 156.04,12.02 153.76,12.02 153.33,12.45 147.76,12.45 147.11,11.81 144.93,11.81 144.56,12.18 138.34,12.18 137.47,13.05 137.47,14.62 136.72,15.37 133.81,15.37 131.55,17.62 129.29,17.62 121.66,25.24 117.25,25.24 115.33,27.16 112.56,27.16 108.34,31.38 102.08,31.38 101.98,31.48 98.27,31.48 98.08,31.29 96.34,31.29 96.04,30.99 91.57,30.99 91.4,31.16 82.49,31.16 81.46,32.19 71.58,32.19 68.46,29.07 66.02,29.07 65.12,28.16 59.43,28.16 59.17,27.91 54.37,27.91 v2(54.31,27.97)
  BOTTOM w0.102: CN5000.15 43.1,42.72 42.87,42.95 42.87,43.31 v2(42.42,43.76) ; v2(49.9,28.5) 49.9,28.91 50.07,29.08 51.38,29.08 51.96,28.5 C5011.2 51.96,28.24 52.66,27.54 53.88,27.54 v2(54.31,27.97)
KSO9: length 236
  TOP w0.102: C5012.2 51.21,34.35 51.01,34.15 v2(50.95,34.09) 50.66,33.8 50.04,33.8 49.2,34.64 v2(49.2,34.94) ; U4701.C10 v3(201.98,55.23)
  IN2 w0.076: 200.33,47.63 200.33,48.51 200.93,49.11 200.93,49.46 200.66,49.74 200.66,52.13 200.9,52.37 200.9,53.52 201.98,54.6 v3(201.98,55.23)
  IN2 w0.114: v2(50.95,34.09) 52.94,32.1 52.94,31.31 55.89,28.36 57.23,28.36 57.93,29.06 60.94,29.06 61.15,29.27 63.69,29.27 63.95,29.53 68.27,29.53 71.39,32.65 81.65,32.65 82.68,31.62 91.59,31.62 91.76,31.45 95.85,31.45 96.15,31.75 97.75,31.75 98.51,32.51 103.53,32.51 104.09,31.95 111.37,31.95 112.45,30.87 117.36,30.87 120.44,27.79 124.1,27.79 125.74,26.16 125.74,22.84 127.54,21.03 127.54,20.1 129.56,18.07 131.74,18.07 134,15.82 136.91,15.82 137.93,14.81 137.93,13.32 138.6,12.64 143.43,12.64 143.7,12.91 153.52,12.91 153.88,12.55 162.1,12.55 163.37,13.81 184.22,13.81 185.59,15.17 193.53,15.17 194.16,15.79 194.89,15.79 199.7,20.6 199.7,22.53 200.32,23.15 200.32,33.34 201.97,34.99 201.97,42.54 201.27,43.24 201.27,44.18 200.33,45.12 200.33,47.63
  BOTTOM w0.102: v2(50.95,34.09) 50.73,33.86 50.16,33.86 49.27,34.75 48.66,34.75 47.46,35.94 47.46,38.61 46.23,39.85 46.23,42.17 47.39,43.33 47.39,46.31 49.03,47.94 49.03,48.88 48.2,49.71 45.21,49.71 45.12,49.8 44.37,49.8 44.07,49.5 44.07,48.99 43.79,48.72 CN5000.27
KSO10: length 226.5
  TOP w0.102: v2(200.56,55.85) 200.59,55.89 201.11,55.89 201.44,55.56 U4701.B11
  IN2 w0.114: v2(55.41,32.34) 55.99,32.92 58.78,32.92 58.88,32.82 61.1,32.82 61.58,32.35 65.93,32.35 66.89,33.3 67.65,33.3 69.81,35.47 82.82,35.47 83.93,34.36 87.94,34.36 88.91,35.33 104.7,35.33 105.27,34.77 112.55,34.77 113.62,33.69 118.53,33.69 120.99,31.24 125.5,31.24 127.74,29 128.43,29 129.1,28.32 129.63,28.32 131.94,26.01 131.94,22.86 132.51,22.3 132.8,22.3 135.01,20.08 139.2,20.08 141.34,17.95 141.34,17.46 141.73,17.07 142.97,17.07 144.31,15.73 151,15.73 151.4,16.13 154.13,16.13 154.56,16.56 157.27,16.56 157.6,16.89 169.19,16.89 169.72,17.42 176.25,17.42 176.45,17.22 182.33,17.22 183.02,17.92 188.04,17.92 188.72,18.6 192.52,18.6 193.35,19.43 194.36,19.43 194.87,19.93 194.87,21.47 196.87,23.47 196.87,30.45 196.47,30.86 196.47,31.51 196.88,31.92 196.88,34.15 198.61,35.88 198.61,39.38 197.19,40.8 197.19,42.98 195.82,44.35 195.82,45.03 194.98,45.87 194.98,47.46 193.91,48.54 193.91,52.74 196.22,55.05 197.62,55.05 198.02,55.45 198.94,55.45 199.24,55.15 199.86,55.15 v2(200.56,55.85)
  BOTTOM w0.102: v2(55.41,32.34) 55.41,32.13 54.44,31.16 54.44,29.29 54.24,29.09 52.46,29.09 51.77,29.78 C5013.2 51.77,30.95 51.44,31.27 50.12,31.27 46.04,35.35 46.04,38.02 45.72,38.34 44.8,39.26 44.8,43.98 44.48,44.31 44.48,44.58 44.34,44.72 CN5000.19
KSO11: length 227.6
  TOP w0.102: U4701.B10 201.32,55.25 199.71,55.25 199.47,55.48 v2(199.47,55.64)
  IN2 w0.114: v2(56.12,33.58) 56.55,33.15 58.97,33.15 59.06,33.05 61.2,33.05 61.67,32.57 65.84,32.57 66.8,33.54 67.5,33.54 69.66,35.7 82.92,35.7 84.03,34.59 87.85,34.59 88.82,35.56 104.8,35.56 105.36,34.99 112.64,34.99 113.72,33.92 118.63,33.92 121.08,31.46 125.59,31.46 127.83,29.22 128.52,29.22 129.19,28.55 129.72,28.55 132.17,26.1 132.17,22.96 132.6,22.53 132.89,22.53 135.11,20.31 139.3,20.31 141.55,18.06 142.45,18.06 143.27,17.23 143.27,17.08 144.4,15.96 150.63,15.96 151.03,16.36 154.03,16.36 154.47,16.79 157.18,16.79 157.51,17.12 169.09,17.12 169.63,17.65 176.35,17.65 176.55,17.45 182.23,17.45 182.93,18.14 187.94,18.14 188.62,18.82 192.23,18.82 194.43,21.02 194.43,23.56 196.64,25.78 196.64,30.36 196.24,30.76 196.24,31.6 196.65,32.02 196.65,34.24 198.38,35.98 198.38,39.29 196.96,40.71 196.96,42.88 195.59,44.26 195.59,44.93 194.75,45.77 194.75,47.37 193.68,48.44 193.68,52.84 196.12,55.28 197.05,55.28 197.41,55.64 v2(199.47,55.64)
  BOTTOM w0.102: CN5000.1 43.46,35.45 44.94,33.97 45.37,33.97 48.83,30.51 48.83,29.37 48.12,28.66 48.12,26.22 48.94,25.39 49.96,25.39 50.27,25.71 55.23,25.71 56.45,26.93 56.45,30.49 56.96,31 56.96,31.86 56.52,32.29 C5014.2 56.09,32.6 55.99,32.7 55.99,33.46 v2(56.12,33.58)
