# Allegro board dax8jmb16e0-e-www.DeviceDB.xyz_.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_TXN12_SSD_C: length 8
  TOP w0.097: C4310.1 209.96,18.75 209.79,18.93 209.54,18.93 v2(209.29,18.68) 209.03,18.93 208.85,18.93 208.69,18.78 C4306.1
  BOTTOM w0.097: v2(209.29,18.68) 209.49,18.88 210.19,18.88 210.33,18.75 210.33,18.1 210.54,17.89 211.38,17.89 212.28,16.99 212.73,16.99 212.88,16.84 CN4300.47
PCIE_TXP5_LAN: length 7.4
  TOP w0.097: C417.2 194.03,74.98 193.66,74.61 193.66,74.45 193.75,74.35 194.8,74.35 195.18,73.97 195.18,73.39 194.88,73.08 194.88,70.82 194.73,70.67 194.73,70.31 194.62,70.21 194.62,69.93 194.73,69.83 U4000.13
PCIE_TXP5_LAN_C: length 112.8
  TOP w0.097: C417.1 193.7,76.09 193.7,76.36 193.36,76.71 192.52,76.71 191.7,77.53 191.7,77.94 191.15,78.49 190.19,78.49 188.97,79.71 187.46,79.71 186.14,81.03 186.14,81.92 187.77,83.55 188.73,83.55 189.28,84.1 189.28,91.47 184.72,96.04 179.01,96.04 175.96,99.09 174.57,99.09 173.79,99.86 173.79,101.23 172.35,102.67 170.98,102.67 166.17,107.48 160.55,107.48 151.02,117.01 144.18,117.01 143.63,117.56 138.73,117.56 138.5,117.33 137.76,117.33 137.4,117.68 133.68,117.68 133.32,117.32 133.32,117.09 131.51,115.29 128.78,115.29 128.56,115.07 128.56,114.89 v2(128.34,114.66)
  BOTTOM w0.079: 126.64,108.31 126.64,108.29 126.65,108.28 126.65,107.35 126.97,107.03 127.17,107.03 127.74,106.45 127.74,102.93 127.25,102.44 127.25,102.17 127.14,102.06 127.01,102.06 U400.BR1
  BOTTOM w0.097: v2(128.34,114.66) 128.54,114.46 128.54,114.25 128.39,114.11 128.03,114.11 127.91,113.99 127.26,113.99 126.03,112.76 126.03,109.11 126.64,108.5 126.64,108.31
PCIE_TXP6_WLAN: length 12.4
  BOTTOM w0.097: CN4100.35 169.2,83.73 168.84,84.08 168.64,84.08 arc(167.9,84.23) 167.28,84.65 166.25,85.68 arc(165.89,86.21) 165.77,86.84 165.77,87.05 arc(165.9,87.72) 166.28,88.29 166.97,88.98 167.09,89.1 arc(167.24,89.32) 167.29,89.59 167.29,90.82 arc(167.41,91.4) 167.74,91.89 167.97,92.12 167.97,92.27 167.86,92.38 C419.2
PCIE_TXP6_WLAN_C: length 80.8
  TOP w0.097: v2(163.51,108.11) 163.69,108.29 163.69,108.44 163.59,108.54 160.16,108.54 150.19,118.52 144.59,118.52 144.24,118.16 133.48,118.16 132.84,117.52 132.84,117.29 131.32,115.77 127.48,115.77 127.23,115.52 127.23,115.17 127.38,115.02 v2(127.52,115.02)
  BOTTOM w0.079: 125.07,109.86 125.07,109.84 125.06,109.83 125.06,109.12 125.74,108.44 125.74,107.49 126.65,106.57 127.15,106.57 127.46,106.27 127.46,103.21 126.6,102.35 126.6,102.14 126.65,101.99 126.67,101.89 126.67,101.87 126.65,101.76 126.6,101.56 126.62,101.41 U400.BR3
  BOTTOM w0.097: 125.07,109.86 125.07,112.48 127.05,114.46 127.05,114.63 127.45,115.02 v2(127.52,115.02) ; v2(163.51,108.11) 163.51,108.41 163.66,108.56 165.73,108.56 169.78,104.51 169.78,98.54 168.59,97.35 168.59,94.4 167.93,93.74 167.93,93.33 167.76,93.16 C419.1
PCIE_TXP8_SSD: length 190.5
  TOP w0.097: C4307.2 208.16,19.29 208.16,18.98 208.09,18.9 207.45,18.9 207.25,19.11 207.25,19.79 207.52,20.07 209.96,20.07 210.58,20.69 212.55,20.69 212.75,20.89 212.75,21.54 213.37,22.15 213.37,23.7 214.96,25.29 215.37,25.48 216.54,26.04 217.7,26.6 220.44,26.6 225.06,28.88 225.54,28.88 225.92,28.49 225.92,28.41 v2(225.92,28.4)
  IN2 w0.114: v2(126.3,105.82) 125.99,105.82 125.92,105.9 125.92,106.16 126.21,106.45 129.01,106.45 130.26,107.7 131.8,107.7 132.72,106.78 141.86,106.78 144.07,108.99 144.9,108.99 145.14,109.22 161.23,109.22 163.1,107.35 164.32,107.35 165.52,106.15 167.62,106.15 168.33,105.44 174.7,105.44 177.64,102.49 183.48,102.49 185.04,100.93 190.27,100.93 194.34,96.86 194.34,94.92 198.66,90.61 200.31,90.61 202.78,88.14 202.78,86.7 205.15,84.33 205.15,75.96 207.27,73.83 207.27,72.88 208.36,71.79 208.36,70.82 209.37,69.82 209.37,68.2 209.75,67.82 212.33,67.82 219.15,61.01 219.15,60.14 221.07,58.22 221.07,54.54 221.8,53.81 221.8,48.7 222.73,47.78 222.73,47.77 223.35,47.15 223.35,40.75 224.44,39.66 224.44,29.46 225.23,28.66 225.79,28.66 225.92,28.54 v2(225.92,28.4)
  BOTTOM w0.079: U400.BN1 125.43,102.32 125.43,104.9 125.89,105.35 125.89,105.64 126.07,105.82 v2(126.3,105.82)
PCIE_TXP9_SSD: length 204.1
  TOP w0.097: C4315.2 209.71,8.39 209.49,8.39 209.23,8.13 208.42,8.13 208.27,8.28 208.27,8.39 v2(208.55,8.67)
  IN2 w0.114: v2(124.22,106.14) 124.32,106.14 124.51,106.34 124.51,106.7 125.14,107.33 128.65,107.33 129.9,108.58 132.17,108.58 133.09,107.65 141.49,107.65 143.79,109.95 144.63,109.95 144.77,110.1 163.55,110.1 166.56,107.09 174.35,107.09 178.03,103.41 183.8,103.41 185.4,101.81 190.63,101.81 195.33,97.11 195.33,95.17 198.78,91.72 201.34,91.72 204.76,88.3 204.76,85.98 206.14,84.59 206.14,81.58 206.42,81.3 206.42,77.11 207.27,76.26 208.06,76.26 208.62,75.7 208.62,72.78 209.46,71.94 209.46,71.02 210.62,69.86 211.54,69.86 220.02,61.37 220.02,60.64 222.77,57.89 222.77,50.51 224.29,49 224.29,41.33 225.33,40.29 225.33,35.41 225.84,34.9 225.84,34.5 225.43,34.09 225.43,31.31 226.57,30.17 226.57,28.37 226.84,28.1 226.84,27.53 226.14,26.83 226.14,24.92 225.51,24.29 224.63,24.29 224.07,24.85 222.66,24.85 219.34,21.52 219.34,21.2 217.93,19.79 217.37,19.79 216.03,18.45 215.11,18.45 214.51,17.84 214.51,16.01 213.33,14.83 213.33,13.6 212.73,13 212.73,11.8 212.34,11.41 211.36,11.41 210.91,10.96 210.91,10.52 209.69,9.3 208.38,9.3 208.29,9.21 208.29,8.94 v2(208.55,8.67)
  BOTTOM w0.079: U400.BM3 125.13,101.36 125.13,101.68 124.88,101.93 124.88,105.29 124.54,105.63 124.54,106.03 124.42,106.14 v2(124.22,106.14)
PCIE_TXP9_SSD_C: length 3.6
  TOP w0.097: C4315.1 210.9,8.44 210.98,8.37 211.37,8.37 v2(211.66,8.66)
  BOTTOM w0.097: CN4300.13 212.86,8.34 212.66,8.54 211.77,8.54 v2(211.66,8.66)
PCIE_TXP10_SSD: length 188.7
  TOP w0.097: v2(209.15,10.81) 209.59,10.36 209.88,10.36 209.97,10.45 C4317.2
  IN2 w0.102: 129.75,104.4 129.73,104.4 129.71,104.41 128.22,104.41 128.01,104.2 126.4,104.2 126.07,103.87 124.88,103.87 124.15,104.6 124.01,104.6 v2(123.66,104.95)
  IN2 w0.114: 129.75,104.4 130.36,104.4 131,105.03 131.43,105.03 132.02,104.44 142.18,104.44 145.27,107.53 145.59,107.53 145.82,107.76 147.18,107.76 147.4,107.54 160.7,107.54 161.51,106.73 162.47,105.77 163.51,105.77 164.7,104.58 166.91,104.58 167.52,103.97 173.83,103.97 176.85,100.94 182.98,100.94 184.43,99.49 187.31,99.49 195.58,91.22 196,91.22 199.1,88.12 199.85,88.12 200.3,87.67 200.3,86.7 201.98,85.02 201.98,80.8 203.08,79.71 203.08,76.21 203.31,75.98 203.31,75.06 203.77,74.61 203.77,73.34 207.92,69.18 207.92,67.6 209.18,66.34 211.77,66.34 217.7,60.41 217.7,59.45 219.6,57.55 219.6,53.87 219.9,53.57 219.9,48.52 221.27,47.15 221.27,44.84 221.85,44.25 221.85,39.89 222.99,38.75 222.99,26.62 220.86,24.5 219.71,24.5 218.46,23.24 218.46,21.56 217.58,20.68 217.02,20.68 216.06,19.72 214.99,19.72 213.64,18.36 213.64,16.37 212.46,15.19 212.46,14.52 211.6,13.66 211.13,13.66 209.99,12.52 209.99,10.92 209.54,10.47 209.23,10.47 209.15,10.55 v2(209.15,10.81)
  BOTTOM w0.079: U400.BL1 124.52,102.29 124.52,104.21 124.36,104.37 124.12,104.37 123.96,104.53 123.96,104.79 123.8,104.95 v2(123.66,104.95)
PCIE_TXP10_SSD_C1: length 4.1
  TOP w0.097: v2(211.39,10.78) 211.15,10.54 210.86,10.54 210.75,10.65 C4317.1
  BOTTOM w0.097: CN4300.25 212.97,11.34 212.82,11.19 212.66,11.19 212.43,10.96 212.43,10.7 212.28,10.55 211.62,10.55 v2(211.39,10.78)
PCIE_TXP10_WWAN: length 5.4
  TOP w0.097: C409.1 199.4,76.91 199.4,76.67 v2(199.99,76.09)
  BOTTOM w0.097: v2(199.99,76.09) 199.84,75.93 199.84,75.28 200.3,74.82 200.3,73.25 200.45,73.1 CN4200.49
PCIE_TXP10_WWAN_C: length 99.3
  TOP w0.097: v2(199.35,78.67) 199.35,78.2 C409.2
  IN1 w0.114: v2(199.35,78.67) 199.35,78.78 199.18,78.95 199.07,78.95 198.94,79.08 198.94,80.03 198.48,80.49 198.48,82.93 197.09,84.33 197.09,86.4 196.58,86.91 196.58,92.86 194.55,94.89 194.55,96.32 190.32,100.55 187.09,100.55 184.32,103.33 177.45,103.33 176.86,103.92 167.42,103.92 166.65,104.69 164.72,104.69 163.26,106.15 162.25,106.15 158.54,109.86 156.6,109.86 155.57,110.89 143.6,110.89 140.44,107.73 132.99,107.73 132.02,106.76 130.94,106.76 130.82,106.88 130.82,107 v2(131.07,107.25)
  BOTTOM w0.079: v2(131.07,107.25) 130.98,107.25 130.58,106.86 130.58,106.27 130.01,105.7 130.01,102.74 129.94,102.67 129.94,101.71 129.73,101.5 129.73,101.28 129.78,101.23 U400.BY3
PCIE_TXP11_SSD: length 186.8
  TOP w0.097: C4309.2 209.97,14.57 209.91,14.5 209.5,14.5 209.3,14.7 v2(209.3,14.92)
  IN2 w0.102: v2(124.12,103.99) 124.06,103.99 123.91,103.84 123.91,103.69 124.04,103.56 126.14,103.56 126.5,103.92 129.3,103.92 130.55,102.67 134.85,102.67 136.18,104.01 137.46,104.01 137.47,104.02 137.5,104.02
  IN2 w0.114: v2(209.3,14.92) 209.3,14.68 209.18,14.56 208.96,14.56 208.85,14.67 208.85,15.18 209.35,15.68 210.21,15.68 210.35,15.54 212.21,15.54 213.22,16.55 213.22,18.73 214.62,20.13 215.89,20.13 216.86,21.11 217.42,21.11 218.04,21.74 218.04,23.42 219.54,24.92 220.69,24.92 222.57,26.8 222.57,38.14 221.39,39.32 221.39,44.07 220.79,44.67 220.79,46.99 219.48,48.3 219.48,53.37 219.18,53.66 219.18,57.33 217.28,59.24 217.28,59.84 214.48,62.64 213.83,62.64 212.81,63.66 211.57,63.66 211.3,63.93 211.3,64.53 210.71,65.12 208.95,65.12 207.5,66.57 207.5,68.99 203.25,73.25 203.25,74.48 202.81,74.91 202.81,75.76 202.65,75.93 202.65,79.25 201.18,80.72 201.18,82.52 196.51,87.19 196.51,89.7 187.14,99.07 184.26,99.07 182.84,100.49 176.67,100.49 173.62,103.54 167.31,103.54 166.7,104.15 164.42,104.15 163.3,105.26 162.29,105.26 160.68,106.88 152.58,106.88 150.91,105.2 149.96,105.2 147.45,102.69 144.62,102.69 143.97,103.34 139.21,103.34 138.53,104.02 137.5,104.02
  BOTTOM w0.079: v2(124.12,103.99) 123.96,103.99 123.84,103.87 123.84,103.64 124.15,103.33 124.15,102.12 124.24,101.89 124.24,101.79 124.16,101.61 124.16,101.51 124.19,101.43 U400.BL3
PCIE_TXP11_SSD_C: length 3.9
  TOP w0.097: v2(211.41,14.9) 211.14,14.64 210.9,14.64 210.75,14.79 C4309.1
  BOTTOM w0.097: v2(211.41,14.9) 211.7,14.61 211.9,14.61 212.32,14.19 212.73,14.19 212.88,14.34 CN4300.37
PCIE_TXP12_SSD: length 199.3
  TOP w0.097: v2(226.73,26.82) 226.73,26.61 226.51,26.39 225.69,26.39 225.03,27.05 223.93,27.05 222.97,26.79 220.58,26.12 218.19,26.12 215.2,24.86 213.96,23.61 213.96,22.01 213.24,21.29 213.24,20.22 213.01,19.99 212.42,19.99 212.22,19.79 211.87,19.79 210.96,18.88 210.85,18.88 210.74,19 C4311.2
  IN2 w0.114: v2(226.73,26.82) 226.73,26.6 226.87,26.46 226.98,26.46 227.54,27.02 227.54,27.99 226.99,28.54 226.99,30.34 225.87,31.47 225.87,33.91 226.27,34.31 226.27,35.11 225.76,35.62 225.76,40.53 224.75,41.54 224.75,49.26 223.35,50.65 223.35,57.99 220.58,60.77 220.58,61.41 211.41,70.58 211.41,77.06 208.36,80.11 208.36,81.39 206.78,82.97 206.78,84.73 205.69,85.81 205.69,87.96 202.52,91.13 202.52,92.51 201.98,93.05 198.05,93.05 195.75,95.35 195.75,97.29 190.81,102.23 185.57,102.23 183.86,103.94 178.32,103.94 174.73,107.52 167.12,107.52 164.12,110.52 144.6,110.52 144.45,110.37 143.62,110.37 141.32,108.07 133.26,108.07 132.31,109.02 129.58,109.02 128.31,107.75 125.51,107.75 124.7,108.56 124.26,108.56 122.42,106.72 122.42,104.85 122.54,104.73 122.79,104.73 122.91,104.85 v2(122.91,105.09)
  BOTTOM w0.079: v2(122.91,105.09) 122.91,104.75 122.87,104.71 122.43,104.71 122.22,104.5 122.22,104.15 122.62,103.75 122.62,103.3 123.38,102.54 123.38,102.14 123.34,102.04 123.34,101.71 123.37,101.66 123.4,101.51 123.37,101.43 123.3,101.3 123.26,101.25 123,101.25 122.87,101.12 122.87,101.02 122.99,100.9 U400.BJ3
PCIE_TXP12_SSD_C: length 8.1
  TOP w0.097: C4311.1 209.96,19.24 209.84,19.13 209.48,19.13 v2(209.29,19.31) 209.1,19.13 208.82,19.13 208.64,19.31 C4307.1
  BOTTOM w0.097: v2(209.29,19.31) 209.52,19.08 210.27,19.08 210.52,18.83 210.52,18.19 210.62,18.09 211.46,18.09 212.37,17.19 212.73,17.19 212.88,17.34 CN4300.49
PCIE_WAKE#_R: length 12.7
  TOP w0.102: R4005.1 186.95,71.53 Q4001.1 189,72.27 R4006.2 189.5,71.77 190.78,71.77 191.01,72.01 191.98,72.01 192.19,71.8 192.19,70.32 192.34,70.16 v2(192.34,69.63) ; v2(191.55,67.65) 191.55,67.64 192.27,66.91 U4000.21
  BOTTOM w0.102: v2(192.34,69.63) 192.34,68.44 v2(191.55,67.65)
PD_ADP_DIS1: length 66.9
  TOP w0.102: U4701.H7 v3(205.88,53.28) ; v2(202.24,89.87) 202.27,89.9 PR8013.2 202.7,91.69 202.7,93.58 202.52,93.76 PQ8005.2
  IN1 w0.114: v2(213.72,63.36) 212.77,62.41 212.5,62.41 211.71,63.21 211.58,63.21 211.14,63.65 209.95,63.65 209.5,64.1 209.5,67.52 209.02,68 209.02,71.05 207.01,73.06 205.87,73.06 205.47,73.46 205.47,76.38 205.72,76.64 205.72,78.92 205.08,79.57 205.08,79.94 203.97,81.05 203.97,84.34 202.57,85.74 202.57,89.54 v2(202.24,89.87)
  BOTTOM w0.076: v3(205.88,53.28) 206.2,52.96 207.7,52.96 208.14,53.4 208.85,53.4
  BOTTOM w0.102: v2(213.72,63.36) 214.51,63.36 215.75,62.12 219.09,62.12 219.57,61.65 219.57,57.59 219.06,57.08 218.3,57.08 217.41,56.19 217.41,55.94 214.36,52.89 211.69,52.89 211.18,53.4 208.85,53.4
PD_I2C_SCL: length 78.8
  TOP w0.102: R6118.2 203.06,65.22 203.9,66.05 204.25,66.05 204.96,66.76 204.96,68.76 205.25,69.06 v2(205.25,69.68) ; U6100.17 189.86,106.11 189.61,105.86 189.61,105.3 188.63,104.33 188.63,103.65 188,103.01 187.67,103.01 v2(187.55,102.9)
  IN1 w0.114: v2(214.61,61.14) 214.49,61.27 211.31,61.27 211.06,61.52 209.94,61.52 208.26,63.2 208.26,65.36 207.25,66.37 207.25,67.62 205.25,69.61 v2(205.25,69.68)
  IN1 w0.127: v2(196.71,97.11) 195.56,95.97 195.56,94.59 199.5,90.66 199.5,89.83 198.48,88.81 198.48,85.15 200.19,83.44 200.19,82.93 201.28,81.84 201.28,80.07 201.02,79.81 201.02,77.97 202.36,76.64 202.36,75.92 202.46,75.82 202.46,72.84 205.25,70.05 v2(205.25,69.68)
  BOTTOM w0.102: v2(196.71,97.11) 196.55,96.96 195.9,96.96 193.74,99.12 189.85,99.12 187.56,101.4 187.56,102.89 v2(187.55,102.9) ; R7731.1 R6120.1 218.57,60.3 218.93,60.66 218.93,61.4 218.65,61.68 215.15,61.68 v2(214.61,61.14)
PD_I2C_SCL3: length 16.4
  TOP w0.076: U4701.F8 v3(203.93,53.28)
  TOP w0.102: R4705.2 202.44,62.12 201.54,62.12 201.16,62.5 201.16,62.95 201.25,63.04 v2(201.27,63.06) 201.25,63.46 202.23,64.45 R6118.1
  BOTTOM w0.076: v3(203.93,53.28) 203.93,53.38 204.26,53.71 204.26,54.09 204.1,54.26 203.73,54.26 203.6,54.39 203.6,55.48 203.87,55.75 203.87,56.33 203.72,56.48 203.72,57.44
  BOTTOM w0.102: v2(201.27,63.06) 201.3,63.03 201.3,61.21 201.5,61.01 201.5,60.28 203.35,58.44 203.35,57.98 203.72,57.61 203.72,57.44
PD_I2C_SCL_C: length 107.8
  IN1 w0.127: v2(172.83,9.45) 172.83,10.22 174.48,11.87 185.01,11.87 187.47,9.42 197.32,9.42 202.93,15.03 202.93,17.23 204.62,18.92 206.18,18.92 208.62,21.37 209.16,21.37 211.41,23.62 213.64,23.62 218.31,28.29 218.31,28.64 219.26,29.59 219.26,29.78 219.94,30.46 219.94,35.92 218.96,36.9 218.96,39.17 219.62,39.83 219.62,56.27 216.82,59.06 216.42,59.06 v2(215.98,59.49)
  BOTTOM w0.102: v2(172.83,9.45) 173.59,9.45 173.85,9.71 173.85,10.47 176.64,13.26 176.64,13.77 176,14.41 175.23,14.41 v2(174.15,15.49) 174.15,13.72 173.45,13.02 CN7702.2 ; v2(215.98,59.49) 215.98,59.14 217.03,58.1 217.97,58.1 R7731.2
PD_I2C_SDA: length 74.4
  TOP w0.102: v2(186.91,102.93) 186.91,102.97 187.42,103.48 187.83,103.48 188.28,103.93 188.28,104.55 189.25,105.52 189.25,105.97 189.36,106.08 U6100.16 ; v2(205.9,69.67) 205.9,69.06 205.47,68.64 205.47,66.71 R6117.2
  IN1 w0.114: v2(205.9,69.67) 205.9,69.48 207.5,67.87 207.5,66.48 208.52,65.46 208.52,63.3 210.04,61.78 211.18,61.78 211.39,61.57 214.78,61.57 216.01,60.35 v2(216.01,60.13)
  IN1 w0.127: v2(196.71,96.3) 196.07,95.66 196.07,94.8 200.01,90.87 200.01,89.46 198.99,88.45 198.99,85.4 200.7,83.69 200.7,83.16 201.79,82.07 201.79,79.81 201.55,79.58 201.55,78.27 202.87,76.95 202.87,76.13 202.97,76.03 202.97,73.07 205.9,70.14 v2(205.9,69.67)
  BOTTOM w0.102: v2(186.91,102.93) 187.05,102.78 187.05,101.19 189.64,98.61 193.53,98.61 195.69,96.45 196.55,96.45 v2(196.71,96.3) ; R7730.1 R6119.1 217.09,60.3 216.92,60.13 v2(216.01,60.13)
PD_I2C_SDA3: length 14.2
  TOP w0.076: U4701.F9 v3(203.93,54.58)
  TOP w0.102: R4704.2 202.64,62.65 v2(201.73,62.62) 201.71,62.82 201.79,62.9 201.79,63.3 202.37,63.89 203.42,63.89 R6117.1
  BOTTOM w0.076: 203.95,56.85 204.26,56.54 204.26,54.91 v3(203.93,54.58)
  BOTTOM w0.102: v2(201.73,62.62) 201.81,62.54 201.81,61.38 201.99,61.21 201.99,60.48 203.76,58.7 203.76,58 203.93,57.84 203.93,56.87 203.95,56.85
PD_I2C_SDA_C: length 100
  IN1 w0.127: v2(216.62,59.49) 216.9,59.49 220,56.39 220,39.67 219.34,39.01 219.34,37.24 220.32,36.26 220.32,30.3 219.64,29.63 219.64,29.43 218.71,28.49 218.71,28.15 213.8,23.24 211.57,23.24 209.32,20.99 208.75,20.99 206.44,18.68 204.73,18.68 203.31,17.27 203.31,14.87 197.48,9.03 187.31,9.03 184.73,11.61 174.99,11.61 v2(173.34,9.96)
  BOTTOM w0.102: v2(173.34,9.96) 173.34,10.47 176.14,13.27 v2(176.14,13.63) 174.79,13.63 173.95,12.8 CN7702.1 ; v2(216.62,59.49) 216.62,59.01 217.09,58.54 R7730.2
PDB: length 10
  TOP w0.102: U3600.40 217.38,15.65 216.62,16.41 R3620.2 R3621.1 216.4,18.52 D3604.2 215.15,19.77 215.15,22.51 Q3600.3 215.85,22.56 C3611.1
PIRQA#: length 13.9
  TOP w0.079: v1(132.39,82.86) 132.39,82.48 132.64,82.24 132.64,82.01 132.97,81.68
  TOP w0.102: 132.97,81.68 133.1,81.55 133.1,81.21 134.86,79.45 134.86,78.65 138.7,74.81 v2(138.7,73.07) 138.7,72.5 R496.1
  BOTTOM w0.079: U400.CC32 132.1,82.57 v1(132.39,82.86)
PLAY_MUTE_LED: length 3
  TOP w0.102: Q5001.3 44.31,51.35 44.31,51.9 43.9,52.31 v2(43.33,52.31) 42.33,52.31 R5007.1
PLAY_MUTE_LED_CNTR: length 227.2
  TOP w0.102: v2(58.02,26.15) 58.02,27.08 56.65,28.45 56.65,29.55 59.22,32.11 59.22,32.75 58.84,33.13 55.95,33.13 55.75,33.33 50.22,33.33 48.52,35.03 48.52,35.7 45.02,39.21 45.02,43.08 49.23,47.29 49.23,48.75 47.68,50.3 47.07,50.3 46.57,50.81 R5010.1 45.91,50.81 45.84,50.74 Q5001.2 ; v2(149.89,7.1) 149.89,7.7 149.6,8 149.26,8 148.55,7.29 147.33,7.29 143.07,11.55 137.1,11.55 136.25,12.4 134.64,12.4 v2(134.51,12.54) ; U3600.10 216.18,10.73 216.12,10.67 216.12,9.74 215.8,9.43 215.8,8.78 215.99,8.58 215.99,8.04 215.2,7.24 214.59,7.24 214.37,7.46 R3610.1 213.5,7.02 v2(212.48,7.02)
  IN2 w0.114: v2(149.89,7.1) 149.89,6.94 150.66,6.18 159.67,6.18 160.74,7.25 165.56,7.25 166.15,6.66 171.18,6.66 174.73,10.21 185.41,10.21 188.94,6.68 199.45,6.68 200.56,7.79 203.82,7.79 204.59,7.02 209.54,7.02 210.12,7.59 211.07,7.59 211.4,7.27 211.85,7.27 212.11,7.02 v2(212.48,7.02) ; v2(58.02,26.15) 58.38,26.5 59.71,26.5 59.99,26.79 64.91,26.79 65.23,26.47 67.79,26.47 70.04,28.71 75.42,28.71 77.52,30.82 80.89,30.82 81.93,29.79 90.84,29.79 92.01,28.61 95.6,28.61 96.91,29.92 98.65,29.92 98.84,30.11 101.41,30.11 104.11,27.42 109.46,27.42 111.09,25.79 114.51,25.79 117.2,23.09 121.87,23.09 126.48,18.49 126.48,17.14 125.71,16.37 125.71,14.55 128.63,11.63 128.8,11.63 129.1,11.33 132.15,11.33 133.36,12.54 v2(134.51,12.54)
PLT_DET: length 10.5
  TOP w0.102: U4701.K11 206.53,55.89 206.53,56.41 207.16,57.05 208.34,57.05 v2(208.89,57.59) 210.5,57.59 211.15,58.25 212.33,58.25 212.46,58.38 213.76,58.38 213.99,58.62 R4730.2 213.36,58.98 R4729.2
PLT_ID1: length 13.8
  BOTTOM w0.079: U400.CJ17 135.93,91.72 136.69,91.72 136.7,91.73 136.94,91.73 136.95,91.72 137.9,91.72 137.97,91.79 138.26,91.79 138.33,91.72 138.55,91.72 138.62,91.79 138.91,91.79 139.36,91.34 141.04,91.34 141.15,91.45 142.37,91.45 142.52,91.6 ; v2(145.3,91.75) 145.3,91.75
  BOTTOM w0.102: v2(145.3,91.75) 144.98,92.07 142.98,92.07 142.52,91.6 ; 145.3,91.75 145.79,91.75 146.68,90.86 R513.1 R512.2
PLT_ID2: length 190.4
  TOP w0.102: R3425.2 46.59,124.52 48.5,126.42 48.5,128.45 49.74,129.7 64.78,129.7 70.04,124.44 74.07,124.44 74.51,124.87 75.07,124.87 v2(75.29,124.64)
  IN1 w0.114: v2(153.17,117.02) 153.65,117.02 156.32,119.69 156.32,120.07 156.45,120.2 156.45,121.6 155.56,122.48 151.49,122.48 148.45,119.44 144.13,119.44 143.67,119.89 128.68,119.89 127.87,120.71 126.6,120.71 126.07,120.17 124.09,120.17 124,120.26 120.7,120.26 120.12,119.69 114.03,119.69 113.47,120.25 112.3,120.25 111.57,119.51 107.98,119.51 106.92,120.58 84.06,120.58 81.01,123.63 77.83,123.63 77.07,124.39 77.07,124.77 76.69,125.15 75.8,125.15 v2(75.29,124.64)
  IN2 w0.114: v2(152.66,91.37) 152.92,91.62 155.94,91.62 156.45,91.12 156.7,91.12 157.46,90.35 157.97,90.35 158.48,90.86 159.6,90.86 v2(160.21,90.25)
  BOTTOM w0.079: 142.5,91.23 142.44,91.29 141.22,91.29 141.11,91.17 136.49,91.17 136.17,91.5 135.51,91.5 U400.CH17
  BOTTOM w0.102: v2(152.66,91.37) 152.03,90.73 149.84,90.73 149.46,90.35 145.78,90.35 145.65,90.23 145.27,90.23 145.14,90.35 144.5,90.35 R516.1 143.99,91.24 v2(143.56,91.67) 143.1,91.21 143.1,91.09 R515.2 142.5,91.23 ; v2(160.21,90.25) 160.21,90.4 159.65,90.96 159.65,92.41 160.33,93.1 160.33,94.85 158.61,96.58 158.61,98.02 161.91,101.33 161.91,105.72 160,107.63 160,108.49 153.17,115.32 v2(153.17,117.02)
PLT_ID4: length 16.1
  TOP w0.102: v1(133.94,91.66) 134.31,92.03 134.86,92.03 135.51,91.38 138.16,91.38 138.37,91.17 141.05,91.17 141.26,91.38 v2(142.53,91.38) 142.94,91.38 143.58,92.02 144.81,92.02 145.14,92.36 R652.1 145.67,92.53 146.16,93.02 146.91,93.02 R529.2
  BOTTOM w0.079: v1(133.94,91.66) 133.56,92.04 U400.CF17
PLT_RST#_KBC: length 34.3
  TOP w0.102: v2(187.5,55.1) 187.23,54.83 187.22,54.83 186.32,53.93 186.32,53.73 186.1,53.51 184.84,53.51 v2(184.27,54.07) 184.27,54.53 183.67,55.13 R4761.2 ; U4701.J5 v3(206.53,51.33)
  IN1 w0.076: 201.82,52.32 202.21,52.32 202.86,51.67 203.42,51.67 203.6,51.85 203.6,52.17 203.74,52.31 205.3,52.31 205.95,51.67 206.2,51.67 v3(206.53,51.33)
  IN1 w0.114: 201.82,52.32 201.55,52.58 201.55,52.9 200.8,53.65 196.93,53.65 196.48,53.2 195.93,53.2 194.91,54.22 192.09,54.22 191.99,54.11 191.03,54.11 190.56,54.59 190.56,55.05 190.61,55.1 190.61,57.92 190.1,58.43 189.01,58.43 187.5,56.92 v2(187.5,55.1)
PLTRST#: length 91.8
  TOP w0.102: v2(179.81,53.52) 180.07,53.78 182.59,53.78 R4761.1 ; v2(135.06,57.71) 135.06,58.07 135.01,58.12 Q408.2 134.65,60.36 134.65,61.26 132.53,63.38 129.8,63.38 129.64,63.22 U402.1 129.64,61.97 129.42,61.75 129.17,61.75 128.99,61.93 U402.2 128.99,63.4 128.8,63.6 128.14,63.6 127.14,62.6 R469.1
  IN1 w0.127: v2(179.81,53.52) 174.35,53.52 173.85,53.02 169.84,53.02 169.42,53.43 164.89,53.43 164.53,53.79 v2(164.53,54.2)
  BOTTOM w0.079: R657.2 125.89,76.02 126.74,75.16 126.74,74.62 127.72,73.64 127.72,71.38 126.59,70.25
  BOTTOM w0.102: v2(164.53,54.2) 164.53,54.44 160.75,58.22 159.75,58.22 159.37,57.84 156.45,57.84 155.86,57.25 135.52,57.25 v2(135.06,57.71) 134.45,58.32 132.86,58.32 126.59,64.59 126.59,70.25
PLTRST#_PCH: length 5.5
  BOTTOM w0.079: R657.1 125.89,76.93 124.68,78.14 124.37,78.14 123.61,78.9 123.61,80.62 U400.BJ35
PM_EXTTS#0: length 2.2
  TOP w0.102: R2800.2 82.36,38.67 v2(82.36,38.53)
  BOTTOM w0.102: JDIM2800.134 82.35,38.52 v2(82.36,38.53)
PM_EXTTS#1: length 4.2
  TOP w0.102: v2(159.39,38.93) 159.39,38.08 159.71,37.76 R9648.2
  BOTTOM w0.102: v2(159.39,38.93) 159.32,38.85 JDIM2801.134
PM_PWROK: length 225
  TOP w0.102: v2(168.2,65.56) 168.2,65.09 167.74,64.64 156.08,64.64 155.79,64.35 149.65,64.35 148.95,63.65 134.03,63.65 130.94,66.73 129.52,66.73 128.74,67.51 128.74,68.45 127.03,70.16 R466.2 ; U4701.K4 207.18,50.68 208.41,50.68 208.55,50.55 209.05,50.55 209.59,50.01 209.98,50.01 210.87,49.12 213.61,49.12 214.03,49.54 R4747.1 214.28,49.39 214.28,48.82 v2(214.03,48.57)
  IN2 w0.114: v2(141.6,95.49) 141.95,95.49 142.38,95.92 142.38,96.07 143.19,96.88 144.7,96.88 146.09,95.5 148.37,95.5 149,94.87 149.25,94.87 150.67,93.46 151.47,93.46 151.58,93.57 153.32,93.57 154.29,94.54 157.55,94.54 158.68,93.42 159.16,93.42 159.71,92.87 162.35,92.87 162.89,93.41 168.12,93.41 168.23,93.31 172.11,93.31 172.34,93.07 176.14,93.07 177.79,94.72 184.64,94.72 189.28,90.08 190.41,90.08 191.11,89.39 191.11,88.75 190.48,88.12 190.4,88.12 190.11,87.83 190.11,87.47 190.73,86.85 190.73,84.49 191.45,83.77 191.45,80.03 192.81,78.67 192.81,77.88 193.12,77.57 193.12,72.96 193.63,72.45 196.98,72.45 199.41,70.02 199.76,70.02 202.17,67.6 v2(202.17,66.38) ; v2(168.2,65.56) 168.26,65.56 169.64,64.18 170.68,64.18 171.12,63.74 172.25,63.74 172.7,63.28 175.47,63.28 v2(176.08,63.89)
  BOTTOM w0.079: v2(141.6,95.49) 141.57,95.52 141.57,96.26 141.29,96.54 140.99,96.54 140.9,96.63 139.73,96.63 139.65,96.54 138.8,96.54 U400.CR10
  BOTTOM w0.102: v2(176.08,63.89) 176.69,63.28 183.04,63.28 186.14,66.38 189.86,66.38 190.56,65.68 190.56,64.5 192.61,62.45 193.89,62.45 194.44,63 196.63,63 197.11,62.51 197.87,62.51 198.28,62.92 199.8,62.92 200.19,63.3 200.19,63.3 200.4,63.52 200.4,63.52 200.49,63.61 200.49,63.61 201.29,64.41 201.29,64.41 201.81,64.93 201.81,66.02 v2(202.17,66.38) 203.55,67.76 205.43,67.76 205.57,67.9 208.47,67.9 210.12,66.25 210.12,65.48 210.9,64.7 214.04,64.7 215.99,62.74 219.38,62.74 220.18,61.94 220.18,56.2 218.16,54.19 218,54.19 217.55,53.74 217.24,53.74 215.23,51.73 215.23,50.72 214.03,49.52 v2(214.03,48.57)
PM_SLP_A#: length 232.8
  TOP w0.102: v2(52.94,64.92) 52.96,64.9 53.6,64.9 58.12,60.38 58.12,59.4 62.79,54.73 106.2,54.73 107.7,53.23 141.15,53.23 141.8,53.88 145.37,53.88 152.43,60.93 v2(157.74,60.93)
  IN1 w0.114: v2(153.86,70.07) 153.86,67.88 v2(154.79,66.95) 157.01,64.73 157.01,61.67 v2(157.74,60.93)
  BOTTOM w0.079: 133.25,75.57 132.9,75.92 130.87,75.92 128.5,78.29 128.5,79.45 U400.BU37
  BOTTOM w0.102: v2(52.94,64.92) 52.94,65.79 52.63,66.1 51.87,66.86 51.87,67.75 50.78,68.84 50.78,72.83 50.02,73.59 50.02,74.35 46.21,78.16 44.63,78.16 44.12,78.67 37.8,78.67 37.11,77.98 32.58,77.98 30.54,80.02 30.54,82.28 19.79,93.02 19.79,100.51 19.16,101.15 19.16,103.69 20.3,104.83 20.3,106.1 18.15,108.25 PR8114.2 ; v2(153.86,70.07) 151.75,72.18 R7702.1 ; v2(154.79,66.95) 153.94,67.8 152.13,67.8 150.36,66.02 144.65,66.02 144.35,66.33 137.52,66.33 135.96,67.88 135.96,71.11 136.19,71.34 136.19,72.03 135.22,73 135.22,73.27 134.26,74.23 134.26,74.56 133.25,75.57
PM_THRMTRIP#: length 5.3
  BOTTOM w0.079: U400.BJ1 123.11,102.57 122.41,103.28 122.41,103.64 122,104.04 122,104.99 122.22,105.2 v2(122.22,105.81) 122.85,106.43 R405.1
PRE: length 4.1
  TOP w0.102: U3501.15 213.77,86.26 214.36,85.67 R3505.1 214.03,85.13 214.03,85.05 213.91,84.93 213.91,83.6 R3504.1
PROC_POPIRCOMP: length 27.8
  TOP w0.102: R411.1 143.46,71.35 v2(142.91,71.35) v2(142.25,71.35)
  IN2 w0.079: v1(126.91,85.53) 127.34,85.1 127.34,82.73
  IN2 w0.114: v2(142.91,71.35) 142.91,71.82 141.17,73.56 138.3,73.56 133.25,78.61 133.25,79.18 133,79.43 131.79,79.43 131.08,80.14 129.78,80.14 128.91,81.01 128.56,81.01 127.72,81.84 127.62,81.84 127.34,82.12 127.34,82.73
  BOTTOM w0.079: U400.BP27 126.54,85.75 126.76,85.53 v1(126.91,85.53)
PVADPTR: length 63.4
  TOP w0.127: 197.44,85.83 197.1,85.48 PD8001.1 ; 197.44,85.83 197.79,85.48 199.89,85.48 200.85,86.44 202.73,86.44 ; 197.44,85.83 197.44,87.1 v2(197.98,87.64) ; 202.73,86.44 202.98,86.19 202.98,84.76 203.22,84.52 PQ8012.1 ; 202.73,86.44 203.35,87.06 PQ8013.1
  TOP w0.254: PD8202.2 129.55,28.66 131.17,27.03 131.17,22.79 132.24,21.72 v2(135.25,21.72)
  TOP w0.508: v2(126.32,27.84) 126.2,27.96 PD8202.2
  BOTTOM w0.127: v2(197.98,87.64) 198.69,87.64 198.92,87.86 199.82,87.86 200.26,87.43 201.66,87.43 202.93,88.7 206.36,88.7 207.32,87.74 207.32,85.75 208.49,84.59 210.47,84.59 210.88,84.99 211.39,84.99 211.79,84.59 212.66,84.59 214.84,86.77 214.84,93.22 216.47,94.85
  BOTTOM w0.508: v2(126.32,27.84) 126.32,28.27 PR8209.2 ; v2(135.25,21.72) 135.12,21.85 134.63,21.85 134.43,22.05 134.43,24.02 PR8240.1
  vias: v2(214.92,97.64) v2(214.94,96.98) v2(214.97,96.25) v2(215.5,97.29) v2(215.48,96.63) v2(215.48,95.87) v2(215.63,98.28) v2(216.34,98.25) v2(224.85,89.19) v2(224.84,88.56) v2(224.86,89.83) v2(225.52,90.53) v2(225.52,89.87) v2(225.52,89.24) v2(225.52,88.6) v2(225.71,91.14) v2(226.1,90.29) v2(226.11,89.02)
PVCORE_PG: length 132
  TOP w0.102: U401.1 127.15,64.52 R449.1 125.91,63.28 125.91,61.68 126.4,61.18 126.67,61.18 126.98,60.86 126.98,60.44 126.6,60.06 126.6,58.33 125.91,57.64 110.57,57.64 109.16,59.05 65.68,59.05 63.84,60.89 63.84,63.16 64.49,63.81 64.49,65.62 63,67.11 62.6,67.11 61.66,68.05 52.27,68.05 50.2,70.13 50.2,71.23 48.43,72.99 47.22,72.99 45.65,74.56 42.28,74.56 40.78,73.06 v2(39.2,73.06) ; v2(40.55,92.23) 40.9,92.59 40.9,93.21 PR8816.2 41.76,94.06 41.76,94.96 PR8818.2
  IN1 w0.114: v2(40.55,92.23) 40.55,88.51 40.55,88.5 40.55,87.36 40.86,87.05 40.86,84.18 40.39,83.72 40.39,76.79 40.11,76.51 40.11,73.97 v2(39.2,73.06)
PVT_CS#: length 8.4
  TOP w0.102: U4701.L10 207.82,55.22 208.31,55.22 208.85,55.76 210.45,55.76 211.36,56.67 214.01,56.67 214.21,56.87 TP4701.1
PVT_MOSI_L: length 5.9
  TOP w0.102: TP4703.1 211.22,57.76 210.33,56.87 207.29,56.87 206.86,56.43 U4701.K12
PVT_SCLK_L: length 7.7
  TOP w0.102: U4701.L12 207.81,56.51 208.57,56.51 208.67,56.41 210.45,56.41 211.11,57.08 213.47,57.08 TP4702.1
PVT_SPI_MISO: length 8.3
  TOP w0.102: TP4704.1 215.15,57.97 214.51,57.33 214.07,57.33 213.62,56.88 211.26,56.88 210.59,56.21 U4701.M12
PWM_LED#: length 131.6
  TOP w0.102: U4701.H10 v3(205.88,55.23)
  IN2 w0.076: 207.98,46.44 207.98,49.38 207.27,50.09 207.27,51.97 206.93,52.32 205.75,52.32 205.56,52.5 205.56,52.77 205.57,52.77 205.57,53.14 205.56,53.15 205.56,54.92 v3(205.88,55.23)
  IN2 w0.114: 207.98,46.44 207.98,46.21 208.49,45.7 208.49,44.89 207.74,44.14 207.74,35.59 204,31.85 204,19.07 202.92,17.99 202.92,14.77 199.65,11.5 195.47,11.5 194.83,10.86 193.71,10.86 193.48,11.08 188.53,11.08 187.86,11.75 173.02,11.75 171.76,10.49 169.86,10.49 169.43,10.93 167.12,10.93 166.68,10.49 160.98,10.49 159.81,9.32 153.73,9.32 153.25,8.84 152.66,8.26 v2(152.66,7.7)
  BOTTOM w0.102: Q5003.2 140.6,20.3 140.6,18.44 140.28,18.12 138.1,18.12 137.96,17.98 137.96,16.91 136.01,14.96 136.01,14.01 138.35,11.66 140.84,11.66 141.19,11.31 143.42,11.31 145.2,9.54 145.2,7.87 146.49,6.58 148.18,6.58 149.11,7.51 150.06,7.51 150.4,7.17 152.14,7.17 v2(152.66,7.7)
PWR1_3290_A3: length 3.4
  TOP w0.102: R6320.1 220.18,95.9 U6302.A3
PWR1_3290_A4: length 4.7
  TOP w0.102: R6319.1 218.91,94.17 219.37,94.64 219.52,94.79 219.9,95.16 219.9,96.12 U6302.A4
PWR1_3290_C4: length 8
  TOP w0.102: R6322.1 227.08,96.9 227.08,98.07 226.42,98.74 226.42,98.99 226.17,99.24 224.93,99.24 224.19,98.51 v2(224.19,98.14) 222.91,98.14 U6302.C4
PWR1_3290_D4: length 4.1
  TOP w0.102: v2(225.51,96.35) 225.76,96.6 C6304.1 225.76,97.5 225.55,97.71 U6302.D4
PWR1_3290_EN: length 19.9
  TOP w0.102: U6302.B4 222.66,98.38 223.73,98.38 224.84,99.5 226.3,99.5 226.68,99.12 226.68,98.86 227.31,98.23 227.31,96.31 R6323.2 R6324.1 226.42,94.29 227.62,95.48 227.62,99.45 Q6301.3 227.57,102.07 v2(227.81,102.31)
PWR_BTN_OUT#: length 98.5
  TOP w0.102: v2(189.35,52.43) 189.35,53 190.15,53.8 194.72,53.8 195.59,54.67 196.38,54.67 R4755.1 197.38,54.84 R4753.2 197.62,54.64 197.77,54.49 198.81,54.49 198.92,54.59 199.96,54.59 200.15,54.41 200.67,54.41 200.85,54.59 202.63,54.59 U4701.D9
  IN2 w0.079: v1(128.74,84.9) 128.74,84.38 129.26,83.86 129.26,82.25 129.76,81.74 130.36,81.74 130.83,81.27 131.08,81.27 131.27,81.08
  IN2 w0.114: 131.27,81.08 132.13,80.22 133.26,80.22 134.04,79.44 134.04,78.79 138.54,74.29 141.41,74.29 144.33,71.38 150.21,71.38 150.71,70.87 155.42,70.87 156.05,70.24 158.48,70.24 159.14,69.58 160.07,69.58 160.14,69.51 162.88,69.51 163.73,70.36 163.92,70.36 165.23,71.66 166.28,71.66 167.31,70.62 172.26,70.62 172.87,70.01 173.85,70.01 173.98,69.88 174.81,69.06 177.93,69.06 178.56,68.43 178.56,67.66 178.92,67.3 179.12,67.3 179.73,66.68 179.73,63.6 181.48,61.85 181.48,57.76 186.48,52.76 186.48,52.76 189.02,52.76 v2(189.35,52.43)
  BOTTOM w0.079: v1(128.74,84.9) 128.48,85.17 U400.BU28
PWR_GOOD_3: length 412.5
  TOP w0.102: C4729.1 190.35,52.85 189.52,52.03 189.18,52.03 189.13,52.08 187.27,52.08 186.46,52.9 ; v2(25.81,111.08) 26.02,110.86 Q7700.5 ; Q7701.2 28.3,110.88 v2(28.08,111.11) ; 186.46,52.9 180.79,52.9 175.9,48.01 144.71,48.01 143.95,47.25 117.64,47.25 116.78,48.1 104.51,48.1 102.45,50.16 58.96,50.16 58.04,51.08 v2(56.34,51.08) ; 186.46,52.9 188.88,52.9 190.65,54.67 v2(191.08,54.67) ; v2(52.21,85.35) 50.25,87.31 50.25,92.08 49.84,92.49 49.6,92.49 49.18,92.91 49.18,93.28 50.05,94.15 50.05,95.59 49.71,95.92 48.75,95.92 R3311.1 ; Q7700.2 26.02,107.03 v2(26.08,106.96) ; Q7701.5 28.3,107.18 v2(27.99,106.86)
  TOP w0.114: v2(208.76,50.93) 208.68,51.01 U4701.M4
  IN1 w0.114: v2(28.08,111.11) 26.26,111.11 26.23,111.08 v2(25.81,111.08) ; v2(28.08,111.11) 28.56,110.63 28.56,107.43 v2(27.99,106.86) 27.36,106.86 27.26,106.96 v2(26.08,106.96) 23.99,106.96 21.09,104.07 21.09,103.13 32.97,91.24 34.46,91.24 v2(40.43,85.27) ; v2(28.08,111.11) 28.79,111.82 39.37,111.82 43.72,116.17 44.3,116.17 50.22,122.09 53.09,122.09 53.53,122.54 60.69,122.54 60.9,122.33 62.19,122.33 62.97,123.11 64.33,123.11 64.44,123.21 69.5,123.21 70.17,122.54 71.07,122.54 72.14,121.47 76.12,121.47 76.56,121.03 79.93,121.03 82.97,117.99 88.39,117.99 89.18,117.21 89.18,113.42 90.14,112.45 102.13,112.45 102.49,112.81 113.72,112.81 115.93,110.6 117.2,110.6 117.76,110.04 118.55,110.04 118.95,110.44 121.62,110.44 121.86,110.68 123.51,110.68 v2(124.06,111.23) ; v2(191.08,54.67) 191.19,54.56 195.48,54.56 v2(196.36,53.68)
  IN2 w0.114: v2(40.43,85.27) 40.94,85.78 51.77,85.78 v2(52.21,85.35)
  BOTTOM w0.076: 204.2,49.71 204.46,49.71 205.1,50.35 205.35,50.35 205.36,50.37 205.36,50.37 205.55,50.55 205.55,50.55 205.56,50.57 205.56,51.52 205.7,51.66 206.06,51.66 206.21,51.51 206.21,51.16 206.37,51 208.68,51 v2(208.76,50.93)
  BOTTOM w0.102: Q402.2 123.81,109.78 124.06,110.04 v2(124.06,111.23) ; v2(52.21,85.35) 53.17,84.38 53.17,77.3 54.08,76.38 54.08,70.54 55.2,69.42 55.2,58.58 56.35,57.44 56.35,55.05 56.9,54.5 56.9,51.64 v2(56.34,51.08) ; PU8100.1 11.69,115.27 12.14,114.82 ; v2(196.36,53.68) 196.35,53.68 196.35,52.63 197.24,51.74 197.24,50.46 198.14,49.56 198.66,49.56 198.81,49.71 204.2,49.71 ; PR8117.2 12.14,114.82 ; 12.14,114.82 PR8119.1 12.14,116.42 12.02,116.54 PC8104.2 11.19,117.02 15.17,117.02 17.27,114.91 20.1,114.91 23.94,111.08 v2(25.81,111.08)
PWRBTN#: length 15.3
  TOP w0.076: v3(204.58,51.33) 204.9,51.66 U4701.G5
  TOP w0.102: C4722.2 v2(194.76,53.2) 195.82,54.26 R4755.2 196.01,53.95 195.71,53.65 195.71,52.98 R4754.2 195.77,52.8 196.23,52.33 196.23,52.33 196.89,51.67 196.89,51.62 197.24,51.27 R4752.2 197.28,51.01 197.93,51.01 v2(198.28,50.65)
  BOTTOM w0.076: v3(204.58,51.33) 204.45,51.33 204.12,51.01 201.79,51.01 200.98,50.19
  BOTTOM w0.102: v2(198.28,50.65) 198.74,50.19 200.98,50.19
R_SPK+: length 163.9
  TOP w0.762: v4(165.92,118.32) 165.92,117.84 165.63,117.54 L3603.2
  IN1 w0.762: 219.44,16.08 221.29,17.93 221.29,20.48 222.11,21.3 222.11,23.96 224,25.85 224,26.7 225.09,27.79 225.09,33.34 226.01,34.26 226.01,38.2 226.37,38.57 226.37,47.07 226.83,47.53 226.83,54.28 226.35,54.77 226.35,58.51 225.87,58.99 225.87,60.25 223.04,63.07 220.75,63.07 217.64,66.19 217.64,67.39 ; 214.85,80 214.09,80.76 213.08,80.76 211.82,82.02 211.82,82.51 210.33,84 210.33,85.37 210.57,85.61 210.57,87.6 210.3,87.88 210.3,91.3 210.57,91.57 210.57,92.84 211.45,93.72 211.45,95.18 213.7,97.43 213.7,102.81 213.01,103.5 213.01,105.24 211.21,107.04 211.21,111.29 210.46,112.04 210.46,113.42 209.06,114.81 208.17,114.81 207.51,115.48 201.53,115.48 200.87,114.81 185.68,114.81 184.91,114.05 181,114.05 180.34,113.39 176.56,113.39 175.78,112.6 172.99,112.6 172.09,113.5 168.74,113.5 165.92,116.32 v4(165.92,118.32)
  IN1 w1.524: 217.64,67.39 217.64,76.2 216.16,77.68 216.16,78.69 214.85,80
  vias: v2(218.14,16.72) v2(218.19,16.03)
R_SPK+_R: length 5.1
  TOP w0.762: L3603.1 164.91,119.9 C3638.2 v2(164.81,122.32)
  BOTTOM w0.762: CN3600.1 165.45,122.96 v2(164.81,122.32)
R_SPK-: length 163.4
  TOP w0.762: L3602.2 163.66,121.43 v4(163.92,121.17)
  IN1 w0.762: 213.59,78.74 213.59,78.82 210.8,81.6 210.8,82.09 209.32,83.58 209.32,85.79 209.56,86.04 209.56,87.18 209.28,87.46 209.28,91.76 209.56,92.04 209.56,93.26 210.43,94.14 210.43,95.6 212.68,97.85 212.68,102.39 211.99,103.07 211.99,104.82 210.19,106.62 210.19,110.87 209.44,111.62 209.44,112.99 208.64,113.8 207.75,113.8 207.09,114.46 201.95,114.46 201.29,113.8 186.1,113.8 185.33,113.03 181.42,113.03 180.77,112.37 176.98,112.37 176.2,111.59 172.57,111.59 171.67,112.48 168.29,112.48 164.91,115.87 164.91,120.19 v4(163.92,121.17) ; 215.86,67.25 215.86,66.35 220.16,62.06 222.62,62.06 224.85,59.83 224.85,58.57 225.33,58.09 225.33,54.99 224.91,54.57 224.91,51.2 225.82,50.3 225.82,47.95 225.36,47.49 225.36,39.21 225,38.85 225,36.13 224.07,35.2 224.07,28.21 222.98,27.12 222.98,26.27 220.92,24.21 220.92,22.64 220.19,21.91 220.19,18.62 219.92,18.35
  IN1 w1.524: 213.59,78.74 213.59,77.32 215.86,75.05 215.86,67.25
  vias: v2(218.85,17.53) v2(218.85,16.9)
R_SPK-_R: length 2.9
  TOP w0.762: v4(163.94,124.35) 163.67,124.08 C3637.2 163.66,123.49 L3602.1
  BOTTOM w0.762: CN3600.2 164.36,124.76 v4(163.94,124.35)
REC_MUTE_LED: length 2.7
  TOP w0.102: R5002.1 42.82,52.78 43.84,52.78 44.34,53.27 Q5000.3
RECORD_MUTE_LED_CNTRL: length 238.4
  TOP w0.102: R5009.1 46.41,52.9 46.27,52.77 Q5000.2 44.98,52.77 44.69,52.49 44.69,50.93 45.25,50.38 46.57,50.38 46.85,50.09 47.6,50.09 49.02,48.67 49.02,47.38 44.81,43.17 44.81,39.12 48.32,35.62 48.32,34.95 50.14,33.13 55.67,33.13 55.87,32.93 58.75,32.93 59.01,32.67 59.01,32.2 56.45,29.63 56.45,28.37 57.39,27.43 v2(57.39,26.12) ; U3600.24 222.68,11.93 v2(222.74,11.87) ; v2(149.26,7.09) 147.25,7.09 142.99,11.35 135.05,11.35 v2(134.51,11.9)
  IN1 w0.114: v2(110.28,25.33) 110.66,24.95 115.17,24.95 117.5,22.61 119.11,22.61 v2(119.31,22.41)
  IN2 w0.114: v2(57.39,26.12) 57.79,25.71 58.19,25.71 58.75,26.28 59.8,26.28 60.09,26.56 64.81,26.56 65.99,25.38 67.03,25.38 70.13,28.49 75.51,28.49 77.62,30.59 80.8,30.59 81.83,29.56 90.74,29.56 91.92,28.38 95.69,28.38 97,29.69 98.74,29.69 98.93,29.88 101.32,29.88 104.01,27.19 109.26,27.19 110.28,26.17 v2(110.28,25.33) ; v2(222.74,11.87) 221.14,10.27 217.76,10.27 217.52,10.03 217.52,8.98 216.05,7.52 215.93,7.52 215.81,7.4 213.22,7.4 213.17,7.45 212,7.45 211.95,7.5 211.49,7.5 211.17,7.82 210.02,7.82 209.45,7.25 204.69,7.25 203.91,8.02 200.47,8.02 199.36,6.91 189.07,6.91 185.53,10.44 174.58,10.44 171.03,6.89 166.25,6.89 165.66,7.48 160.64,7.48 159.57,6.41 151.19,6.41 150.07,7.52 149.7,7.52 v2(149.26,7.09) ; v2(134.51,11.9) 133.98,11.9 133.19,11.1 129.01,11.1 128.71,11.4 128.53,11.4 125.48,14.45 125.48,19.16 121.78,22.87 119.77,22.87 v2(119.31,22.41)
REGN6V:
  vias: v2(124.21,23.98)
REQ_WLAN#: length 15.4
  TOP w0.102: v2(173.61,85.3) 173.74,85.16 Q4101.3 174.75,84.38 175.06,84.7 179.62,84.7 180.01,85.09 180.01,85.56 180.37,85.92 v2(180.37,86.61) 180.89,87.13 R4103.1 181.97,88.09 C4107.1 181.92,88.14 R4101.2
  BOTTOM w0.102: CN4100.53 173.7,85.21 v2(173.61,85.3)
REXT_PS: length 3.7
  TOP w0.102: U5800.2 207.36,113.35 207.81,113.8 208.74,113.8 v2(209.09,113.45) 209.4,113.76 R5800.2
RSMRST#: length 362.8
  TOP w0.102: R4762.2 214.32,56.34 215.5,56.34 215.73,56.57 216.52,56.57 217.1,57.16 D4700.2 217.1,59.31 217.2,59.42 217.2,59.93 216.44,60.69 216.44,62.8 214.13,65.1 211.65,65.1 211.24,64.7 210.11,64.7 209.35,65.45 209.35,67.4 208.87,67.88 208.87,72.18 208.09,72.97 208.09,74.29 209.11,75.31 v2(209.11,76.35) ; v2(185.5,74.02) 185.5,74.68 186.14,75.32 187.28,75.32 187.82,74.78 v2(188.59,74.78) ; v2(158.42,62.22) 158.39,62.19 152.95,62.19 145.05,54.29 141.63,54.29 140.98,53.64 107.86,53.64 106.36,55.14 62.96,55.14 58.52,59.57 58.52,60.55 53.64,65.44 50.35,65.44 v2(50.2,65.28) ; v2(32.14,120.71) R7720.1
  IN1 w0.127: v2(185.5,74.02) 185.09,73.6 185.09,65.7 184.62,65.23 184.62,61.7 v2(184.89,61.42) ; v2(159.3,68.01) 159.3,65.24 158.73,64.67 158.73,62.53 v2(158.42,62.22)
  IN2 w0.127: v2(159.3,68.01) 159.36,67.94 166.61,67.94 167.07,68.41 167.44,68.41 167.9,67.94 169.02,67.94 169.25,67.72 174.18,67.72 v2(174.66,67.24) ; v2(43.69,77.85) 41.48,80.07 40.37,80.07 39.35,81.08 35.06,81.08 25.18,90.96 25.18,92.99 26.63,94.45 26.63,100.05 17.19,109.5 17.19,114.31 18.11,115.24 23.54,115.24 27.94,119.64 31.91,119.64 32.14,119.87 v2(32.14,120.71)
  BOTTOM w0.079: U400.BR36 126.94,80 126.94,79.74 126.91,79.67 126.91,79.35 127,79.25 127,78.14
  BOTTOM w0.102: v2(50.2,65.28) 50.15,65.33 50.15,71.05 47.1,74.1 47.1,74.73 43.98,77.85 v2(43.69,77.85) ; 127,78.14 131.4,73.74 131.4,72.67 131.07,72.34 130.67,72.34 130.56,72.24 130.56,71.75 131.39,70.92 131.39,70.53 131.25,70.39 131.17,70.31 131.17,68.53 132.41,67.3 132.41,65.89 135.09,63.2 143.09,63.2 143.37,62.92 148.94,62.92 149.72,62.14 152.62,62.14 156.64,66.16 157.78,66.16 159.3,67.68 v2(159.3,68.01) ; v2(188.59,74.78) 188.96,74.78 189.85,75.67 194.6,75.67 196.1,77.17 200.59,77.17 201.1,77.68 202.27,77.68 203.23,78.64 204.15,78.64 204.51,78.28 204.51,77.87 204.71,77.67 204.71,76.6 205.23,76.08 206.13,76.08 206.41,76.36 209.1,76.36 v2(209.11,76.35) ; v2(174.66,67.24) 174.66,67.21 174.26,66.82 174.26,66.01 174.08,65.83 174.08,64.31 174,64.22 174,63.31 175.86,61.45 178.88,61.45 179.93,60.41 183.22,60.41 183.68,60.86 184.34,60.86 v2(184.89,61.42)
RSMRST#_R: length 6.1
  TOP w0.102: R4762.1 212.93,55.87 212.54,56.26 v2(211.52,56.26) 211.24,55.98 R4763.1 210.52,55.43 210.4,55.56 209.05,55.56 208.4,54.91 U4701.M10
RSMRST_PG: length 277.8
  TOP w0.076: U4701.H9 v3(205.88,54.58)
  TOP w0.102: D4700.1 217.1,60.81 217.66,60.25 217.66,57.08 216.64,56.06 v2(216.14,56.06) ; v2(54.62,52.35) 57.08,52.35 57.52,52.79 58.03,52.79 59.65,51.17 103.07,51.17 105.13,49.12 117.21,49.12 118.06,48.27 143.53,48.27 144.29,49.02 169.86,49.02 179.04,58.2 183.88,58.2 184.08,58.4 v2(184.67,58.4)
  IN1 w0.076: v3(205.88,54.58) 205.7,54.58 205.22,55.07 205.22,55.26 204.75,55.73 204.4,55.73 203.98,56.16
  IN1 w0.114: v2(184.67,58.4) 184.76,58.31 185.61,58.31 185.62,58.29 186.67,58.29 187.95,59.57 191.27,59.57 192.71,58.14 194.46,58.14 195.1,58.78 197.89,58.78 199.08,57.59 200.75,57.59 201.68,58.53 201.95,58.53 202.69,57.79 202.69,57.02 203.54,56.16 203.98,56.16
  BOTTOM w0.076: v3(205.88,54.58) 205.88,54.7 208.03,56.85
  BOTTOM w0.102: v2(216.14,56.06) 216.13,56.06 215.88,56.31 214.36,56.31 213.72,56.95 208.14,56.95 208.03,56.85 ; PU8100.7 5.91,114 6.03,113.88 6.03,113.57 7.63,111.97 PR8118.2 PR8120.2 10.33,110.22 11.46,109.1 11.46,108.5 11.9,108.06 17.81,108.06 18.51,107.36 20.05,105.82 20.05,105.09 18.91,103.94 18.91,101.07 19.59,100.39 19.59,92.94 30.34,82.19 30.34,79.94 32.49,77.78 37.19,77.78 37.88,78.47 44,78.47 44.53,77.93 46.12,77.93 49.79,74.26 49.79,73.49 50.55,72.73 50.55,68.61 51.54,67.62 51.54,66.73 52.41,65.87 52.41,60.18 53.2,59.39 53.2,56.7 53.96,55.94 53.96,55.05 53.83,54.92 53.83,53.52 54.62,52.73 v2(54.62,52.35)
RTC_DET#: length 139.4
  TOP w0.079: v1(129.65,84.84) 129.89,84.84 130.2,84.53 130.2,83.55 130.5,83.25 130.78,83.25 131,83.04 131,82.56 130.66,82.22 130.66,81.92 131.17,81.42 131.17,81.23
  TOP w0.102: Q7702.3 59.83,61.57 59.83,59.77 60.12,59.48 62.44,59.48 64.85,57.07 108.33,57.07 109.84,55.57 140.18,55.57 140.83,56.22 144.25,56.22 150.19,62.15 v2(150.19,62.61) ; v2(145.93,68.01) 145.69,67.77 143,67.77 142.16,66.93 137.32,66.93 136.31,67.93 136.31,68.78 137.05,69.51 137.05,71.06 R444.1 136.07,72.89 135.77,73.19 135.77,75.78 133.53,78.02 133.53,78.91 133,79.43 132.39,79.43 131.17,80.65 131.17,81.23
  IN1 w0.114: v2(145.93,68.01) 145.93,66.8 150.11,62.61 v2(150.19,62.61)
  BOTTOM w0.079: U400.BV29 129.33,84.52 v1(129.65,84.84)
RTC_RST#: length 171.4
  TOP w0.102: v2(60.79,58.57) 63.19,56.16 63.73,55.62 106.56,55.62 108.07,54.12 140.78,54.12 141.43,54.77 144.85,54.77 152.75,62.67 v2(157.97,62.67) ; v2(57.04,55.88) 56.72,55.57 Q7500B.3
  IN1 w0.127: v2(157.55,69.42) 157.55,69.11 v2(158.66,68.01) 158.66,65.32 157.97,64.63 v2(157.97,62.67)
  BOTTOM w0.079: R599.1 132.5,74.92 131.03,74.92 130.32,75.64 130.04,75.64 127.39,78.28 127.39,79.13 127.42,79.16 127.42,81.02 127.17,81.27 U400.BR34
  BOTTOM w0.102: v2(158.66,68.01) 158.66,67.72 157.58,66.64 156.34,66.64 153.58,63.88 143.77,63.88 143.49,64.16 135.49,64.16 133.37,66.29 133.37,67.7 132.14,68.93 132.14,69.92 132.61,70.39 132.61,72.11 C427.1 C426.1 ; R7704.1 154.58,71.41 155.82,70.18 156.55,70.18 157.31,69.42 v2(157.55,69.42) ; v2(57.04,55.88) 58.85,55.88 60.79,57.81 v2(60.79,58.57)
  BOTTOM w0.112: C426.1 133.5,73.18 133.5,74.07 133.21,74.36 R599.1
RTC_X1: length 37
  TOP w0.079: v1(125.93,83.57) 126.32,83.97 126.32,85.86 126.6,86.14 127.64,86.14 127.67,86.16 127.95,86.16
  TOP w0.102: Y401.1 156,82.6 C421.1 156,83.56 155.4,84.16 R586.1 151.53,84.16 151.24,83.88 150.35,83.88 150.22,84 149.36,84 148.63,84.73 146.54,84.73 v2(146.29,84.49) 145.4,83.6 142.62,83.6 142.45,83.76 141.21,83.76 141.15,83.82 139.66,83.82 137.35,86.14 133.54,86.14 133.51,86.16 127.95,86.16
  BOTTOM w0.079: v1(125.93,83.57) 125.74,83.39 125.73,83.39 U400.BN31
RTC_X2: length 34
  TOP w0.079: v1(125.93,82.87) 126.49,83.43 126.49,85.62 126.78,85.91 127.54,85.91
  TOP w0.102: Y401.2 152.76,82.94 C422.1 153.17,83.38 R586.2 152.11,83.37 v2(150.22,83.37) 150.1,83.37 149.98,83.49 149.19,83.49 148.43,84.25 146.74,84.25 145.6,83.11 142.42,83.11 142.25,83.28 141.01,83.28 140.95,83.34 139.46,83.34 136.89,85.91 127.54,85.91
  BOTTOM w0.079: U400.BN32 125.72,82.73 125.79,82.73 v1(125.93,82.87)
RUNSCI_EC#: length 6.2
  BOTTOM w0.079: R479.1 142.32,94.53 v2(141.76,94.53) 141.64,94.53 141.57,94.6 140.39,94.6 139.72,95.27 139.42,95.27 139.35,95.2 139.15,95.2 138.91,94.97 137.29,94.97 U400.CM12
S_SD_CD#: length 13.3
  TOP w0.102: U7600.23 42.62,27.2 v2(42.15,26.73) 42.37,26.5 42.37,25.4 41.33,24.36 38.13,24.36 37.52,23.76 v2(37.52,23.73)
  BOTTOM w0.102: CN7601.20 35.24,24.37 35.88,23.73 v2(37.52,23.73)
S_SD_CLK: length 3.6
  TOP w0.102: U7600.18 40.7,30.16 40.52,29.98 39.91,29.98 39.75,30.14 39.75,30.64 v2(39.73,30.66)
  BOTTOM w0.102: v2(39.73,30.66) 39.75,30.64 39.75,30.3 39.43,29.98 39.43,29.8 39.58,29.65 R7625.1
S_SD_CLK_C: length 4.5
  BOTTOM w0.102: CN7601.12 39.24,27.32 39.01,27.55 38.48,27.55 38.4,27.62 38.4,27.91 38.49,28 39,28 39.18,28.17 39.18,28.38 39.04,28.51 C7618.2 38.8,28.52 R7625.2
S_SD_CMD: length 7
  TOP w0.102: v2(39.11,30.51) 39.11,30.41 39.76,29.76 U7600.19
  BOTTOM w0.102: v2(39.11,30.51) 38.84,30.51 38.19,29.86 38.19,27.36 38.24,27.31 CN7601.14
S_SD_DATA0: length 3
  TOP w0.102: U7600.17 40.48,30.56 v2(40.39,30.65)
  BOTTOM w0.102: R7638.2 40.54,30.1 40.66,30.23 41,30.23 41.12,30.36 41.12,30.53 41,30.65 v2(40.39,30.65)
S_SD_DATA0_C: length 5.7
  BOTTOM w0.102: CN7601.10 40.24,27.31 39.99,27.56 39.99,28.2 40.06,28.28 40.31,28.28 40.41,28.17 40.41,27.56 40.53,27.44 40.7,27.44 40.82,27.56 40.82,28.17 40.92,28.28 40.98,28.28 41.32,28.61 C7626.2 41.32,29.69 R7638.1
S_SD_DATA1: length 2.3
  TOP w0.102: v2(40.28,31.6) 40.28,31.43 40.76,30.96 U7600.16
  BOTTOM w0.102: R7639.2 40.78,32.1 v2(40.28,31.6)
S_SD_DATA1_C: length 5.8
  BOTTOM w0.102: CN7601.8 41.24,28.14 41.36,28.26 41.5,28.26 41.73,28.49 C7623.2 41.76,31.14 R7639.1
S_SD_DATA2: length 5.1
  TOP w0.102: R7641.2 37.46,30.1 38.36,30.1 38.92,29.55 39.18,29.55 39.77,28.96 U7600.21
S_SD_DATA2_C: length 3.3
  TOP w0.102: R7641.1 36.94,28.3 v2(36.56,27.92) 36.93,27.55 C7624.2
  BOTTOM w0.102: v2(36.56,27.92) 36.56,27.59 36.24,27.27 CN7601.18
S_SD_DATA3: length 5
  TOP w0.102: v2(37.75,30.53) 38.5,30.53 39.67,29.35 U7600.20
  BOTTOM w0.102: R7640.2 37.16,30.53 v2(37.75,30.53)
S_SD_DATA3_C: length 3
  BOTTOM w0.102: CN7601.16 37.24,28.34 C7625.2 37.03,28.9 36.91,29.01 R7640.1
S_SD_WP: length 6.6
  TOP w0.102: v2(42.32,23.3) 42.35,23.32 R7600.2 43.74,23.31 43.74,22.32 R7615.1 43.73,21.52 v2(43.74,21.5)
  BOTTOM w0.102: v2(42.32,23.3) 42.24,23.38 42.24,25.09 CN7601.6
SAR_DPR: length 2.6
  TOP w0.102: R4214.2 193.78,71.22 v2(193.58,71.02)
  BOTTOM w0.114: v2(193.58,71.02) 193.81,71.02 194.45,71.66 CN4200.25
SATA_LED#_C: length 3.4
  TOP w0.102: v2(205.06,7.7) 205.62,7.7 D4300.1 206.05,7.27 v2(207,7.27)
  BOTTOM w0.102: v2(205.06,7.7) 205.18,7.59 CN4300.10
SATA_RXN7: length 158.2
  IN2 w0.102: v1(125.94,97.06) 127.23,97.06 128.38,95.91 128.38,95.35 128.69,95.04 129.48,95.04 130.16,94.37 132.48,94.37 132.98,93.87 132.98,93.56 133.16,93.38 133.28,93.26 133.42,93.12 137.12,93.12 138.03,92.21 138.03,91.54 138.96,90.61 139.57,90.61 140.08,90.1 140.94,90.1 140.94,90.09 141,90.09 141.02,90.07 141.03,90.07
  IN2 w0.114: v2(220.07,28.08) 220.35,27.8 220.44,27.8 220.84,28.2 220.84,35.59 219.48,36.96 219.48,43.44 218.18,44.73 218.18,46.17 216.09,48.27 216.09,53.83 216.59,54.34 216.59,56.24 216.33,56.5 215.59,56.5 212.85,59.24 212,59.24 211.42,59.82 210.73,59.82 210.05,60.5 209.7,60.5 207.77,62.42 205.71,62.42 205.3,62.83 204.71,62.83 202.46,65.09 201.95,65.09 201.13,65.91 201.13,67.63 199.46,69.3 199.11,69.3 197.61,70.8 197.23,70.8 195.61,69.17 193.22,69.17 192.2,68.15 191.4,68.15 190.86,68.69 190.86,68.87 190.72,69.02 189.82,69.02 189.74,68.94 188.08,68.94 187.44,69.58 187.44,75.77 185.91,77.3 185.91,81.02 183.75,83.18 183.75,85.36 183.98,85.6 183.98,86.21 183.49,86.7 178.66,86.7 177.75,87.61 175.5,87.61 174.48,88.63 172.22,88.63 170.96,87.37 169.11,87.37 168,86.27 167.25,86.27 167.17,86.35 165.84,86.35 165.46,85.97 162.22,85.97 161.8,85.55 158.88,85.55 157.99,86.44 157.72,86.44 155.9,88.26 152.9,88.26 152.31,88.85 150.24,88.85 149.5,89.59 147.39,89.59 146.9,90.07 146.38,90.07 146.08,89.77 145.08,89.77 144.6,90.25 142.25,90.25 142.08,90.07 141.03,90.07
  BOTTOM w0.079: U400.BN10 125.69,96.8 v1(125.94,97.06)
  BOTTOM w0.097: C4405.1 220.28,25.28 220.36,25.36 220.36,25.88 219.65,26.59 219.65,27.66 v2(220.07,28.08)
SATA_RXN7_C: length 2.4
  BOTTOM w0.097: C4405.2 220.07,24.5 220.38,24.19 220.38,24.01 220.95,23.44 220.95,23.38 220.8,23.24 CN4400.6
SATA_RXP7: length 158.2
  IN2 w0.102: 141.03,90.3 140.17,90.3 139.66,90.81 139.05,90.81 138.24,91.62 138.24,92.29 137.2,93.32 133.5,93.32 133.42,93.4 133.18,93.65 133.18,93.95 132.56,94.57 130.24,94.57 129.57,95.25 128.77,95.25 128.58,95.43 128.58,95.99 127.31,97.26 126.37,97.26 126.16,97.48 v1(126.16,97.69)
  IN2 w0.114: 141.03,90.3 141.98,90.3 142.16,90.48 144.69,90.48 145.18,90 145.98,90 146.29,90.3 147,90.3 147.48,89.82 149.6,89.82 150.34,89.08 152.4,89.08 152.99,88.49 156,88.49 157.82,86.67 158.09,86.67 158.98,85.78 161.7,85.78 162.12,86.2 165.37,86.2 165.75,86.58 167.27,86.58 167.34,86.5 167.91,86.5 169.01,87.6 170.87,87.6 172.12,88.85 174.58,88.85 175.59,87.84 177.84,87.84 178.75,86.93 183.59,86.93 184.21,86.31 184.21,85.5 183.97,85.27 183.97,83.27 186.14,81.11 186.14,77.4 187.67,75.87 187.67,69.67 188.17,69.17 189.64,69.17 189.72,69.25 190.81,69.25 191.09,68.97 191.09,68.79 191.5,68.38 192.11,68.38 193.13,69.4 195.51,69.4 197.14,71.02 197.7,71.02 199.2,69.53 199.55,69.53 201.35,67.72 201.35,66 202.04,65.32 202.55,65.32 204.81,63.06 205.39,63.06 205.81,62.65 207.87,62.65 209.79,60.72 210.15,60.72 210.82,60.05 211.51,60.05 212.1,59.47 212.95,59.47 215.69,56.73 216.43,56.73 216.82,56.34 216.82,54.24 216.31,53.73 216.31,48.36 218.41,46.26 218.41,44.82 219.7,43.53 219.7,37.05 221.07,35.69 221.07,28.1 220.54,27.57 220.21,27.57 v2(220.06,27.42)
  BOTTOM w0.079: U400.BN8 126.02,97.56 v1(126.16,97.69)
  BOTTOM w0.097: C4404.1 220.66,25.28 220.55,25.38 220.55,25.97 219.85,26.68 219.85,27.25 220.02,27.42 v2(220.06,27.42)
