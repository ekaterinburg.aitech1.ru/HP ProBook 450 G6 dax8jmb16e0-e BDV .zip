# Allegro board dax8jmb16e0-e-www.DeviceDB.xyz_.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
WLAN_TRANSMIT_OFF#: length 7.8
  BOTTOM w0.079: U400.CP12 138.37,95.28 138.58,95.5 138.66,95.54 139.21,95.54 139.26,95.59 139.68,95.59 140.5,94.77 141.34,94.77 141.49,94.92 142.35,94.92 142.53,94.74 143.55,94.74 143.7,94.59 R4116.2
  BOTTOM w0.102: R4106.2 145.05,94.46 144.91,94.61 143.96,94.61 R4116.2
WLAN_WAKE#: length 10.6
  TOP w0.102: v2(173.5,86.92) 173.5,87.68 R4105.1 172.95,88.58 172.6,88.93 R4117.1 172.73,89.24 173.44,89.95 Q4104.1
  BOTTOM w0.102: v2(173.5,86.92) 173.5,86.31 174.42,85.38 174.42,84.3 174.2,84.07 CN4100.55
WR_CLK_DN: length 35
  IN2 w0.114: v1(143.01,82.02) 143.01,81.68 143.18,81.51 149.63,81.51 151.69,79.46 152.79,79.46 153.22,79.89 154.08,79.89 154.36,79.61 155.56,79.61 155.63,79.69 156.96,79.69 157.7,78.94 165.48,78.94 165.69,79.15 165.69,79.27 v2(165.4,79.56)
  BOTTOM w0.079: U400.CN31 138.17,83.55 138.94,83.55 139.24,83.24 140.7,83.24 140.86,83.08 142.57,83.08 142.75,82.9 142.75,82.29 v1(143.01,82.02)
  BOTTOM w0.097: CN4100.21 165.7,81.98 165.62,81.9 165.62,81.34 165.47,81.19 165.47,80.63 165.62,80.48 165.62,79.79 v2(165.4,79.56)
WR_CLK_DP: length 35
  IN2 w0.114: v1(142.38,82) 143.09,81.29 149.54,81.29 151.6,79.23 152.88,79.23 153.32,79.66 153.99,79.66 154.27,79.38 155.65,79.38 155.73,79.46 156.86,79.46 157.6,78.71 165.58,78.71 165.92,79.06 165.92,79.37 v2(166.12,79.56)
  BOTTOM w0.079: U400.CP31 138.73,83.38 138.87,83.38 139.17,83.07 140.63,83.07 140.79,82.91 142.5,82.91 142.58,82.83 142.58,82.2 v1(142.38,82)
  BOTTOM w0.097: v2(166.12,79.56) 165.97,79.56 165.82,79.71 165.82,80.56 165.67,80.71 165.67,81.11 165.82,81.26 165.82,81.82 166.2,82.2 CN4100.23
WR_LANE0_DN: length 34
  IN2 w0.114: v2(164.07,79.64) 164.17,79.64 164.3,79.77 164.3,80.4 164.07,80.62 160.82,80.62 160.49,80.96 158.66,80.96 158.23,81.39 156,81.39 154.86,82.53 154.29,82.53 153.46,83.37 149.95,83.37 149.55,83.77 145.36,83.77 144.9,83.32 142.15,83.32 141.89,83.58 141.89,84.01 141.75,84.14 v1(141.48,84.14)
  BOTTOM w0.079: v1(141.48,84.14) 141.84,84.14 141.91,84.06 141.91,83.72 141.65,83.46 140.99,83.46 140.83,83.62 139.36,83.62 139.1,83.88 138.86,83.88 U400.CR30
  BOTTOM w0.097: v2(164.07,79.64) 164.23,79.64 164.35,79.76 164.35,80.83 164.5,80.99 164.5,81.94 164.43,82.02 164.32,82.02 164.2,82.14 CN4100.15
WR_LANE0_DP: length 34
  IN2 w0.114: v1(142.25,84.18) 142.12,84.05 142.12,84.05 142.12,83.67 142.25,83.55 144.81,83.55 145.26,84 149.64,84 150.05,83.6 153.55,83.6 154.39,82.76 154.95,82.76 156.1,81.62 158.33,81.62 158.76,81.18 160.58,81.18 160.91,80.85 164.17,80.85 164.53,80.49 164.53,79.85 v2(164.75,79.64)
  BOTTOM w0.079: v1(142.25,84.18) 142.1,84.03 142.1,83.83 142.08,83.81 142.08,83.65 141.72,83.29 140.92,83.29 140.76,83.45 139.29,83.45 139.03,83.71 138.31,83.71 U400.CP30
  BOTTOM w0.097: CN4100.17 164.7,80.9 164.54,80.75 164.54,79.84 v2(164.75,79.64)
WR_LANE1_DN: length 32.8
  IN2 w0.114: v2(162.69,79.46) 162.87,79.64 162.87,79.84 162.75,79.96 157.9,79.96 157.25,80.61 151.41,80.61 150.05,81.97 144.1,81.97 143.47,82.61 141.01,82.61 140.04,83.58 140.04,84.11 139.93,84.23 v1(139.82,84.23)
  BOTTOM w0.079: v1(139.82,84.23) 139.82,84.13 139.71,84.02 139.47,84.02 139.09,84.4 138.61,84.4 138.45,84.33 137.82,84.33 137.77,84.3 137.39,84.3 137.02,83.93 U400.CM30
  BOTTOM w0.097: CN4100.9 162.7,80.24 162.91,80.03 162.91,79.68 v2(162.69,79.46)
WR_LANE1_DP: length 32.8
  IN2 w0.114: v1(140.43,84.2) 140.27,84.04 140.27,83.67 141.11,82.83 143.56,82.83 144.2,82.2 150.14,82.2 151.5,80.84 157.35,80.84 158,80.19 162.85,80.19 163.13,79.91 163.13,79.79 v2(163.46,79.46)
  BOTTOM w0.079: U400.CN30 137.62,84.14 137.81,84.14 137.86,84.16 138.48,84.16 138.65,84.23 139.02,84.23 139.4,83.85 140.08,83.85 v1(140.43,84.2)
  BOTTOM w0.097: v2(163.46,79.46) 163.13,79.78 163.13,80.09 162.9,80.32 162.9,81.89 163.2,82.2 CN4100.11
WT_CLK_DN: length 49
  IN2 w0.114: v1(140.83,79.89) 141.07,79.65 141.07,79.5 141.34,79.23 142.28,79.23 142.73,78.78 148.01,78.78 149.98,76.81 152.18,76.81 152.59,76.41 155.68,76.41 156.04,76.77 166.44,76.77 168.16,78.49 169.4,78.49 170.14,79.23 170.56,79.23 171.67,80.33 173.96,80.33 174.19,80.56 178.32,80.56 178.56,80.32 178.77,80.32 v2(179,80.09)
  BOTTOM w0.079: v1(140.83,79.89) 141.04,80.1 141.04,80.5 140.9,80.64 139.98,80.64 139,81.63 138.68,81.63 138.55,81.56 138.09,81.56 U400.CP34
  BOTTOM w0.097: CN4100.71 178.2,82.04 178.31,81.93 178.31,80.78 v2(179,80.09)
WT_CLK_DP: length 49.1
  IN2 w0.114: v2(178.96,80.73) 178.78,80.55 178.66,80.55 178.41,80.79 174.1,80.79 173.86,80.56 171.57,80.56 170.47,79.46 170.04,79.46 169.3,78.72 168.07,78.72 166.35,77 155.95,77 155.58,76.64 152.68,76.64 152.27,77.04 150.07,77.04 148.1,79.01 142.82,79.01 142.38,79.46 141.44,79.46 141.3,79.6 141.3,79.72 v1(141.44,79.86)
  BOTTOM w0.079: v1(141.44,79.86) 141.21,80.09 141.21,80.57 140.97,80.81 140.05,80.81 139.06,81.79 138.63,81.79 138.51,81.72 138.21,81.72 138.15,81.79 137.89,81.79 137.6,81.49 U400.CN34
  BOTTOM w0.097: CN4100.73 178.7,82.04 178.51,81.85 178.51,80.86 178.64,80.73 v2(178.96,80.73)
WT_LANE0_DN: length 48.2
  IN2 w0.114: v1(140.42,82) 140.64,82 140.78,81.87 140.78,81.22 141.37,80.62 149.13,80.62 151.49,78.26 156.98,78.26 157.18,78.07 165.84,78.07 167.14,79.36 167.14,80.33 167.69,80.88 169.48,80.88 169.91,81.31 170.49,81.31 170.86,81.68 172.77,81.68 173.44,82.35 176.18,82.35 176.94,81.6 176.94,81.41 176.79,81.25 v2(176.61,81.25)
  BOTTOM w0.079: U400.CN32 137.64,82.85 138.91,82.85 139.16,82.59 140.53,82.59 140.8,82.33 140.8,82.09 140.71,82 v1(140.42,82)
  BOTTOM w0.097: CN4100.65 176.7,82.04 176.77,81.97 176.89,81.97 176.97,81.89 176.97,81.46 176.76,81.25 v2(176.61,81.25)
WT_LANE0_DP: length 48.2
  IN2 w0.114: v1(141.15,82.03) 141,81.88 141,81.31 141.46,80.85 149.23,80.85 151.59,78.49 157.08,78.49 157.27,78.29 165.75,78.29 166.91,79.46 166.91,80.42 167.59,81.11 169.38,81.11 169.81,81.54 170.4,81.54 170.77,81.91 172.67,81.91 173.34,82.58 176.28,82.58 177.17,81.69 177.17,81.42 v2(177.34,81.25)
  BOTTOM w0.079: v1(141.15,82.03) 140.97,82.21 140.97,82.4 140.6,82.76 139.23,82.76 138.98,83.02 137.12,83.02 U400.CM32
  BOTTOM w0.097: CN4100.67 177.2,81.98 177.17,81.95 177.17,81.42 v2(177.34,81.25)
WT_LANE1_DN: length 48.1
  IN2 w0.114: v2(174.97,81.23) 175.19,81.23 175.32,81.36 175.32,81.55 175.18,81.69 173.97,81.69 173.31,81.03 171.28,81.03 170.39,80.14 168.99,80.14 168.87,80.02 168.87,79.51 168.58,79.22 167.95,79.22 166.15,77.42 155.82,77.42 155.66,77.58 150.59,77.58 148.73,79.43 143.14,79.43 142.91,79.66 142.91,79.88 142.76,80.03 v1(142.58,80.03)
  BOTTOM w0.079: U400.CP33 138.52,82.12 139,82.12 139.89,81.24 144.33,81.24 144.46,81.11 144.46,80.93 144.33,80.8 143.11,80.8 142.92,80.61 142.92,80.18 142.77,80.03 v1(142.58,80.03)
  BOTTOM w0.097: CN4100.59 175.2,82.09 175.28,82.01 175.4,82.01 175.5,81.92 175.5,81.81 175.36,81.67 175.36,81.35 175.24,81.23 v2(174.97,81.23)
WT_LANE1_DP: length 48.1
  IN2 w0.114: v2(175.75,81.23) 175.55,81.43 175.55,81.64 175.27,81.92 173.88,81.92 173.22,81.26 171.19,81.26 170.3,80.37 168.89,80.37 168.64,80.12 168.64,79.6 168.48,79.45 167.86,79.45 166.06,77.65 155.91,77.65 155.75,77.81 150.68,77.81 148.83,79.66 143.23,79.66 143.14,79.75 143.14,79.91 143.14,79.92 v1(143.27,80.05)
  BOTTOM w0.079: v1(143.27,80.05) 143.09,80.22 143.09,80.54 143.18,80.64 144.4,80.64 144.63,80.86 144.63,81.18 144.4,81.4 139.96,81.4 139.07,82.29 138.67,82.29 138.66,82.3 138.26,82.3 U400.CN33
  BOTTOM w0.097: v2(175.75,81.23) 175.56,81.42 175.56,81.59 175.7,81.73 CN4100.61
WW_LED#: length 306
  TOP w0.102: v2(38.28,60.97) 39.1,60.97 42.13,57.94 43.01,57.94 R5013.2 43.29,56.86 43.29,56.37 43.5,56.15 Q5004.4 ; v2(148.53,122.61) 148.63,122.51 148.63,122.3 154.41,116.52 154.41,115.43 159.13,110.71 163.84,110.71 171.27,103.28 172.74,103.28 177.99,98.03 181.09,98.03 182.47,96.64 184.97,96.64 189.89,91.72 189.89,83.76 v2(190.28,83.37)
  IN1 w0.114: v2(38.28,60.97) 37.59,61.67 37.59,75.35 37.07,75.88 37.07,81.21 27.81,90.46 27.81,92.16 26.51,93.46 25.63,93.46 16.58,102.51 16.58,104.2 16.37,104.41 16.37,107.45 20.49,111.57 20.49,113.73 25.94,119.19 25.94,122.27 24.22,123.99 24.22,127.71 24.99,128.48 25.78,128.48 26.2,128.9 28.7,128.9 29.18,128.43 31.38,128.43 31.97,127.84 35.38,127.84 35.87,127.34 37.64,127.34 38.83,128.54 39.35,128.54 39.48,128.66 39.48,129.6 39.69,129.8 41.01,129.8 41.77,129.05 51.74,129.05 52.16,129.47 57.79,129.47 58.3,128.96 73.07,128.96 73.28,128.75 78.79,128.75 81.02,126.52 85,126.52 88.79,130.31 88.79,131.9 88.85,131.97 88.85,133.69 v2(88.37,134.17)
  IN2 w0.114: v2(88.37,134.17) 88.58,133.96 88.58,128.51 90.53,126.57 90.53,124.65 91.69,123.49 100.13,123.49 106.05,117.57 108.79,117.57 109.66,118.44 114.83,118.44 115.11,118.72 117.47,118.72 121.28,122.53 126.66,122.53 127.35,123.22 128.41,123.22 129.09,122.53 131.84,122.53 132.45,121.93 133.3,121.93 133.9,122.53 147.09,122.53 147.56,122.99 148.14,122.99 v2(148.53,122.61)
  BOTTOM w0.102: v2(190.28,83.37) 190.53,83.62 192.65,83.62 193.12,83.15 R4209.1
WW_LED#_C: length 4.7
  BOTTOM w0.102: R4209.2 193.25,81.64 v2(193.16,81.55) 192.86,81.55 192.69,81.72 192.04,81.72 191.53,81.21 191,81.21 190.7,80.91 CN4200.10
WWAN_CONFIG_2: length 99.2
  TOP w0.102: v1(134.8,87.51) 134.8,87.71 135.16,88.07 137.09,88.07 137.84,87.32 140.46,87.32 140.68,87.55 143.64,87.55 143.96,87.23 144.64,87.23 144.71,87.31 146.41,87.31 146.91,86.81 148.97,86.81 149.77,86.01 R426.1 150.25,86.24 150.41,86.4 151.3,86.4 151.59,86.11 155.58,86.11 157.31,87.84 158.84,87.84 159.5,87.18 160.38,87.18 160.77,87.56 160.92,87.56 161.22,87.86 161.22,88.6 v2(161.03,88.79)
  IN2 w0.114: v2(161.03,88.79) 161.03,88.91 161.79,89.66 163.12,89.66 164,90.54 169.18,90.54 169.43,90.79 173.54,90.79 174.22,91.47 176.8,91.47 178.46,93.12 180.37,93.12 182.1,91.39 182.76,91.39 183.88,90.27 185.96,90.27 186.57,89.66 186.57,88.37 186.38,88.17 186.38,86.72 186.87,86.24 187.3,86.24 187.69,85.85 187.69,84.6 189.6,82.69 189.6,81.75 190.18,81.17 190.18,74.97 190.02,74.81 v2(189.8,74.6)
  BOTTOM w0.102: v2(189.8,74.6) 190.02,74.81 190.47,75.27 194.77,75.27 196.27,76.76 200.76,76.76 201.27,77.27 203.18,77.27 203.68,77.77 204.03,77.77 204.31,77.5 204.31,76.43 206.95,73.79 CN4200.75 ; U400.CH23 134.8,87.93 v1(134.8,87.51)
WWAN_CONFIG_3: length 93.5
  TOP w0.102: 200.9,78.24 200.9,78.14 202.29,76.74 202.29,75.88 202.04,75.62 202.04,73.84 201.4,73.21 198.1,73.21 197.65,73.66 D4201.2 195.96,74.73 195.53,74.73 v2(195.24,75.02) ; v1(134.22,87.49) 134.22,87.73 134.78,88.3 137.24,88.3 138,87.54 140.23,87.54 140.44,87.75 143.5,87.75 144.22,88.47 145.88,88.47 146.91,87.44 150.58,87.44 150.75,87.61 R431.1 151.03,87.67 151.62,87.67 152.27,87.03 155.58,87.03 158.29,89.73 158.7,89.73 159.15,89.28 v2(159.15,89.14)
  IN2 w0.114: v2(159.15,89.14) 159.25,89.24 161.02,89.24 161.67,89.89 162.97,89.89 163.85,90.77 169.08,90.77 169.33,91.02 173.45,91.02 174.13,91.7 176.71,91.7 178.36,93.35 180.47,93.35 182.2,91.62 182.85,91.62 183.97,90.5 186.07,90.5 186.8,89.77 186.8,88.27 186.61,88.08 186.61,86.83 186.97,86.47 187.39,86.47 187.94,85.91 187.94,84.67 189.83,82.79 189.83,81.84 190.41,81.27 190.41,76.69 191.93,75.17 v2(191.93,74.86)
  BOTTOM w0.102: v2(195.24,75.02) 195.2,75.06 192.13,75.06 v2(191.93,74.86) ; v1(134.22,87.49) 134.21,87.49 U400.CG23
WWAN_CONFIG_3_C: length 39.4
  TOP w0.102: v2(195.79,75.37) 195.79,75.46 196.28,75.96 D4201.1 197.04,74.78 198.36,73.46 201.15,73.46 201.66,73.97 201.66,75.75 201.41,76 v2(201.41,76.79) ; Q4202.5 206.92,62.87 206.77,63.02 206.77,63.49 v2(206.54,63.73) 206.47,63.79 R4250.2
  IN1 w0.114: v2(206.54,63.73) 206.54,64.11 207.36,64.94 207.36,65.43 206.36,66.43 206.36,67.67 205.97,68.06 205.12,68.06 203.01,70.16 203.01,71.24 201.73,72.52 201.73,75.19 201.63,75.29 201.63,75.75 201.3,76.08 201.3,76.68 v2(201.41,76.79)
  BOTTOM w0.102: CN4200.1 188.45,73.39 189.2,74.15 189.93,74.15 190.66,74.88 191.33,74.88 191.76,74.45 195.25,74.45 195.79,74.99 v2(195.79,75.37)
WWAN_DET#: length 57.4
  TOP w0.076: v3(203.93,52.63) 203.6,52.31 U4701.E6
  TOP w0.102: R4700.1 214.7,54.81 v2(214.7,55.53) 214.86,55.68 215.63,55.68 215.86,55.45 216.8,55.45 218.07,56.72 218.07,62.03 214.39,65.71 211.39,65.71 211,65.32 210.36,65.32 209.96,65.71 209.96,67.65 209.48,68.13 209.48,72.43 208.75,73.16 208.75,74.09 210.45,75.79 210.45,78.08 209.62,78.91 206.27,78.91 205.85,78.49 205.85,77.29 R4202.2
  BOTTOM w0.076: 208.16,56.7 206.21,54.75 206.21,54.34 206.13,54.25 205.75,54.25 205.37,53.87 205.37,52.3 204.73,51.67 203.77,51.67 203.6,51.84 203.6,52.3 v3(203.93,52.63)
  BOTTOM w0.102: v2(214.7,55.53) 214.36,55.53 213.19,56.7 208.16,56.7
WWAN_I2C_INT#_C: length 39.2
  TOP w0.102: Q4202.1 209.56,62.22 209.8,62.46 209.8,63.9 208.74,64.95 208.74,67.15 208.26,67.63 208.26,70.81 v2(207.94,71.13)
  IN1 w0.114: v2(201,71.18) 200.82,71.18 200.43,71.57 200.12,71.57 198.23,73.46 198.23,74.36 197.89,74.7 197.89,76.21 196.32,77.77 196.32,80.36 195.95,80.74 195.95,82.03 196.28,82.36 196.28,82.91 196.55,83.19 197.08,83.19 v2(197.33,82.94)
  BOTTOM w0.102: v2(207.94,71.13) 207.71,71.13 207.41,71.44 201.26,71.44 v2(201,71.18) ; CN4200.20 193.2,80.83 194.14,81.77 195.23,81.77 195.46,82 195.46,82.1 196.5,83.15 197.13,83.15 v2(197.33,82.94)
WWAN_I2C_INT#_L: length 3.2
  TOP w0.102: v2(205.06,64.16) 205.3,63.93 205.3,63.81 206.09,63.01 R4251.2 206.96,62.22 Q4202.6
WWAN_I2C_SCL: length 27.7
  TOP w0.076: 209.36,59.92 R4252.1 ; U4701.F5 v3(203.93,51.98) ; v2(210,59.72) 210.04,59.76 210.04,59.77
  TOP w0.102: 209.36,59.92 209.85,60.41 R4770.2 210.04,59.77
  BOTTOM w0.076: 205.6,58.17 205.6,58.1 205.72,57.97 205.72,57.71 205.37,57.36 205.37,54.69 205.06,54.39 205.06,52.61 204.77,52.32 204.26,52.32 v3(203.93,51.98)
  BOTTOM w0.102: R6120.2 218.03,61.47 216.34,61.47 213.98,59.11 213.98,57.71 213.72,57.46 211.18,57.46 210,58.64 v2(210,59.72) 206.46,59.72 205.6,58.86 205.6,58.17
WWAN_I2C_SCL_C: length 32.5
  TOP w0.102: v2(206.22,65.44) 206.14,65.36 206.14,64.99 206.6,64.52 207.54,64.52 208.09,63.98 208.09,62.03 207.91,61.85 207.44,61.85 206.99,61.41 206.99,61.03 206.82,60.85 Q4201.4
  IN1 w0.114: v2(206.22,65.44) 205.65,66.01 204.64,66.01 203.82,66.83 203.82,68.35 202.24,69.93 202.24,71 200.41,72.83 200.13,72.83 199.12,73.84 199.12,74.22 198.35,74.99 198.35,76.4 196.96,77.79 196.96,79.9 197.22,80.16 197.22,82.29 v2(197.19,82.32)
  BOTTOM w0.102: CN4200.28 195.2,81.16 195.87,81.83 195.87,81.94 196.25,82.32 v2(197.19,82.32)
WWAN_I2C_SCL_L: length 2
  TOP w0.102: Q4201.3 208.46,60.85 v2(208.94,61.33) 209.18,61.08 R4252.2
WWAN_I2C_SDA: length 27.7
  TOP w0.076: U4701.F6 v3(204.58,51.98)
  TOP w0.102: v2(206.08,58.63) 205.44,59.26 205.44,60.27 205.06,60.66 205.06,61.71 R4253.1 204.97,62.03 204.83,61.89 R4771.2
  BOTTOM w0.076: 205.56,55.52 205.56,54.47 205.21,54.12 205.21,52.51 204.69,51.98 v3(204.58,51.98)
  BOTTOM w0.102: R6119.2 216.25,61.08 214.23,59.06 214.23,57.59 213.85,57.21 210.93,57.21 209.51,58.63 v2(206.08,58.63) 206.61,58.1 206.61,56.57 205.56,55.52
WWAN_I2C_SDA_C: length 38.4
  TOP w0.102: v2(210.93,60.55) 210.4,60.03 210.4,59.49 210.14,59.24 208.52,59.24 208.2,59.55 Q4201.1
  IN1 w0.114: v2(210.93,60.55) 210.46,61.02 209.5,61.02 207.86,62.65 207.01,62.65 204.26,65.4 204.26,66.03 203.56,66.73 203.56,68.28 202.01,69.84 202.01,70.91 200.56,72.36 199.97,72.36 198.61,73.72 198.61,74.31 198.12,74.8 198.12,76.3 196.71,77.72 196.71,80.07 196.99,80.35 196.99,81.89 196.71,82.17 v2(196.71,82.74)
  BOTTOM w0.102: v2(196.71,82.74) 196.38,82.74 195.66,82.02 195.66,81.91 195.32,81.56 194.45,81.56 193.7,80.82 CN4200.22
WWAN_I2C_SDA_L: length 3.4
  TOP w0.102: Q4201.6 205.97,59.55 205.77,59.75 205.77,60.36 205.51,60.62 v2(205.51,61.12) 205.51,61.38 R4253.2
WWAN_IOT_INT#: length 14.3
  TOP w0.076: U4701.G9 v3(204.58,54.58)
  TOP w0.102: R4251.1 205.25,63.01 204.75,63.5 R4772.1 204.44,63.5 204.2,63.26 204.2,63.1 203.9,62.81 203.43,62.81 202.86,63.38 v2(202.53,63.38)
  BOTTOM w0.076: v3(204.58,54.58) 204.58,54.72 204.92,55.06 204.92,56.31 204.37,56.85
  BOTTOM w0.102: 204.37,56.85 204.13,57.09 204.13,58.38 204.25,58.5 204.25,58.9 202.47,60.68 202.47,61.41 202.31,61.56 202.31,63.17 v2(202.53,63.38)
WWAN_OFF#: length 114.6
  TOP w0.102: v2(209.46,77.53) 209.41,77.53 208.14,76.26 208.14,75.2 207.24,74.3 206.05,74.3 205.08,73.33 203.81,73.33 203.4,72.92 203.4,72.51 203.89,72.01 204.78,72.01 205.38,71.42 U4202.1 ; R4746.2 215.75,48.55 214.65,47.45 209.86,47.45 v2(209.79,47.53) 209.38,47.12 209.01,47.12 207.18,48.95 207.18,49.39 U4701.K2
  IN1 w0.114: v2(209.79,47.53) 210.24,47.99 210.24,52.3 207.83,54.72 207.15,54.72 206.27,55.61 205.63,55.61 202.26,58.98 201.49,58.98 200.56,58.05 199.27,58.05 197.97,59.34 196.5,59.34 195.64,60.2 193.42,60.2 189.92,63.71 188.58,63.71 185.9,66.39 185.9,70.31 186.49,70.9 186.49,79.06 v2(187.6,80.17) ; v2(209.46,77.53) 209.28,77.7 209.28,78.29 208.42,79.15 207.09,79.15 206.35,79.89 206.35,81.77 205.77,82.36 205.77,84.63 v2(203.97,86.43)
  BOTTOM w0.102: v2(203.97,86.43) 203.6,86.8 200.52,86.8 199.75,86.04 199.27,86.04 198.41,86.9 191.98,86.9 191.75,86.67 191.04,86.67 190.46,86.09 189.75,86.09 188.8,85.14 188.54,85.14 187.91,84.51 187.91,82.46 188.04,82.33 188.04,80.65 187.6,80.21 v2(187.6,80.17) 187.6,79.87 188.52,78.95 189.59,78.95 189.7,79.05 CN4200.6 189.7,80.73 191.04,82.08 R4203.2
WWAN_RST#: length 103.4
  TOP w0.102: U4201.6 196.18,79.57 195.94,79.81 194.93,79.81 194.77,79.66 R4235.2 194.77,79.18 194.62,79.03 194.62,77.91 194.47,77.76 v2(194.19,77.76) ; v2(148.62,83.29) 148.15,83.77 146.94,83.77 145.8,82.63 142.21,82.63 142.04,82.8 140.81,82.8 140.75,82.86 139.25,82.86 138.53,83.58 138.53,83.78 136.72,85.59 134.23,85.59 134.05,85.42 v1(133.33,84.69) ; v2(163.33,81.56) 163.33,81.88 R571.1
  IN1 w0.114: v2(176.89,75.41) 177.4,75.92 177.4,77.32 177.91,77.83 177.91,78.5 176.62,79.79 173.69,79.79 171.74,81.74 171.74,85 170.93,85.81 169.92,85.81 169.53,85.43 168.03,85.43 164.88,82.28 164.04,82.28 v2(163.33,81.56) 163.05,81.56 162.34,80.85 161.68,80.85 161.36,81.17 159.46,81.17 157.82,82.81 153.35,82.81 153.34,82.81 149.1,82.81 v2(148.62,83.29)
  BOTTOM w0.102: v1(133.33,84.69) 132.86,85.17 U400.CE28 ; v2(176.89,75.41) 176.89,75.15 178.42,73.62 178.42,71.24 177.14,69.96 177.14,66.55 178.62,65.07 182.94,65.07 184.74,66.87 184.74,70.25 182.87,72.12 182.87,72.86 186.63,76.62 188.12,76.62 188.81,77.3 193.73,77.3 v2(194.19,77.76)
WWAN_TRANSMIT_OFF#: length 365.8
  TOP w0.102: v2(151.57,87.02) 152.02,86.57 155.43,86.57 157.79,88.92 v2(158.16,88.92) ; D4200.1 191.88,83.73 191.78,83.83 R4213.1 190.31,84.72 v2(190.31,86.52) 190.95,87.16 190.95,89.98 190.67,90.25 190.67,91.37 190.89,91.58 190.89,92.66 189.73,93.82 188.66,93.82 185.22,97.25 182.72,97.25 181.34,98.64 178.24,98.64 172.99,103.89 171.52,103.89 164.09,111.32 159.39,111.32 155.3,115.4 155.3,116.9 150.15,122.05 150.15,122.79 v2(149.73,123.21) ; Q5004.5 43.37,55.5 43.08,55.79 43.08,57.4 42.74,57.74 41.94,57.74 41.72,57.95 40.49,57.95 v2(38.47,59.98)
  IN1 w0.114: v2(89.51,133.8) 89.97,133.34 89.97,132.43 89.27,131.74 89.27,130.14 85.19,126.06 80.83,126.06 78.72,128.18 75.14,128.18 74.47,127.51 73.78,127.51 73.42,127.88 72.27,127.88 71.65,128.5 58.11,128.5 57.76,128.85 52.51,128.85 50.92,127.26 49,127.26 48.48,127.78 42.19,127.78 40.84,126.43 35.49,126.43 35,126.92 31.06,126.92 30.3,126.16 29.87,126.16 29.17,126.85 26.57,126.85 26.39,127.04 25.47,127.04 25.16,126.72 25.16,124.35 26.39,123.11 26.93,123.11 27.19,122.85 27.19,119.47 21.17,113.45 21.17,110.96 17.39,107.18 17.39,104.93 18.5,103.82 18.5,101.88 26.23,94.14 27.12,94.14 29.04,92.22 29.04,91.28 38.84,81.48 38.84,75.24 38.28,74.67 38.28,67.28 39.53,66.02 39.53,64.34 38.31,63.12 38.31,62.75 38.94,62.12 38.94,60.44 v2(38.47,59.98)
  IN2 w0.114: v2(158.16,88.92) 158.16,89.39 158.58,89.82 160.89,89.82 161.42,90.35 162.66,90.35 163.55,91.23 168.9,91.23 169.14,91.48 171.3,91.48 172.21,92.39 176.42,92.39 178.08,94.04 184.31,94.04 189.34,89.01 189.34,87.48 v2(190.31,86.52) ; v2(89.51,133.8) 90.43,132.88 90.43,129.98 91.3,129.11 91.3,129.06 94.15,126.21 98.42,126.21 104.97,119.66 106.44,119.66 106.98,119.12 114.55,119.12 114.83,119.41 116.62,119.41 120.69,123.48 126.63,123.48 127.06,123.91 128.69,123.91 129.22,123.37 146.84,123.37 147.86,124.39 148.99,124.39 149.73,123.64 v2(149.73,123.21)
  BOTTOM w0.079: U400.CN22 137.65,88.76 138.39,88.76 138.5,88.65 138.62,88.59 139.99,88.59
  BOTTOM w0.102: 139.99,88.59 141.53,88.59 141.94,89.01 147.31,89.01 R474.1 147.56,89.37 147.91,89.72 149.21,89.72 151.57,87.36 v2(151.57,87.02)
WWAN_TRANSMIT_OFF#_R: length 9.2
  TOP w0.102: D4200.2 194.77,83.73 194.55,83.95 194.09,83.95 192.61,82.47 v2(192.61,82.2) 192.05,82.2 R4213.2
  BOTTOM w0.102: v2(192.61,82.2) 192.54,82.13 R4210.2 191.32,81.51 190.84,81.51 190.2,80.88 CN4200.8
WWAN_WAKE#: length 110.9
  TOP w0.102: v2(187.03,87.02) 186.82,87.02 186.09,86.29 185.12,86.29 183.93,85.09 183.93,79.89 182.45,78.41 v2(180.14,78.41)
  IN1 w0.114: v2(198.99,90.18) 198.31,90.18 197.21,89.08 197.21,87.18 197.59,86.8 197.59,84.64 199.12,83.11 199.12,82.67 v2(200.07,81.73) ; v2(171.76,76.89) 171.76,76.89 171.76,76.89 171.36,77.3 171.36,78.19 170.65,78.9 168.67,78.9 167.25,77.48 162.5,77.48 162.31,77.29 156.32,77.29 155.44,76.41 152.56,76.41 v2(152.2,76.05)
  IN2 w0.114: v2(187.03,87.02) 187.16,87.02 v2(188.64,85.55) ; v2(180.14,78.41) 179.99,78.57 178.57,78.57 177.81,79.33 175.16,79.33 174.47,78.64 174.47,77.66 173.74,76.93 172.57,76.93 172.52,76.89 v2(171.76,76.89)
  BOTTOM w0.079: U400.CP7 138.48,98.41 140.25,98.41 140.39,98.27 141.08,98.27 141.23,98.13 141.57,98.13 142.07,97.63 142.07,97.24 143.06,96.25 144.64,96.25 144.81,96.08
  BOTTOM w0.102: 144.81,96.08 144.85,96.04 144.85,95.83 145.32,95.36 149.38,95.36 149.6,95.15 149.96,95.15 R531.1 150.09,94.83 150.3,94.62 151.94,94.62 152.98,93.57 153.57,93.57 155.01,92.14 155.01,90.82 154.75,90.56 154.75,88.65 154.44,88.35 154.44,85.51 151.75,82.82 151.75,79.7 151.62,79.57 151.62,76.89 152,76.51 152,76.25 v2(152.2,76.05) ; v2(200.07,81.73) 200.04,81.75 200.04,81.8 200.01,81.83 R4245.1 ; v2(198.99,90.18) 190.7,90.18 189.58,89.06 189.58,86.49 v2(188.64,85.55)
WWAN_WAKE#_R: length 2.9
  BOTTOM w0.102: R4245.2 200.9,82.36 v2(200.9,81.65) 201.7,80.85 CN4200.54
WWANSSD_M2: length 76
  TOP w0.102: v2(158.63,88.51) 158.61,88.51 158.55,88.45 157.62,88.45 155.51,86.34 151.94,86.34 151.8,86.49 151.52,86.49 151.39,86.62 150.25,86.62 150.12,86.49 149.59,86.49 149.06,87.03 147,87.03 146.26,87.76 v2(144.81,87.76)
  IN2 w0.114: v2(192.32,73.3) 192.67,73.64 192.67,76.82 191.96,77.53 191.96,77.81 191,78.77 191,83.58 189.92,84.65 189.92,85.65 188.83,86.75 188.83,88.47 183.72,93.58 178.27,93.58 176.61,91.93 174.03,91.93 173.35,91.25 169.24,91.25 168.99,91 163.7,91 162.82,90.12 161.57,90.12 161.02,89.57 158.96,89.57 158.63,89.24 v2(158.63,88.51)
  BOTTOM w0.079: U400.CR24 139.21,87.72 139.3,87.62 140.17,87.62
  BOTTOM w0.102: v2(192.32,73.3) 193.28,73.3 193.45,73.13 CN4200.21 ; 140.17,87.62 142.46,87.62 R476.1 142.96,88.33 143.13,88.5 144.08,88.5 v2(144.81,87.76)
XCLK_BIASREF: length 10.7
  BOTTOM w0.079: R587.2 R627.1 141.47,103.81 140.95,104.32 140.19,104.32 139.91,104.04 139.91,103.49 139.75,103.33 139.28,103.33 138.76,103.85 136.68,103.85 135.32,102.49 U400.CJ1
  BOTTOM w0.102: R587.2 142.05,105.13 v2(142.53,105.6)
XDP_BPM0: length 128.7
  TOP w0.102: CN7700.21 35.76,119.79 35.64,119.91 35.64,121.13 36.18,121.67 36.6,121.67 37.12,122.19 37.12,122.37 37.91,123.17 41.22,123.17 42.1,122.29 42.1,120.17 v2(41.59,119.66)
  IN2 w0.114: v2(100.99,106.13) 100.99,106.27 100.8,106.47 100.62,106.47 98.86,108.23 92.66,108.23 92.01,108.87 85.02,108.87 79.03,102.88 78.68,102.88 70.56,94.75 68.81,94.75 66.13,92.07 61.28,92.07 59.61,90.4 57.97,88.77 40.69,88.77 39.48,89.97 35.36,89.97 33.8,91.54 33.8,92.74 36.33,95.27 36.33,102.11 40.63,106.41 40.63,107.79 41.91,109.07 41.91,111.67 41.72,111.87 41.72,114.5 42.24,115.02 42.24,117.14 41.03,118.35 41.03,119.1 v2(41.59,119.66)
  BOTTOM w0.079: U400.U1 103.5,102.29 103.5,103.8 101.98,105.33 101.86,105.33 101.27,105.92 101.2,105.92 v2(100.99,106.13)
XDP_BPM1: length 130.4
  TOP w0.102: CN7700.23 35.26,119.87 35.44,120.05 35.44,121.22 36.09,121.87 36.45,121.87 36.81,122.23 36.9,122.32 36.9,122.48 37.82,123.4 41.3,123.4 42.53,122.16 v2(42.53,120.96) 42.53,119.96 v2(41.59,119.02)
  IN2 w0.114: v2(103.89,103.24) 103.92,103.27 103.92,103.82 104.05,103.94 104.05,105.49 102.88,106.66 102.47,106.66 101.25,107.88 101.25,108.46 100.64,109.07 95.35,109.07 94.87,109.56 84.74,109.56 78.75,103.57 78.4,103.57 70.27,95.44 68.52,95.44 65.84,92.76 61,92.76 58.08,89.84 57.69,89.45 41.27,89.45 39.99,90.73 35.83,90.73 35.05,91.51 35.05,93.35 36.79,95.08 36.79,101.51 41.91,106.63 41.91,108.42 42.37,108.88 42.37,111.86 42.18,112.06 42.18,114.31 42.7,114.83 42.7,117.92 v2(41.59,119.02)
  BOTTOM w0.079: v2(103.89,103.24) 103.89,102.94 103.83,102.88 103.83,102.06 103.59,101.82 U400.U2
XDP_DBRESET#: length 329.3
  TOP w0.102: CN7700.48 29.26,110.71 29.89,110.07 C7702.2 30.67,109.31 30.67,108.38 R7719.1 30.18,108.15 30.06,108.03 30.06,105.97 25.08,100.99 v2(25.08,97.01) ; v2(160.66,75.19) 160.66,75.9 162.31,77.55 167.39,77.55 172,82.17 172.64,82.17 173.33,82.87 174.99,82.87 175.58,83.46 180.5,83.46 181.67,84.63 v2(181.67,85.16)
  IN1 w0.114: v2(89.56,134.44) 89.56,134.35 90.2,133.72 90.2,132.34 89.5,131.64 89.5,130.05 85.28,125.83 80.74,125.83 78.62,127.95 75.23,127.95 74.57,127.28 73.69,127.28 73.33,127.65 72.18,127.65 71.56,128.27 57.27,128.27 56.72,127.72 51.7,127.72 51.02,127.03 48.91,127.03 48.39,127.55 43.33,127.55 41.98,126.2 35.4,126.2 34.91,126.69 31.15,126.69 30.39,125.93 29.77,125.93 29.08,126.63 26.47,126.63 26.29,126.81 25.57,126.81 25.38,126.62 25.38,124.44 26.48,123.34 27.03,123.34 27.42,122.95 27.42,119.37 21.4,113.35 21.4,110.87 17.62,107.08 17.62,105.03 18.73,103.92 18.73,101.97 23.69,97.01 v2(25.08,97.01) ; v2(171.51,94.25) 172.32,93.43 174.4,93.43 177.85,89.99 178.76,89.99 179.25,89.49 180.82,89.49 181.23,89.09 181.23,87.34 182.16,86.41 182.16,85.65 v2(181.67,85.16)
  IN2 w0.114: v2(89.56,134.44) 90.19,133.8 90.41,133.58 91.04,133.58 93.3,131.32 93.3,131.03 93.07,130.8 93.07,129.75 93.8,129.01 120.75,129.01 122.36,127.41 129.64,127.41 132.9,124.14 133.48,124.14 133.8,123.83 146.09,123.83 147.47,125.2 155.55,125.2 v2(156.48,124.28) ; v2(139.86,97.31) 140.53,96.64 141.64,96.64 142.34,97.34 144.89,97.34 145.46,96.77 146.36,96.77 147.17,95.96 148.56,95.96 149.17,95.35 149.43,95.35 150.01,94.77 150.91,94.77 151.66,94.03 153.01,94.03 154.03,95.05 158.23,95.05 158.51,94.77 159.3,94.77 159.99,94.07 161.14,94.07 161.29,94.22 166.86,94.22 167.63,94.98 170.77,94.98 v2(171.51,94.25)
  BOTTOM w0.079: U400.CN10 137.82,96.85 138.39,96.85 138.49,96.95 138.64,97.01 138.7,97.03 138.97,97.03 139.12,96.88 139.43,96.88 v2(139.86,97.31)
  BOTTOM w0.102: CN7701.18 159.53,75.91 159.88,75.57 160.28,75.57 v2(160.66,75.19) ; v2(156.48,124.28) 156.43,124.23 156.43,122.32 155.97,121.87 155.97,118.68 156.35,118.31 156.35,116.96 156.12,116.73 156.12,116.14 159.48,112.78 162.94,112.78 166.85,108.87 169.38,108.87 170,108.26 170,106.01 170.99,105.01 170.99,98.55 172.25,97.3 172.25,94.99 v2(171.51,94.25)
XDP_TRST#: length 7.7
  TOP w0.102: CN7700.54 27.76,111.68 27.31,111.23 27.31,109.15 27.67,108.79 28.87,108.79 28.95,108.7 Q7701.6 28.95,107.22 v2(28.66,106.92)
XTAL1: length 8.5
  TOP w0.102: v2(189.79,63.01) Y4000.1 190.4,61.53 C4000.2 191.19,61.78 192.76,61.78 R4002.2 193.04,62.05 193.55,62.05 194.51,63.01 194.51,64.33 194.73,64.55 U4000.28
XTAL2: length 4.2
  TOP w0.102: Y4000.3 188.94,60.49 189.47,60.49 C4001.2 190.23,60.22 v2(191.01,60.22) 191.29,60.5 R4018.2
XTAL2_LAN: length 5.9
  TOP w0.102: R4018.1 192.75,61.28 R4002.1 192.93,61.13 194.73,62.93 194.73,64.2 194.99,64.47 195.05,64.47 195.13,64.55 U4000.29
XTAL24_IN: length 9.1
  BOTTOM w0.079: U400.CK3 135.99,101.07 135.88,101.07 135.69,101.26 135.69,101.83 135.56,101.95 135.56,102.46 136.03,102.93 138.96,102.93 139.32,102.57 140.44,102.57 140.6,102.42 141.74,102.42 L401.2 142.03,102.71 R589.1
XTAL24_IN_C: length 9.8
  BOTTOM w0.102: Y400.1 150.13,101.04 149.28,101.04 149.14,101.18 148.6,101.18 148.45,101.02 147.77,101.02 v2(147.61,101.18) 147.33,100.89 145.83,100.89 145.28,101.44 C424.1 144.17,101.65 R591.1 143.74,101.91 143.2,102.45 142.69,102.45 L401.1 142.48,102.66 R589.2
XTAL24_OUT: length 7.9
  BOTTOM w0.079: U400.CK2 135.94,101.44 135.94,101.8 135.72,102.02 135.72,102.34 136.1,102.72 138.75,102.72 139.18,102.29 140.37,102.29 140.47,102.19 141.84,102.19 L401.3 142.03,102.01 R590.1
XTAL24_OUT_C: length 8.9
  BOTTOM w0.102: Y400.3 149.33,100.67 148.87,100.67 v2(148.83,100.72) 148.77,100.77 147.76,100.77 147.58,100.59 145.72,100.59 C425.1 144.96,100.48 144.96,101.02 144.85,101.13 R591.2 143.92,101.16 142.97,102.11 L401.4 142.48,102.06 R590.2
XTAL_FREQ_SELECT: length 19.2
  TOP w0.079: v1(135.16,86.54) 135.67,87.05 137.1,87.05 137.25,86.91 138.79,86.91
  TOP w0.102: 138.79,86.91 141.15,86.91 141.34,87.1 142.55,87.1 143.4,86.24 143.53,86.24 144.51,85.26 v2(144.51,85.09) 144.51,85.04 v2(143.48,84)
  BOTTOM w0.102: U400.CF25 133.41,86.8 133.41,86.42 133.69,86.14 134.76,86.14 v1(135.16,86.54) ; v2(143.48,84) 144.1,83.38 144.1,82.64 144.31,82.43 144.79,82.43 145.2,82.83 R629.2 146.15,82.01 R628.2
N16923117: length 3.1
  TOP w0.102: v2(13.89,100.69) 14.09,100.48 R3300.1 14.72,101.27 C3300.2 14.71,102.65 R3312.1
N17267000: length 4.9
  TOP w0.203: PR8800.1 PC8800.1 46.36,99.35 46.36,100.01 v2(45.73,100.63) PU8800.40
N17285713: length 2
  TOP w0.102: U5100.6 167.07,70.73 R5104.1
N17286719: length 2.6
  TOP w0.102: R7507.2 53.07,61.17 52.91,61.01 v2(52.91,60.57) 53.29,60.57 53.58,60.28 U7500.2
N17777419: length 4.3
  TOP w0.102: v2(194.75,43.07) 194.75,43.46 195.72,44.43 R4736.2
  TOP w0.254: R4736.2 195.54,44.5 194.34,45.7 L4700.1
N17791245: length 4
  BOTTOM w0.102: v2(122.45,111.51) R468.1 121.63,111.12 122.07,110.68 122.07,110.54 121.97,110.43 Q402.6 121.2,110.43 121.06,110.3 121.06,109.91 121.19,109.78 Q402.5
N17791654: length 5.8
  BOTTOM w0.079: U400.BJ2 122.86,101.81 122.86,102.59 122.24,103.21 122.24,103.57 121.83,103.98 121.83,106.19 R458.2
N18345378: length 2.4
  BOTTOM w0.102: v2(38.21,111.99) 37.98,112.22 U5401.1
  BOTTOM w0.508: U5401.1 37.44,112.72 37.13,112.42 R5406.1
N18697825: length 2.2
  TOP w0.102: v2(162.94,66.39) 162.94,65.91 R7712.2 164.38,65.49 C7700.2
N18697895: length 2.4
  TOP w0.102: R4702.2 215.09,50.62 C4704.2 215.09,51.17 v2(215.6,51.68)
N18861075: length 4
  TOP w0.102: R5102.2 174.82,68.66 174.82,68.65 C5100.2 174.67,67.83 175.08,67.42 175.08,66.78 v2(174.95,66.65)
N18940787: length 3.9
  TOP w0.102: R4005.2 186.74,70.15 R4003.1 185.66,71.24 Q4001.2 186.5,72.27 v2(186.68,72.09)
N20385398: length 18.3
  TOP w0.203: 123.76,82.38 123.76,84.54 124.37,85.15 124.82,85.15 v1(125.18,85.5) 124.85,85.83 C631.1
  TOP w0.305: R620.1 123.68,72.73 v2(122.89,72.73) 122.25,72.73 121.8,73.18 121.8,77.17 123.53,78.9 123.53,82.15 123.76,82.38
  BOTTOM w0.254: U400.BL27 124.97,85.5 v1(125.18,85.5)
  BOTTOM w0.305: U400.BM26 125.11,86.27 125.04,86.2 124.68,85.85 U400.BL27
N20937188: length 3
  TOP w0.102: R5400.2 48.71,69.01 Q5400.3 ; R5400.2 48.85,69.6 48.86,69.61 R5401.1 ; R5400.2 49.48,69.14 v2(49.56,69.07)
N20937236: length 3.4
  TOP w0.102: v2(48.71,65.44) Q5400.4 48.71,66.93 48.86,67.08 49.82,67.08 50.01,66.89 Q5400.6
N23161371: length 3.9
  TOP w0.102: 169.01,65.42 169.01,66.13 168.81,66.34 Q5100.6 167.19,66.34 R5109.1 v2(166.94,65.27)
  TOP w0.114: R5108.2 169.01,65.42
N23161400: length 3.7
  TOP w0.102: 167.23,66.99 167.06,66.99 R5109.2 ; v2(166.57,67.73) 166.57,67.24 R5109.2 ; R5109.2 166.58,66.51
  TOP w0.114: 167.23,66.99 Q5100.5 ; C5104.1 166.58,66.51
N23590926: length 3.3
  TOP w0.102: Q404.2 74.56,78.96 R552.1 R551.2 v2(75.57,77.94)
N23590933: length 10.2
  TOP w0.102: Q404.3 72.65,75.78 v2(72.29,75.41) 71.75,74.88 71.75,74.41 72.02,74.15 73.3,74.15 R549.2 74.29,72.89 73.77,72.37 73.77,71.33 74.86,70.24 Q403.2
N25107404: length 3.1
  TOP w0.102: Q7501.2 48.82,60.38 v2(49.2,60.76) 49.63,60.76 R7509.1 R7508.2
N25257440: length 4.3
  TOP w0.102: PQ8005.6 200.98,93.11 201.35,93.48 201.35,93.99 201.78,94.41 PQ8005.3 202.26,94.41 202.83,94.98 202.83,95.28 203.03,95.48 PR8008.2
N25318825: length 6.9
  TOP w0.102: PR8006.1 205.05,96.45 v2(205.31,96.72) 204.78,97.25 204.78,98.15 205.04,98.41 206.44,98.41 207.78,97.07 PQ8004.3
N25319146: length 4.1
  TOP w0.102: v2(202.13,96.92) 202.04,96.83 PQ8002.2 202.79,95.86 PR8006.2 204.35,97.42 PR8001.2
N25319276: length 19.3
  TOP w0.508: v2(204.44,101.05) 204.55,100.94 PR8000.2 PC8002.2 203.86,99.4 203.33,98.86 201.32,98.86 200.7,98.24 200.7,97.57 PQ8002.3
  BOTTOM w0.508: v2(213.76,104.77) 213.41,104.77 212.73,104.09 208.7,104.09 208.42,104.37 206.79,104.37 204.44,102.02 v2(204.44,101.05)
N25580644: length 7.2
  BOTTOM w0.508: 178.39,16.03 177.48,16.03 177.12,15.67 175.86,15.67 175.05,16.48 175.05,16.77 175.05,17.27 173.83,18.5 F5200.1
  vias: v2(178.39,15.4) v2(179.03,15.4) v2(183.27,15.3) v2(183.83,15.6)
N26734829: length 5.2
  TOP w0.102: v2(67.8,22.64) 68.45,21.98 R5302.1 68.45,21.53 68.64,21.34 70.06,21.34 70.43,21.71 R5301.2 70.43,22.04 70.02,22.45 69.9,22.45 69.73,22.62 U5300.3
N27228992: length 3.7
  BOTTOM w0.508: PCN8000.8 225.4,107.2 225.78,106.83 226.8,106.83 PR8004.1
N27229026: length 2.5
  BOTTOM w0.508: PCN8000.7 224.15,107.4 224.94,106.61 PR8002.2
N27235971: length 9
  BOTTOM w0.102: PR8520.2 134.51,25.2 135,24.71 135.91,24.71 136.11,24.91 PR8519.2 136.65,25.13 137.73,24.05 v2(137.73,23.7) 138.11,23.32 138.11,22.78 137.94,22.61 136.36,22.61 136.13,22.84 PQ8503.3
N27239944: length 1.1
  BOTTOM w0.203: PU8700.3 147.33,16.67 147.38,16.62 PR8709.1
N27239982: length 5.9
  TOP w0.102: PD8700.1 171.16,58.76 170.76,58.35 169.89,58.35 v2(168.97,57.42) PR8719.2
N27241425: length 2.8
  BOTTOM w0.102: v2(133.05,121.25) 133.17,121.36 PR9202.1
  BOTTOM w0.508: PR9202.1 133.63,122.69 134.7,122.69 PC9209.1
N27241434: length 2.5
  TOP w0.102: v2(137.15,128.06) PR9204.1
  TOP w0.508: PR9204.1 136.24,126.98 PC9210.2
N27265621:
  vias: v2(169.86,34)
N27265632:
  vias: v2(165.98,33.29)
N27265640: length 4
  TOP w0.102: v2(170.87,28.81) 170.68,28.62 PR9504.2
  TOP w0.178: PU9501.5 168.89,30.01 168.94,29.95 PC9517.1 169.24,29.12 169.74,28.62 PR9504.2
N27265648: length 3.1
  TOP w0.102: PC9518.1 167.52,34.7 v2(167.52,35.83)
  TOP w0.178: PC9518.1 168,33.56 168.09,33.48 PU9501.12
N27265649: length 2.7
  TOP w0.102: PC9519.1 169.83,35.02 v2(169.83,35.33)
  TOP w0.178: PC9519.1 169.02,34.02 168.89,33.88 PU9501.10
N27265652: length 5.8
  TOP w0.102: v2(166.57,27.8) 166.42,27.94 166.42,28.84 PC9520.1
  TOP w0.178: PU9501.3 168.09,30.43 167.06,29.4 PC9520.1 PR9507.1 165.48,29.4 165.46,29.38 PR9508.1
N27265672:
  vias: v2(185,28.93)
N27265684:
  vias: v2(188.83,29.24)
N27265691: length 7.6
  TOP w0.102: PU9500.5 187.31,32.85 187.64,33.18 187.64,33.47 187.71,33.54 187.71,33.61 187.71,34.22 187.64,34.29 187.64,35.24 v2(187.23,35.65) 187.01,35.87 184.94,35.87 PC9514.1 PR9505.2
N27265699: length 1.8
  TOP w0.102: PU9500.12 188.11,28.74 PC9515.1
N27265700: length 3.2
  TOP w0.102: PU9500.10 187.31,29.6 186.65,28.94 PC9516.1 v2(185.79,27.6)
N27265702: length 4
  TOP w0.102: v2(190.89,33.87) PR9506.1 189.84,34.06 PC9521.1 189.03,33.65 188.11,32.74 PU9500.3
N27267900: length 14.1
  BOTTOM w0.102: PU8100.2 6.43,114 5.88,114.56 4.17,114.56 3.95,114.33 3.95,113.74 PC8100.1 ; PC8100.1 3.7,113.15 4.12,112.73 PU8100.6 ; PC8100.1 PR8109.2 ; v2(2.37,112.18) PR8109.2 ; PR8109.2 3.89,111.65 3.89,110.95 4.14,110.71 PR8107.2
N27267906:
  vias: v2(13.71,110.82)
N27267915: length 4.1
  BOTTOM w0.102: PU8100.3 11.59,112.73 v2(11.77,112.91) 12.14,113.28 PR8111.2 12.14,114.14 12.31,114.3 12.78,114.3 12.92,114.44 PR8117.1
N27267917: length 238.1
  IN2 w0.114: v2(163.08,19.23) 156.53,19.23 156.43,19.34 155.47,19.34 154.84,18.71 149.64,18.71 149.1,19.25 143.97,19.25 140.85,22.37 139.73,22.37 138.14,23.95 136.24,23.95 135.52,24.67 135.39,24.67 134.74,25.33 134.74,27.84 133.9,28.68 132.31,28.68 130.48,30.5 130.48,30.77 129.53,31.72 128.05,31.72 126.39,33.38 122.21,33.38 118.17,37.43 114.41,37.43 113.9,36.91 108.23,36.91 107.66,37.48 84.67,37.48 83.8,36.61 67.78,36.61 64.66,33.49 62.05,33.49 61.32,34.22 60.61,34.22 59.93,34.91 51.93,34.91 51.45,35.39 49.92,35.39 45.7,39.61 45.7,43.18 49.4,46.88 49.4,48.74 49.06,49.08 49.06,53.74 49.97,54.65 52.67,54.65 v2(53.51,55.49)
  BOTTOM w0.102: v2(53.51,55.49) 52.31,56.69 52.31,57.97 50.74,59.54 50.74,60.59 50.3,61.03 50.3,62.53 49.74,63.09 49.74,70.83 42.31,78.26 38.06,78.26 37.19,77.4 32.37,77.4 30.06,79.71 30.06,82.12 18.73,93.45 18.73,97.9 11.13,105.49 11.13,105.64 9.14,107.64 PR8110.1 8.35,108.42 PC8102.2 PR8116.1 7.16,108.42 6.61,108.97 PR8112.2 ; v2(163.08,19.23) 163.07,19.24 PR8103.2 162.84,20.15 161.88,20.15 161.76,20.27 PR8105.2 161.98,20.63 163.31,20.63 PR8108.1
N27267918: length 6.5
  BOTTOM w0.102: PU8100.5 6,111.46 6.61,110.85 PR8112.1 7.39,109.45 PR8118.1 8.14,108.93 9.94,108.93 v2(10.02,108.85)
N27303100:
  vias: v2(152.47,33.53)
N27303319:
  vias: v2(156.09,33.5)
N27303349: length 4.1
  TOP w0.178: PC9532.1 155.38,29 155.38,29.39 154.97,29.81 PU9502.5
  TOP w0.254: PC9532.1 156.39,27.99 PR9514.2 156.74,28.12 157.39,28.12 v2(157.46,28.2)
N27303375: length 3.7
  TOP w0.102: v2(152.72,27.5) PR9515.1
  TOP w0.178: PR9515.1 153.14,28.33 153.59,28.77 PC9535.1 153.68,29.38 154.17,29.87 PU9502.3
N27329196: length 3.4
  TOP w0.102: v2(135.08,109.62) 134.77,109.94 PQ9602.2
  TOP w0.254: PR9605.1 133,111.44 133.92,110.52 PQ9602.2
N27329277: length 4.3
  TOP w0.102: PR9614.1 119.64,58.63 120.05,59.03 PQ9604.2 121.65,59.03 121.88,58.81 PR9611.1
N27329284: length 8.9
  TOP w0.102: PU9602.2 112.73,60.05 112.86,59.92 112.86,58.71 113.17,58.4 113.89,58.4 v2(114.25,58.75) 114.44,58.94 PR9610.1 115.01,59.06 116.14,59.06 PR9613.1 PR9614.2
N27329341: length 8.2
  TOP w0.102: PU9602.1 113.38,62.18 112.94,62.62 109.48,62.62 109.04,62.17 v2(109.04,61.64) 109.1,61.58 PR9609.1 PR9608.1
N27332808: length 2.3
  TOP w0.102: v2(139.75,112.45) PR9601.2 138.79,112.32 PQ9600.2
N27334099: length 4.9
  TOP w0.102: v2(178.71,110.68) 178.71,111.37 PQ9601.6 179.34,111.52 179.43,111.61 179.43,112.07 179.33,112.17 PQ9601.5 178.24,112.17 178.12,112.29 PR9603.1 PR9602.2
N27339065: length 5.9
  TOP w0.102: PR9606.2 175.07,110.27 174.33,111 174.33,111.28 174.39,111.34 PQ9603.6 175.09,111.34 175.28,111.54 175.28,111.82 175.1,111.99 PQ9603.5 174.07,111.99 173.96,111.88 PR9607.1 172.92,111.88 v2(172.57,112.23)
N27342806: length 12.3
  TOP w0.102: PR9616.1 117.3,59.03 119.7,59.03 120,59.33 120,59.62 120.1,59.72 121.5,59.72 121.75,59.47 PQ9605.5 124.87,59.47 124.95,59.39 124.95,58.88 124.89,58.82 PQ9605.6 ; PR9616.1 v2(116.61,60.63) ; PR9616.1 116.11,59.72 116.05,59.66 PR9615.2
N27342823: length 4.6
  TOP w0.102: v2(126.32,60.77) 126.01,60.46 PQ9605.3 125.49,60.12 125,60.61 123.18,60.61 122.59,60.02 PR9612.2
N27347933: length 2.2
  BOTTOM w0.102: PR8113.1 v2(17.37,111.42) 17.11,111.42 PD8100.2
N27347950: length 2.2
  BOTTOM w0.102: PR8114.1 v2(17.37,108.64) 17.08,108.64 PD8100.1
N27365118: length 2.5
  TOP w0.102: PR9600.2 181.09,113.89 181.39,113.59 v2(181.39,113.37) 181.39,112.98 181.23,112.82 PQ9601.3
N27365824: length 4
  TOP w0.102: PQ9603.3 176.71,112.64 176.89,112.83 176.89,113.4 PR9604.2 176.05,114.25 174.81,114.25 v2(174.51,113.94)
N27381080: length 4.1
  TOP w0.102: v2(198.21,31.41) 198.98,32.18 PR8500.2 199.37,31.8 PC8501.2 198.87,30.55 198.87,30.41 PR8502.2
N27585860: length 2.3
  TOP w0.102: PC8806.1 PR8824.2 41.39,109.14 v2(41.39,109.1)
N27585915: length 2.3
  TOP w0.102: v2(33.37,107.14) 33.93,107.69 PC8812.1 PR8849.2
N27671965: length 6.7
  TOP w0.102: PR8504.2 v2(159.77,9.43)
  TOP w0.508: PR8504.2 159.49,10.24 159.1,10.63 PR8503.1 PR8505.1 157.29,10.95 PC8500.2 157.29,12.43 157.46,12.6 PQ8500.1
N27672021: length 4.3
  TOP w0.102: PR8505.2 157.24,9.48 PR8501.2 PR8506.2 155.79,10.98 v2(154.66,10.98)
N27672045: length 6.8
  TOP w0.102: v2(150.34,12.6) PQ8502.3 152.54,11.56 152.54,11.08 153.7,9.91 PQ8501.1 155.02,9.91 PR8506.1
N27672058: length 3
  TOP w0.102: PR8501.1 154.66,8.59 PQ8501.2 154.36,7.83 v2(154.82,7.37)
N27673930: length 2.6
  TOP w0.102: PQ8702.3 PR8712.1 162.53,8.24 v2(162.01,7.73)
N30957248:
  vias: v2(32.36,125.3)
N30974767: length 11.7
  TOP w0.102: 133.9,60.55 133.69,60.76 132.44,60.76 132.09,61.12 Q407.3
  TOP w0.114: Q408.1 v2(137.04,58.5) 137.04,57.83 136.25,57.04 134.37,57.04 133.9,57.51 133.9,60.55
N30974776: length 2.4
  TOP w0.102: Q407.1 133.1,59.11 132.98,58.98 ; v2(133.19,57.67) 132.82,58.04 R584.2
  TOP w0.114: R584.2 132.82,58.83 132.98,58.98
N31445230:
  vias: v2(224.06,66.08)
N31510805: length 2.3
  TOP w0.102: U5800.35 208.84,109.98 208.95,110.09 209.23,110.09 v2(209.41,110.27)
  BOTTOM w0.102: R5806.2 209.63,110.04 v2(209.41,110.27)
N31547751: length 2.5
  TOP w0.102: v2(191.03,115.15) 191.03,114.83 C6103.1
  TOP w0.254: U6100.33 190.36,113.66 190.5,113.8 C6103.1
N31652171: length 1.1
  TOP w0.102: PR8834.2 PC8808.1
N31667829:
  vias: v2(160.03,31.58) v2(160.33,30.94) v2(160.76,31.5) v2(160.84,29.73) v2(161.15,30.94) v2(161.5,31.55)
N31667845: length 1.3
  BOTTOM w0.102: PC9309.1 163.95,27.16 v2(163.95,28.28)
N31667871: length 1.2
  TOP w0.102: v2(157.62,22.56) 157.68,22.56 PC9314.2
N31839995: length 4
  TOP w0.102: R5005.2 41.39,55.41 v2(40.66,55.41)
  BOTTOM w0.102: CN5000.39 42.14,54.72 41.44,55.41 v2(40.66,55.41)
N31840009: length 5.3
  TOP w0.102: v2(39.42,55.79) 39.69,55.52 R5000.1 40.19,54.67 40.29,54.77 v2(40.7,54.77)
  BOTTOM w0.102: CN5000.38 42.18,54.22 41.64,54.77 v2(40.7,54.77)
N31840035: length 4
  TOP w0.102: v2(40.64,54.02) 40.29,53.68 R5001.1
  BOTTOM w0.102: v2(40.64,54.02) 41.63,54.02 41.94,53.72 CN5000.37
N31840061: length 4.3
  TOP w0.102: v2(40.65,53.18) 41.1,53.63 41.1,53.96 R5006.2
  BOTTOM w0.102: CN5000.36 40.69,53.22 v2(40.65,53.18)
N31840087: length 4.8
  TOP w0.102: v2(40.18,52.72) 40.84,52.72 R5002.2
  BOTTOM w0.102: CN5000.35 40.18,52.72 v2(40.18,52.72)
N31840108: length 3.7
  TOP w0.102: R5007.2 40.75,52.38 v2(40.67,52.3)
  BOTTOM w0.102: v2(40.67,52.3) 42.73,52.3 42.81,52.22 CN5000.34
N31840152: length 5.6
  TOP w0.102: R5003.2 40.82,51.42 v2(40.68,51.27) 39.84,51.27 v2(39.12,52)
  BOTTOM w0.102: CN5000.32 41.83,51.22 41.73,51.32 40.72,51.32 v2(40.68,51.27)
N31840183: length 4.9
  TOP w0.102: v2(39.61,50.76) 39.72,50.64 v2(40.65,50.64) 40.84,50.45 R5004.2
  BOTTOM w0.102: v2(40.65,50.64) 40.83,50.82 41.73,50.82 41.83,50.72 CN5000.31
N31840189: length 5
  TOP w0.102: R5008.1 39.05,50.01 v2(40.67,50.01)
  BOTTOM w0.102: CN5000.30 40.88,50.22 v2(40.67,50.01)
N32130761: length 3.5
  BOTTOM w0.102: CN4201.9 215.74,57.84 216.64,57.84 217.04,57.45 v2(217.04,56.94) 217.25,56.94 R4223.2
N32484985: length 6.6
  TOP w0.102: PR8014.2 198.91,94.66 197.69,93.44 v2(197.69,92.8) 197.69,92.53 196.79,91.63 PR8015.1 196.71,91.94 PQ8010.2
N32484987: length 5
  TOP w0.102: PR8015.2 195.65,90.85 PR8021.1 193.52,90.49 193.39,90.36 v2(192.68,90.36) PR8020.2
N32485009: length 15.3
  TOP w0.102: PQ8010.3 197.72,94.34 197.54,94.16 196.17,94.16 192.85,90.84 191.68,90.84 v2(191.34,91.18) 191.19,91.03 191.19,86.96 PR8019.1 191.85,86.8 192.54,86.8 192.95,87.2 PQ8011.2
N32485094: length 27.5
  TOP w0.508: v2(208.68,102.37) 208.01,101.7 207.07,101.7 206.05,100.68 206.05,99.37 207.56,97.87 208.4,97.87 208.77,97.5 208.77,96.04 208.48,95.75 PR8005.1 207.7,94.72 PC8003.2 207.15,93.84 PC8004.2 206.49,93.28 206.27,93.07 PQ8003.3
  BOTTOM w0.508: v2(221.07,102.55) 220.38,101.86 213.49,101.86 212.98,102.37 v2(208.68,102.37)
N32485347: length 9.3
  TOP w0.102: PR8003.1 205.52,91.39 204.78,92.13 204.78,93.88 204.53,94.14 204.53,95.31 204.35,95.48 PR8008.1 203.6,94.95 203.13,94.95 202.93,94.75 202.93,94.26 203.11,94.09 PQ8003.2 203.61,93.31 v2(203.37,93.06)
N32890326: length 3.1
  BOTTOM w0.102: CN4300.12 205.27,8.09 205.23,8.13 204.67,8.13 R4300.1 203.76,7.76 v2(203.49,8.03)
N33445262: length 1.5
  TOP w0.102: U4000.25 193.53,64.37 193.02,63.86 TP4000.1
N33535539: length 6.3
  TOP w0.102: v2(203.1,76.37) 203.23,76.49 v2(203.81,76.49) 204.28,76.49 R4202.1
  BOTTOM w0.102: v2(203.81,76.49) 203.95,76.49 205.23,75.21 205.23,73.27 205.45,73.06 CN4200.69
N33823362: length 2.1
  TOP w0.102: R5801.2 208.9,106.11 208.9,107.45 208.76,107.58 U5800.29
N34650123: length 31.4
  TOP w0.102: v2(146.03,94.16) 146.46,93.73 150.7,93.73 150.8,93.64 151.35,93.64 151.35,93.64 151.97,93.64 152.12,93.5 152.54,93.5 152.55,93.48 153.32,93.48 v2(153.55,93.25) 153.83,92.97 155.94,92.97 156.56,92.35 157.68,92.35 158.05,92.72 158.96,92.72 160.33,91.34 161.93,91.34 162.17,91.11 167.89,91.11 168.18,90.82 169.43,90.82 169.94,91.33 171.22,91.33 171.45,91.1 171.45,90.56 170.77,89.88 170.77,88.75 170.42,88.39 Q4105.2
  BOTTOM w0.114: R4106.1 145.6,94.16 146.03,94.16 v2(146.03,94.16)
N34650132: length 6.3
  TOP w0.102: R4108.2 R4111.1 166.96,82.66 v2(167.2,82.89) 167.37,83.06 Q4103.2 167.88,84.38 167.88,85.25 168.21,85.58 168.92,85.58 Q4105.3
N34650897: length 3.7
  TOP w0.102: Q4000.3 198.45,60.57 198.28,60.41 198.28,59.44 198.11,59.27 Q4000.6 196.88,59.27 v2(196.61,59.54)
N36049795: length 5
  BOTTOM w0.102: R4113.2 170.06,95.2 170.06,93.5 169.83,93.27 169.83,91.57 169.95,91.46 CN4100.38
N36049798: length 5.4
  BOTTOM w0.102: R4114.2 171.17,95.3 170.26,94.39 170.26,93.38 170.14,93.25 170.14,92.13 170.45,91.82 CN4100.40
N36049801: length 4
  BOTTOM w0.102: v2(170.69,94.05) 170.92,93.82 170.92,92.81 R4115.2 170.95,91.92 CN4100.42
N36294800: length 3
  BOTTOM w0.102: v2(202.8,81.97) 202.64,81.81 C4236.2 201.91,81.35 202.2,81.06 CN4200.56
N36294820: length 3.2
  BOTTOM w0.102: CN4200.58 202.7,80.82 C4237.2 204.48,81.81 v2(204.55,81.74)
N36756780: length 1.2
  BOTTOM w0.102: PQ8703.3 v2(152.11,16.73)
N37057994:
  vias: v2(135.22,109.66)
N37096665: length 2.3
  TOP w0.102: PQ8012.3 204.23,85.82 204.5,85.55 PR8016.1 204.6,85.81 v2(204.6,86.44)
N37096667: length 27.8
  TOP w0.508: v2(215.34,95.23) 215.76,95.23 216.11,95.58 PQ8006.4 ; v2(213.13,82.33) 213.02,82.21 211.78,82.21 210.22,83.77 201.94,83.77 201.91,83.75 201.87,83.79 PR8023.2
  IN1 w0.508: v2(215.34,95.23) 214.85,94.74 214.85,86.22 214.08,85.45 214.08,84.87 213.62,84.41 213.62,82.82 v2(213.13,82.33)
N37096688: length 7.2
  TOP w0.102: PR8025.1 204.62,84.18 203.01,84.18 202.67,84.51 202.67,84.99 202.5,85.17 PQ8012.5 ; PR8025.1 204.85,84.82 204.5,85.17 PQ8012.2 ; PR8025.1 205.45,85.01 v2(206.5,85.01)
N37096692: length 10.9
  TOP w0.102: PQ8009.2 196.99,87.58 196.81,87.41 196.32,87.41 196.16,87.25 PR8018.2 196.16,86.62 195.44,85.89 194.86,85.89 194.45,85.48 PD8001.2 194.18,84.33 v2(196.41,84.33) 197.34,84.33 PQ8008.2
N37096694: length 2
  TOP w0.102: PQ8013.3 204.39,88.36 204.43,88.4 PR8017.1 v2(204.85,89.25)
N37096728: length 4.7
  TOP w0.102: PR8026.1 204.57,87.71 PQ8013.2 202.88,87.71 ; PQ8013.5 202.88,87.71 ; 202.88,87.71 202.88,88.57 v2(203.56,89.25)
N37096732: length 25.5
  TOP w0.254: PR8024.2 201.15,87.06 PQ8013.6
  TOP w0.381: PR8024.2 200.56,87.89 201.14,87.89 v2(201.2,87.95)
  TOP w0.508: PQ8007.4 214.69,98.29 214.95,98.29 v2(214.96,98.3)
  BOTTOM w0.508: v2(201.2,87.95) 202.99,89.74 209.42,89.74 209.6,89.92 211.59,89.92 212.02,90.35 212.02,91.88 214.46,94.32 214.46,95.6 213.72,96.34 213.72,97.57 214.46,98.3 v2(214.96,98.3)
N37096738: length 3.4
  TOP w0.102: PQ8013.4 201.64,88.36 201.31,88.69 v2(200.82,88.69) 200.48,88.69 200.08,88.3 PQ8009.1
N37096862: length 3.2
  TOP w0.102: PQ8012.4 v2(201.13,85.82) 200.86,85.82 PQ8008.1
N37277040: length 3.1
  TOP w0.102: U4701.A6 200.87,52.17 200.83,52.17 200.79,52.14 200.48,52.14 200.48,52.13 200.09,52.13 199.91,51.95 198.74,51.95 198.71,51.92 C4708.2
N37519775: length 2
  TOP w0.102: U6100.20 191.36,106.24 192.24,105.36 TP6105.1
N37543651: length 2.8
  TOP w0.102: R3509.2 215.38,85.49 v2(215.38,86.49) 214.97,86.49 214.63,86.14 214.25,86.14 214.17,86.22 U3501.16
N37586765: length 6.8
  TOP w0.102: C3504.1 216.18,82.65 v2(216.24,82.71) 216.24,83.33 215.88,83.7 215.88,87.36 215.62,87.62 U3501.17
N37868269: length 9.5
  BOTTOM w0.079: 95,103.76 95.21,103.76 95.61,103.36 96.17,103.36 96.36,103.17 96.36,102.21 U400.E1
  BOTTOM w0.102: R606.1 93.93,106.56 v2(93.48,106.11) 93.48,105.11 94.83,103.76 95,103.76
N38095593: length 7.7
  TOP w0.102: v2(207.52,23.43) 207.25,23.16 R4307.2
  BOTTOM w0.102: v2(207.52,23.43) 207.73,23.22 209.99,23.22 210.61,23.84 CN4300.75
N38167474:
  vias: v2(25.81,125.5) v2(26.36,125.83) v2(40.8,123.93) v2(41.44,123.93)
N38256574: length 2.4
  TOP w0.102: v2(44.16,35.34) 43.94,35.56 R7611.2 43.81,36.28 D7600.2
N38256936:
  vias: v2(41.18,33.36)
N38259073: length 7.7
  TOP w0.102: R7615.2 45.34,22.31 v2(45.44,22.41) 45.44,23.33 44.95,23.82 44.49,23.82 44.28,24.03 44.28,24.73 44.23,24.78 44.23,25.73 44.33,25.83 44.33,26.65 43.82,27.16 U7600.26
N38478578: length 27.8
  TOP w0.102: R514.2 155.93,78.31 153.39,78.31 153.39,78.3 v2(152.83,78.3) 152.56,78.03 150.34,78.03 148.01,80.36 144.76,80.36 143.4,79 140.88,79 140.56,79.33 138.69,79.33 137.75,80.27 137.75,81.29 136.97,82.08 136.97,82.38 v2(136.1,83.24)
  BOTTOM w0.079: U400.CR32 138.41,82.57 138.38,82.59 U400.CP32 137.93,82.4 136.73,82.4 136.47,82.66 136.47,82.87 v2(136.1,83.24)
N38488617: length 4
  TOP w0.102: R7502.2 52.16,58.07 52.31,58.22 53.2,58.22 53.58,58.6 U7500.6 ; R7502.2 51.71,57.29 Q7500A.1 ; R7502.2 51.78,57.74 v2(51.5,58.02)
N38488687: length 3.1
  TOP w0.102: v2(54.84,58.5) 54.57,58.78 U7500.7 53.98,58.33 54.34,57.97 R7503.2 54.34,57.33 54.12,57.11 Q7500B.1
N38488730: length 3.3
  TOP w0.102: R7500.1 52,60.82 51.89,60.82 v2(51.61,60.55) 52.12,60.03 53.05,60.03 53.18,59.91 U7500.3
N38512591: length 2.7
  TOP w0.102: v2(118.44,41.77) 118.65,41.98 118.65,42.99 C2828.2 118.58,43.5 R2818.2
N38515705: length 2
  TOP w0.102: v2(123.21,42.23) 123.15,42.18 R2842.1 122.33,42.62 122.34,42.63 C2857.2
N38531847: length 2.1
  TOP w0.102: Q5004.6 43.56,54.85 43.35,55.07 v2(43.07,55.07) 42.6,55.53 R5014.1
N38538012: length 2.6
  TOP w0.102: CN7700.41 30.76,120.61 31.15,121 R7717.1
N38538131: length 4
  TOP w0.102: R7720.2 31.93,121.64 31.73,121.44 31.73,120.86 31.55,120.67 31.11,120.67 30.96,120.53 30.96,120.2 31.26,119.9 CN7700.39
