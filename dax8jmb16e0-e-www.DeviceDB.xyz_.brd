# Allegro board dax8jmb16e0-e-www.DeviceDB.xyz_.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3V_WLAN_C: length 1
  TOP w0.102: R4142.1 179.91,93.57 v2(179.96,93.62)
+3V_WLAN_EN: length 14.5
  TOP w0.102: v2(179.51,86.14) 178.49,87.15 178.49,87.51 178.19,87.81 177.27,87.81 177.05,88.04 176.69,88.04 176.47,88.26 Q4109.6 ; U4100.4 183.16,90.29 182.85,89.99 R4139.1 182.85,88.81 182.99,88.68 183.55,88.68 183.75,88.47 183.75,87.49 182.5,86.24 v2(181.62,86.24)
  IN1 w0.114: v2(181.62,86.24) 179.61,86.24 v2(179.51,86.14)
+3V_WLAN_P:
  vias: v2(160.57,91.76) v2(161.23,91.76) v2(161.87,91.76) v2(178.64,91.67) v2(179.26,91.82)
+3V_WWAN_P: length 11.1
  TOP w0.305: v2(194.38,73.69) 193.78,73.1 R4214.1
  IN2 w0.381: v2(194.38,73.69) 194.36,73.72 194.36,75.87 194.75,76.26 194.75,79.84 193.81,80.78 193.81,81.57 v2(194.42,82.18)
  vias: v2(194.37,83.5) v2(194.42,82.81) v2(195.05,82.86) v2(204.4,83.09) v2(204.4,82.38) v2(206.74,82.12) v2(207.15,81.62) v2(207.63,81.11)
+3VLANVCC: length 112.9
  TOP w0.102: R4008.1 227.56,92.62 R4007.1 228.33,93.39 228.33,94.9 v2(228.18,95.05)
  TOP w0.381: C4016.1 198.02,72.36 198.23,72.57 201.28,72.57 202.61,73.91 202.61,74.79 203.48,75.66 206.47,75.66 206.63,75.82 v2(206.64,75.82) ; v2(196.68,60.21) 196.86,60.21 197.15,59.92 Q4000.5
  TOP w0.508: v2(187.23,68.13) 187.43,68.33 187.43,69.14 187.12,69.45 186.72,69.45 186.02,70.15 R4003.2 ; v2(163.6,51.31) 163.6,50.55 164.11,50.04 169.73,50.04 177.3,57.61 177.3,58.92 177.95,59.57 177.95,60.58 181.29,63.91 184.61,63.91 185.05,63.47 185.7,63.47 186.02,63.79 186.02,64.87 186.49,65.34 C4021.1 ; PR9500.1 164.43,35.44 v2(163.64,35.44)
  IN1 w0.381: v2(229.92,84.31) 230.33,84.31 230.57,84.07 230.57,82.76 229.94,82.13 224.93,82.13 v2(224.16,81.36)
  BOTTOM w0.203: v2(195.82,70.63) 196.12,70.32 C4018.1
  BOTTOM w0.381: v2(229.92,84.31) 229.74,84.31 229.33,84.72 229.33,87.3 227.73,88.9 227.73,92.3 228.18,92.74 v2(228.18,95.05) ; v2(206.64,75.82) 207.94,75.82 208.26,75.49 209.03,75.49 210.17,76.63 210.17,76.89 210.82,77.54 220.25,77.54 224.08,81.36 v2(224.16,81.36)
  BOTTOM w0.508: v2(163.64,35.44) 163.64,36.2 163.34,36.49 163.34,39.32 162.73,39.93 162.73,41.47 162.15,42.05 162.15,47.53 162.77,48.15 162.77,49.49 163.6,50.32 v2(163.6,51.31)
  vias: v2(189.06,65.95) v2(189.67,65.73) v2(191.47,70.16)
+3VLCD_CON: length 2.6
  BOTTOM w0.305: CN3400.24 31.65,131.73 v2(31.23,131.32) ; v2(32.17,131.31) 32.15,131.33 CN3400.23
  vias: v2(29.83,125.28) v2(30.46,125.28) v2(31.02,130.73) v2(31.1,125.28) v2(31.75,130.83) v2(31.73,125.53)
+3VPCU: length 936.9
  TOP w0.203: v2(205.77,64.8) 204.91,64.8 204.58,64.47 204.58,64.15 203.72,63.3 v2(203.72,63.22)
  TOP w0.254: v2(214.16,50.22) 213.98,50.4 R4743.2 ; R4250.1 205.88,64.7 v2(205.77,64.8) ; v2(166.33,81.62) 166,81.62 165.34,80.96 162.98,80.96 162.01,79.99 v2(162.01,79.43) ; R4137.2 175.1,85.43 v2(174.3,86.22) ; v2(180.14,59.51) 180.44,59.51 181.19,60.25 U4700.5 ; v2(168.69,84.87) 168.74,84.82 169.93,84.82 170.62,85.5 170.62,85.94 171.17,86.49 171.6,86.49 172.83,87.71 v2(172.83,87.97) ; 40.11,83.75 PR8126.1 36.69,83.36 37.57,82.48 PR8125.1 ; U4202.5 204.99,71.42 206.84,69.56 206.84,65.93 R4249.1 206.85,65.65 v2(206.85,65.13) ; R456.1 131.55,71.19 131.55,70.49 131.96,70.09 131.96,68.56 134.4,66.11 v2(134.76,66.11) ; R4770.1 210.04,61.27 ; R4744.1 211.76,54.67 v2(211.87,54.56) 212.15,54.56 R4728.2 ; R4136.1 R4141.1 178.84,85.76 178.82,85.77 v2(178.82,86.14) ; R4740.2 196.43,50.09 196.4,50.07 195.76,50.07 194.87,50.96 190.9,50.96 v2(190.78,51.08) ; v2(190.39,51.9) 190.62,51.9 190.75,51.77 191.08,51.77 191.22,51.62 195.28,51.62 R4745.2 196.68,50.85 R4752.1 ; R4732.2 185.7,58.69 185.41,58.98 v2(185.25,58.98) 185.63,59.36 R4733.2 ; R4753.1 198.21,54.98 v2(198.71,54.98)
  TOP w0.305: v2(41.28,85.27) 40.11,84.11 40.11,80.83 40.62,80.32 41.77,80.32 42.28,79.8 PR8121.2 42.28,78.78 PR8122.2 ; R4760.2 192.55,55.15 192.27,55.42 192.27,56.2 192.64,56.57 193.4,56.57 193.66,56.32 194.04,56.32 194.67,56.95 ; R5016.10 38.57,43.26 38.82,43.01 40.9,43.01 41.11,42.8 R5016.5
  TOP w0.381: v2(49.16,59.87) 49.21,59.82 50.55,59.82 50.79,60.06 R7509.2 ; v2(91.22,28.12) 91.67,28.57 PR8512.2 ; v2(19.58,102.05) 17.51,104.12 17.51,111.56 16.23,112.84 R3424.2 ; v2(45.37,60.43) 45.42,60.38 Q7501.5 ; C465.2 C450.2 127.71,88.62 127.21,88.11 v1(127.21,88.02) ; R6109.2 189.37,102.99 188.77,102.99 v2(188.76,102.98)
  TOP w0.508: 101.68,30.03 102.14,30.49 102.14,31.81 v2(102.37,32.03) ; 101.68,30.03 97.19,30.03 96.34,29.17 v2(96.34,28.1) ; 101.68,30.03 104.45,27.26 107.13,27.26 v2(108.39,26) ; v2(215.78,6.43) 215.96,6.61 R3624.1 ; v2(134.21,14.25) 134.21,14.55 134.6,14.94 136.56,14.94 137.02,14.48 137.02,14.02 138.27,12.77 143.58,12.77 ; v2(187.58,47.18) 187.9,46.87 191,46.87 192.16,45.7 L4700.2 193.29,46.49 v2(194.32,46.49) ; v2(186.03,7.67) 186.03,9.78 184.51,11.31 175.69,11.31 171.73,7.35 170.95,7.35 PQ8505.1 169.83,7.39 v2(169.34,7.39) ; v2(165.72,7.9) 165.75,7.93 PQ8506.1 ; v2(119.66,24.59) 118.7,23.63 118.7,22.16 119.06,21.8 120.88,21.8 121.22,22.14 v2(121.22,22.41) ; PR8715.1 158.72,60.13 157.73,59.14 v2(155.76,59.14) ; PQ8011.1 194.98,87.66 195.83,88.51 195.83,89.15 197.09,90.4 197.09,91.29 197.44,91.65 198.18,91.65 198.74,92.21 PQ8010.1 198.74,93.6 v2(199.27,94.14) ; v2(130.93,18.73) 130.93,20.04 129.42,21.54 129.42,26.03 PR8226.2 ; 143.58,12.77 145.57,14.77 C7826.2 156.32,14.77 156.64,15.09 158.05,15.09 159.16,13.98 159.49,13.98 159.94,14.42 161.5,14.42 162.08,13.84 v2(162.08,13.81) 165.5,13.81 167.33,11.98 PC8503.2 166.84,11.33 v2(166.51,11) ; 143.58,12.77 146.22,10.13 v2(148.28,10.13) ; v2(44.56,92.18) 44.46,92.28 PR8805.1 PC8802.1 PR8825.1 ; v2(28.99,94.3) 35.77,94.3 v2(36.19,93.88) ; v2(187.75,104.1) 187.72,104.12 R6103.1 ; v2(201.77,43.61) 202,43.85 206.18,43.85 207.18,44.85 207.18,45.16 207.92,45.9 R4742.2 208.01,46.06 208.7,45.37 214.92,45.37 v2(215.96,46.41) ; R3417.1 40.7,127.28 v2(40.7,127.28) ; v2(216.52,57.28) 216.44,57.36 216.44,58.25 215.84,58.86 215.63,58.86 215.37,59.11 215.37,61.52 214.77,62.13 R4723.1 ; PR8806.1 v2(43.42,92.28)
  IN1 w0.254: v2(172.83,87.97) 172.83,86.76 173.16,86.43 174.1,86.43 v2(174.3,86.22) ; v2(166.33,81.62) 166.47,81.76 166.47,83.27 168.06,84.87 v2(168.69,84.87)
  IN1 w0.381: v2(142.65,93.25) 140.84,93.25 140.42,92.83 139.04,92.83 137.61,94.26 136.14,94.26 136.14,94.26 133.87,94.26 133.49,94.65 130.23,94.65 129.72,94.13 129.72,93.21 129.14,92.64 129.14,90.2 128.68,89.74 127.95,89.74 127.21,89 v1(127.21,88.02)
  IN1 w0.508: v2(108.39,26) 109.93,24.46 109.93,24.09 110.37,23.64 111.63,23.64 112.5,24.52 114.99,24.52 117.32,22.19 118.47,22.19 119,21.66 120.82,21.66 121.22,22.05 v2(121.22,22.41) ; v2(180.64,97.05) 175,97.05 v2(174.91,97.13) ; v2(19.58,102.05) 20.3,101.33 21.96,101.33 v2(28.99,94.3) ; v2(159.24,97.11) 159.2,97.15 158.25,97.15 157.73,97.67 156.99,97.67 156.94,97.72 155.34,97.72 154.91,98.15 153.08,98.15 152.73,98.51 151.06,98.51 149.92,97.36 145.76,97.36 143.75,95.36 v2(143.75,95.1) ; v2(42.15,123.85) 42.15,124.14 42.49,124.48 46.77,124.48 48.21,125.92 51.48,125.92 52.06,126.5 57.09,126.5 57.75,127.16 70.93,127.16 72.32,125.77 v2(73.19,125.77) ; v2(130.93,18.73) 130.93,18.42 130.64,18.13 127.78,18.13 123.11,22.8 123.11,23.02 121.54,24.59 v2(119.66,24.59) ; v2(200.85,7.35) 200.82,7.35 200.34,6.86 187.99,6.86 187.02,7.83 186.2,7.83 v2(186.03,7.67) ; v2(38.34,57.67) 38.34,58.46 39.62,59.74 39.62,61.23 v2(40.03,61.64) 40.03,63.47 40.19,63.63 40.19,66.29 38.93,67.55 38.93,71.87 40.88,73.82 40.88,76.51 41.64,77.28 41.64,81.46 41.28,81.82 v2(41.28,85.27) 41.28,87.23 40.98,87.53 40.98,90.53 41.29,90.84 41.86,90.84 43.31,92.28 v2(43.42,92.28) ; v2(157.24,118.14) 156.5,117.4 155.18,117.4 154.16,116.39 152.76,116.39 152.38,116.77 152.38,117.79 154.54,119.94 155.3,119.94 155.96,120.6 155.96,121.45 155.36,122.05 151.82,122.05 148.65,118.87 147.83,118.87 146.8,117.85 v2(146.8,117.77) 146.4,117.77 145.65,117.02 141.54,117.02 v2(141.18,116.67) v2(139.7,116.67) ; v2(206.85,65.13) 206.53,64.8 v2(205.77,64.8) ; v2(96.34,28.1) 96.31,28.12 v2(91.22,28.12) 91.22,28.16 90.69,28.69 87.13,28.69 86.95,28.51 86.95,28.01 86.46,27.51 81.99,27.51 80.64,28.86 79.51,28.86 78.29,27.64 72.27,27.64 71.99,27.92 69.71,27.92 66.84,25.05 65.56,25.05 63.8,26.81 56.07,26.81 55.24,25.98 50.67,25.98 48.97,24.28 44.51,24.28 44.06,23.83 42.97,23.83 42.41,24.39 42.41,25.91 40.86,27.46 40.86,28.03 42.19,29.36 42.19,32.54 41.54,33.2 41.54,34.17 39.02,36.69 v2(39.02,45.01) ; v2(187.75,104.1) 188.09,104.1 188.76,103.43 v2(188.76,102.98) 192.46,102.98 196.07,99.37 197.93,99.37 v2(198.2,99.65) 198.2,97.69 198.86,97.03 198.86,94.54 v2(199.27,94.14) ; v2(155.76,59.14) 155.76,61.78 v2(151.93,65.61)
  IN2 w0.508: v2(200.85,7.35) 203.49,7.35 204.24,6.59 209.72,6.59 210.29,7.17 210.9,7.17 211.22,6.85 211.45,6.85 211.9,6.39 213.16,6.39 213.75,6.97 215.24,6.97 v2(215.78,6.43) ; v2(28.99,94.3) 28.99,94.75 29.89,95.65 29.89,104.26 30.87,105.24 30.87,106.45 31.42,106.99 31.42,108.32 32.31,109.21 32.31,113.07 v2(34.62,115.37) ; v2(168.21,22.03) 168.21,22.64 164.96,25.89 ; v2(155.44,24.92) 160.79,24.92 161.76,25.89 164.96,25.89 ; v2(44.56,92.18) 44.56,92.98 45.97,94.39 46.34,94.39 47.27,95.32 48.12,95.32 49.9,97.1 v2(49.9,97.64) ; v2(166.73,30.16) 166.73,27.67 164.96,25.89 ; v2(174.91,97.13) 174.79,97.26 174.03,97.26 172.14,99.15 169.95,99.15 169.73,99.38 166.78,99.38 165.86,98.46 161.6,98.46 161.46,98.32 160.45,98.32 v2(159.24,97.11) ; v2(177.83,105.87) 177.85,105.89 184.34,105.89 185.83,104.39 187.45,104.39 v2(187.75,104.1)
  BOTTOM w0.203: v2(139.7,116.67) 139.32,116.29 PC9221.1 139.32,115.68 139.55,115.45 PU9201.3
  BOTTOM w0.254: PU9202.5 141.43,116.91 v2(141.18,116.67) ; v2(136.38,69.97) 136.66,70.25 R453.2 ; R4203.1 190.76,82.58 v2(190.28,82.1) ; U400.BT23 127.54,88.35 v1(127.21,88.02) 126.89,87.7 U400.BR24 ; v2(174.3,86.22) 174.67,85.86 176.11,85.86 176.52,85.45 178.14,85.45 v2(178.82,86.14) ; v2(146.8,117.77) 147.43,117.14 PR9214.1 ; v2(162.01,79.43) 162.01,78.65 161.26,77.9 161.21,77.9 161.14,77.83 160.84,77.83 160.53,77.52 CN7701.20
  BOTTOM w0.381: v2(102.37,32.03) 102.83,32.03 103.11,32.31 103.11,33.33 102.84,33.59 PC8222.2 102.46,33.6 PR8236.2 101.96,34.73 101.72,34.48 PU8201.4 ; v2(216.52,57.28) 216.47,57.23 216.47,56.62 216.76,56.33 216.76,55.79 214.89,53.93 v2(213.84,53.93) ; v2(49.16,59.87) 45.93,59.87 v2(45.37,60.43)
  BOTTOM w0.508: 41.79,117.53 43.06,116.26 43.06,114.61 42.4,113.95 42.4,112.63 43.15,111.88 R5403.2 ; 41.79,117.53 42.58,118.32 42.58,122.13 42.15,122.55 v2(42.15,123.85) 42.15,124.38 40.7,125.83 v2(40.7,127.28) ; 41.79,117.53 39.23,117.53 36.28,117.53 35.92,117.17 35.92,116.34 35.28,115.7 R5404.1 34.91,114.76 34.62,115.05 v2(34.62,115.37) ; 135.42,65.67 136.23,64.85 143.77,64.85 144.05,64.57 151.04,64.57 151.93,65.46 v2(151.93,65.61) ; v2(134.21,14.25) 134.21,16.01 132.26,17.96 132.22,18 131.94,18 ; v2(215.96,46.41) 216.38,45.99 C4717.1 ; v2(38.34,57.67) 37.83,57.16 37.83,45.83 38.64,45.01 v2(39.02,45.01) ; v2(44.56,92.18) 43.52,92.18 v2(43.42,92.28) 42.02,93.68 36.39,93.68 v2(36.19,93.88) ; v2(166.51,11) 166.51,10.42 165.72,9.63 v2(165.72,7.9) 166.7,6.91 168.87,6.91 v2(169.34,7.39) ; PR9306.2 155.57,24.8 v2(155.44,24.92) ; v2(210.83,62.57) 210.83,62.89 210.46,63.26 208.92,63.26 208.11,64.07 208.11,64.24 207.64,64.71 207.27,64.71 v2(206.85,65.13) ; PR9309.2 156.87,18.66 157.44,18.09 159.24,18.09 162.08,15.25 v2(162.08,13.81) ; v2(157.24,118.14) 157.67,117.71 159.38,117.71 159.86,117.23 159.86,117.05 167.2,109.71 174,109.71 v2(177.83,105.87) 177.83,99.86 v2(180.64,97.05) ; v2(148.28,10.13) 148.25,10.16 R3302.1 ; v2(40.03,61.64) 40.03,61.41 41,60.43 v2(45.37,60.43) ; v2(128.38,70.62) 128.1,70.34 128.1,64.92 133.4,59.62 136.08,59.62 137.07,58.63 154.67,58.63 154.77,58.53 155.34,58.53 155.76,58.95 v2(155.76,59.14) 155.86,59.24 158.86,59.24 159.37,59.75 161.02,59.75 164.23,56.54 165.47,56.54 167.78,54.23 167.78,53.21 172.95,48.04 183.46,48.04 183.71,48.29 187.21,48.29 187.64,47.85 187.64,47.24 v2(187.58,47.18) ; v2(168.21,22.03) 168.21,19.94 163.11,14.84 162.7,14.84 ; v2(121.22,22.41) 121.24,22.38 PR8233.2 ; v2(204.36,62.58) v2(203.72,63.22)
  vias: v2(134.87,70.09) v2(165.72,30.16) v2(170.15,30.16) v2(170.8,30.16) v2(178.39,32.06) v2(178.39,31.43) v2(178.39,30.71) v2(179.03,32.06) v2(179.03,31.43) v2(179.03,30.71) v2(179.36,30.13) v2(179.66,32.06) v2(179.66,31.43) v2(179.66,30.71) v2(181.95,92.97) v2(182.59,93.01) v2(182.58,92.31) v2(183.11,92.65) v2(183.12,91.98) v2(183.52,85.91) v2(184.57,84.65) v2(184.64,83.9) v2(184.92,85.51) v2(185.14,84.91) v2(185.15,84.28) v2(185.99,32.16) v2(186.29,34.17) v2(186.29,33.15) v2(186.67,35.34) v2(186.67,34.7) v2(186.67,33.67) v2(187.03,81.86) v2(187.05,33.16) v2(187.08,81.15) v2(187.24,35.01) v2(187.24,34.38) v2(187.31,33.76) v2(187.61,82.12) v2(187.62,81.48) v2(187.61,80.8) v2(196.76,57.03)
+3VPCU_G: length 5.7
  TOP w0.508: F7600.1 77.02,128.34 77.02,131.33 v2(76.7,131.65)
  BOTTOM w0.254: v2(76.7,131.65) 76.66,131.69 CN7602.6
+3VPCU_PD: length 144.6
  TOP w0.203: v2(199.68,105.21) 200.21,104.68 R5808.1
  TOP w0.254: v2(200.33,103.36) 200.87,103.36 R5807.1
  TOP w0.508: v2(157.07,85.17) 157.07,84.36 159.03,82.4 159.03,79.39 v2(159.01,79.37) ; v2(185.63,115.58) 185.53,115.58 185.02,115.07 185.02,114.36 184.77,114.1 TP6100.1 183.08,114.1 R6106.1 182.41,113.93 182.23,113.75 182.23,112.1 179.97,109.83 179.97,108.41 180.81,107.57 180.81,106.25 182.43,104.63 183.55,104.63 183.61,104.57 R6108.1 184.23,103.93 R6116.1
  IN1 w0.508: v2(159.01,79.37) 159.1,79.28 161.25,79.28 v2(161.35,79.38)
  IN2 w0.508: v2(185.63,115.58) 188.79,112.41 193.03,112.41 193.9,111.54 195.08,111.54 v2(196.35,112.81) 199.68,109.48 v2(199.68,105.21) 200.64,104.25 200.64,103.67 v2(200.33,103.36) ; v2(164.12,118.6) 164,118.6 159.06,123.53 159.06,124.49 v2(156.45,127.11)
  BOTTOM w0.381: v2(161.35,79.38) 161.15,79.19 R7711.2
  BOTTOM w0.508: v2(157.07,85.17) 156.9,85.34 156.9,86.19 157.54,86.82 157.54,89.18 157.55,89.19 157.55,89.29 158.89,90.63 158.89,91.78 159.01,91.9 159.01,92.79 159.7,93.48 159.7,94.6 157.97,96.32 157.97,98.33 161.2,101.55 161.2,105.29 159.16,107.32 159.16,108.44 152.31,115.3 152.31,120.53 152.95,121.18 152.95,121.39 154.14,122.57 154.14,124.8 v2(156.45,127.11) ; v2(185.63,115.58) 184.9,114.84 184.9,114.23 182.64,111.98 168.09,111.98 164.15,115.92 164.15,118.57 v2(164.12,118.6)
+3VPCU_WWAN: length 24.9
  TOP w0.381: v2(42.12,130.94) 42.12,130.71 41.76,130.34 v2(41.75,130.34) 42.16,129.94 C7871.2 C7860.2 41.91,127.7 41.91,127.59 41.85,127.54 41.85,126.46 R3417.2
  IN1 w0.381: v2(25.48,131.3) 25.39,131.39 25.39,131.9 25.94,132.45 41.3,132.45 42.12,131.63 v2(42.12,130.94)
  BOTTOM w0.254: CN3400.36 25.65,131.8 25.45,131.6 25.45,131.33 v2(25.48,131.3)
+3VSUS: length 20.4
  TOP w0.178: U5800.6 205.76,113.63 v2(205.78,113.65) ; U5800.17 203.63,108.78 v2(203.49,108.64)
  TOP w0.381: Q5800.2 201.13,104.81 200.9,105.04 v2(200.9,106.46) ; v2(209.43,106.79) 209.43,105.62 209.02,105.2 R5801.1 ; R5810.2 207.09,105.5 207.73,104.86 v2(207.73,103.76)
  TOP w0.508: v2(210.79,114.98) 210.4,115.37 R5804.2
  IN1 w0.508: v2(196.77,107.26) 200.1,107.26 v2(200.9,106.46)
  BOTTOM w0.508: 201.81,102.75 200.39,104.17 199.86,104.17 v2(196.77,107.26)
  vias: v2(203.07,101.87) v2(203.08,101.23) v2(204.83,105.19)
+5V: length 346.9
  TOP w0.254: R580.2 138.72,57.71 137.55,56.55 110.11,56.55 108.7,57.96 65.22,57.96 62.75,60.43 62.75,63.62 63.4,64.27 63.4,65.17 62.55,66.02 61.98,66.02 61.45,66.55 52.23,66.55 51.48,67.3 51.48,68.45 49.92,70.01 49.92,71.11 49.23,71.8 v2(47.28,71.8)
  TOP w0.381: PR9514.1 156.89,28.77 v2(157.39,29.27)
  TOP w0.508: v2(196.71,95.61) 196.27,95.61 195.61,96.27 Q6100.2
  IN1 w0.381: v2(152.48,21.44) 153.48,21.44 153.88,21.04 153.88,20.15 153.5,19.77 153.11,19.77 152.38,19.03 148,19.03 147.76,19.27 143.31,19.27 141.95,20.63 141.95,24.18 140.6,25.53 v2(140.6,25.79) ; v2(190.91,30.13) 190.33,30.13 189.8,29.6 187.11,29.6 184.65,27.13 163.9,27.13 161.73,29.31 157.43,29.31 v2(157.39,29.27)
  IN1 w1.016: 221.3,39.13 221.3,54.91 ; 11.92,103.87 12.38,103.87 13.19,103.05 14.31,103.05 14.92,102.44 14.92,101.61 16.59,99.93 16.59,98 26.02,88.58 27.67,88.58 31.92,84.32 31.92,78.16 32.77,77.31 35.4,77.31
  IN2 w0.381: v2(157.39,29.27) 157.31,28.89 156.93,28.5 154.92,28.5 153.8,27.38 153.8,22.76 v2(152.48,21.44)
  IN2 w0.508: v2(196.71,95.61) 199.62,95.61 201.26,93.97 202.37,93.97 203.44,92.89 203.44,91.51 206.61,88.34 206.61,86.19 207.7,85.11 207.7,83.36 209.29,81.77 209.29,80.49 212.39,77.39 212.39,70.9 221.11,62.18 v2(225.08,62.18)
  BOTTOM w0.381: R3627.1 227.19,24.68 227.19,25.08 226.83,25.43 225.94,25.43 225.86,25.35 ; v2(15.48,111.71) 15.43,111.77 PR8101.2
  BOTTOM w0.508: 139.91,24.06 139.89,24.03 139.89,22.05 139.71,21.87 139.33,21.87 139.12,21.67 139.12,19.97 Q5002.1
  BOTTOM w1.016: 220.96,36.43 221.36,36.03 221.36,30.16 223.99,27.54 225,27.54 225.86,26.68 225.86,25.35 225.76,25.25 ; 225.08,68.76 v2(225.08,62.18) 225.08,56.98 224.49,56.39 223.3,56.39
  BOTTOM w2.032: 98.99,65.97 88.35,65.97 80.65,73.66 80.65,82.4
  vias: v2(16.46,116.67) v2(17.1,116.67) v2(26.52,124.97) v2(26.52,124.34) v2(35.29,76.38) v2(35.97,76.36) v2(43.13,68.28) v2(43.14,67.64) v2(43.12,67.01) v2(43.72,68) v2(43.72,67.34) v2(47.81,69.45) v2(47.81,68.81) v2(47.81,68.18) v2(47.84,67.52) v2(61.81,81.64) v2(62.26,82.07) v2(62.35,81.3) v2(62.86,81.69) v2(78.81,84.64) v2(79.28,85.11) v2(79.74,85.57) v2(80.26,86.09) v2(161.55,54.11) v2(162.18,54.1) v2(162.82,54.09) v2(163.45,54.1) v2(186.75,7.21) v2(187.21,6.76) v2(190.84,28.81) v2(190.91,29.47) v2(191.63,28.81) v2(192.31,28.83) v2(192.72,28.25) v2(196.51,14.58) v2(196.96,15.04) v2(197.42,15.49) v2(197.38,14.56) v2(199.42,25.46) v2(199.42,24.82) v2(199.42,24.19) v2(199.42,23.53) v2(200.95,6.48) v2(201.6,6.46) v2(202.23,6.45) v2(202.87,6.42) v2(216.22,9.15) v2(216.52,9.7) v2(216.88,10.22) v2(216.87,9.17) v2(221.42,38.03) v2(221.39,37.37) v2(221.72,56.49) v2(221.75,55.86) v2(222.86,23.65) v2(223.46,23.9) v2(223.91,23.42) v2(224.29,23.93)
+5V_ALW: length 1.9
  BOTTOM w0.102: PC8639.2 193.58,19.97 193.14,19.53 v2(193.14,18.36)
+5V_CAM: length 3.2
  BOTTOM w0.305: v2(29.81,130.74) 29.76,130.79 v2(29.76,131.37) ; CN3400.27 30.15,131.67 29.85,131.37 v2(29.76,131.37) ; CN3400.28 29.65,131.49 v2(29.76,131.37)
+5V_HDMIC: length 10.1
  IN2 w0.508: v2(226.78,60.97) 227.44,60.97 v2(228.53,62.06) 228.53,63.33 229.7,64.5 229.7,65.36 230,65.66 CN3500.18
  BOTTOM w0.203: R3511.1 226.73,61.02 v2(226.78,60.97) ; R3510.1 v2(228.53,62.06)
+5V_LED_KBLIGHT:
  vias: v2(139.41,15.9)
+5V_USBP1:
  vias: v2(225.39,42.3) v2(226.88,31.4) v2(227.06,32.29)
+5VPCU: length 433.5
  TOP w0.254: PR9615.1 115.53,62.19 114.03,63.68 108.96,63.68 105.61,60.33 67.86,60.33 66.86,61.32 v2(66.86,61.75) 66.86,65.88 64.08,68.66 63.33,68.66 62.34,69.65 53.68,69.65 v2(48.87,74.47) ; PC9025.2 113.02,121.54 112.4,120.93 PU9001.8 ; PU9602.5 113.38,60.03 113.79,60.43 113.79,60.67 114.79,61.68 114.79,62.13 113.8,63.12 109.19,63.12 105.84,59.77 67.15,59.77 v2(66.86,60.05) ; v2(142.45,114.42) 142.45,114.28 139.53,111.36 139.53,110.35 139.27,110.09 135.83,110.09 135.56,110.36 134.99,110.36 134.22,111.13 134.22,111.72 134.58,112.07 135.24,112.07 135.53,112.36 PU9601.5
  TOP w0.305: PU9600.5 122.31,116.89 125.76,120.33 v2(125.76,121.31)
  TOP w0.508: v2(186.66,115.58) 186.66,114.76 R6114.2 186.52,114.36 186.46,114.42 R6110.2 ; PR9606.1 176.75,110.27 176.87,110.38 PR9602.1 177.72,110.38 v2(178.72,109.39) ; v2(54.43,78.49) 54.31,78.61 54.31,81.79 55.05,82.53 55.05,92.74 54.47,93.33 54.47,94.11 53.25,95.33 53.25,99.09 54.52,100.36 54.52,104.79 v2(54.97,105.25) 54.45,105.77 53.99,105.77 C7841.2 53.15,108.36 52.59,108.93 52.59,111.77 53.3,112.48 54.8,112.48 55.16,112.84 v2(55.16,113.23) 54.26,114.13 54.26,115.19 52.64,116.82 52.64,120.82 53.56,121.74 v2(53.76,121.74) ; PC9025.2 113.26,121.39 113.71,120.94 v2(114.59,120.94) ; v2(142.23,121.37) 147.34,126.47 v2(158.32,126.47) ; R6115.1 182.24,106.54 181.85,106.94 181.85,108 v2(181.2,108.65) ; 8.52,111.58 9.62,111.58 9.84,111.36 14.89,111.36 15.55,110.7 R7617.1 ; 222.72,94.9 225,94.9 225.41,95.31 R6323.1
  IN1 w0.508: v2(190.2,32.03) 190.2,30.79 189.57,30.16 186.88,30.16 184.49,27.77 176.16,27.77 174.81,29.11 174.05,29.11 173.58,28.65 172.06,28.65 171.92,28.78 168.97,28.78 v2(168.03,29.72) 167.34,29.04 165.26,29.04 164.33,29.96 157.21,29.96 156.73,29.49 156.73,28.76 156.47,28.5 155.38,28.5 v2(154.41,29.47) ; 215.21,114.36 212.2,114.36 211.69,114.87 211.69,115.08 v2(211.17,115.6) ; v2(114.59,120.94) 114.62,120.91 119.21,120.91 119.51,121.21 124.44,121.21 124.82,120.83 125.48,120.83 125.76,121.11 v2(125.76,121.31) 125.94,121.31 126.61,121.98 133.14,121.98 v2(133.93,121.19) 133.93,120.87 134.25,120.55 141.42,120.55 v2(142.23,121.37)
  IN2 w0.508: v2(40.7,61.68) 42.32,61.68 45.97,65.32 45.97,71.57 v2(48.87,74.47) 50.15,75.75 51.69,75.75 v2(54.43,78.49)
  BOTTOM w0.254: PC9002.2 53.93,104.66 PU9000.8 ; v2(142.45,114.42) 143.17,115.14 143.17,117.37 143.04,117.51 142.58,117.51 141.92,118.17 139.79,118.17 139.18,118.77 135.92,118.77 135.17,119.52 135.17,121.46 134.96,121.67 134.42,121.67 v2(133.93,121.19) ; PC8908.2 53.88,112.77 PU8900.8 ; PC8921.2 53.9,120.9 PU8901.8 ; v2(66.86,61.75) v2(66.86,60.05)
  BOTTOM w0.508: v2(53.76,121.74) 54.09,121.41 PC8921.2 ; 187.07,114.95 195.33,114.95 196.17,114.12 200.23,114.12 201.71,115.6 204.85,115.6 207.53,115.6 208.16,114.97 209.3,114.97 209.93,115.6 211.17,115.6 v2(211.17,115.6) ; PC8908.2 54.98,113.41 v2(55.16,113.23) ; PR9201.1 133.67,120.92 v2(133.93,121.19) ; PC9002.2 54.51,105.25 v2(54.97,105.25) ; v2(158.32,126.47) 158.32,126.22 159.42,125.13 159.42,120.54 163.54,116.42 163.54,115.67 167.84,111.37 175.66,111.37 176.11,110.92 177.41,110.92 ; 181.82,111.1 183.05,111.1 185.71,113.75 185.71,114.62 v2(186.66,115.58)
  vias: v2(5.77,116.67) v2(5.77,116.01) v2(6.31,115.24) v2(6.46,115.88) v2(7.05,115.25) v2(7.09,115.88) v2(7.76,115.25) v2(141.54,14.76) v2(142.15,14.56) v2(188.1,33.38) v2(188.3,33.98) v2(189.52,32.68) v2(189.54,32.05) v2(190.24,35.66) v2(190.88,35.66) v2(191.51,35.66) v2(192.17,35.64) v2(192.86,35.62) v2(211.16,39.45) v2(211.46,40.05) v2(211.77,40.64) v2(211.79,39.45) v2(212.1,40.1) v2(212.42,40.65) v2(212.46,39.51) v2(212.75,40.09) v2(213.08,40.65) v2(213.08,39.5) v2(213.38,40.1) v2(213.7,39.51) v2(213.76,40.63) v2(214.03,40.05) v2(217.33,79.79) v2(217.33,79.15) v2(217.36,78.52) v2(217.99,79.79) v2(217.99,79.15) v2(217.99,78.52) v2(218.14,43.29) v2(218.14,42.65) v2(218.14,42.02) v2(218.14,41.38) v2(218.14,40.75) v2(218.14,40.11) v2(218.2,114.5) v2(218.78,43.29) v2(218.78,42.65) v2(218.78,42.02) v2(218.78,41.38) v2(218.78,40.75) v2(218.78,40.11) v2(218.86,114.5) v2(220.63,95.15) v2(220.73,95.81) v2(221.14,94.32) v2(221.29,95.08) v2(221.39,95.71) v2(221.95,95) v2(222.11,106.25) v2(222.74,106.25) v2(223.38,106.25) v2(224.01,106.25)
+V3.3DX_1.5DX_ADO: length 22
  TOP w0.254: C466.2 127.24,90.77 v1(127.24,90.51)
  TOP w0.508: v2(128.89,99.19) 128.89,99.73 130.64,101.48 130.64,103.64 129.4,104.88 v2(129.4,105.97) 129.32,106.05 C478.1 L402.2
  IN1 w0.508: v1(127.24,90.51) 127.9,91.17 127.9,92.72 127.21,93.4 127.21,94.84 128.89,96.52 v2(128.89,99.19)
  BOTTOM w0.254: U400.BT20 127.54,90.21 v1(127.24,90.51)
+VCC_CORE: length 56.2
  BOTTOM w0.127: 121.46,86.92 U400.BF24 121.17,87.21 ; 119.35,86.28 U400.BC26 ; U400.BC26 119.64,85.99 ; U400.BC26 119.92,86.28 ; U400.BC26 119.64,86.57 ; 118.73,85.99 U400.BB26 ; U400.BB26 118.44,86.28 ; U400.BB26 119.02,86.28 ; U400.BB26 118.73,86.57 ; 115.99,85.99 U400.AU26 ; U400.AU26 116.29,86.28 ; U400.AU26 115.7,86.28 ; U400.AU26 115.99,86.57 ; U400.AV10 116.16,96.64 ; U400.AV10 116.74,96.64 ; U400.AV10 116.45,96.93 ; U400.AV10 116.45,96.35 ; U400.AY26 118.11,86.28 ; U400.AY26 117.82,85.99 ; U400.AY26 117.82,86.57 ; U400.AY26 117.52,86.28 ; 120.15,96.35 U400.BD10 ; U400.BD10 120.44,96.64 ; U400.BD10 119.85,96.64 ; U400.BD10 120.15,96.93 ; U400.AR7 114.31,98.21 ; U400.AR7 114.6,97.91 ; U400.AR7 114.89,98.21 ; U400.AR7 114.6,98.5 ; U400.AP24 114.46,87.21 ; U400.AP24 114.17,86.92 ; U400.AP24 114.17,87.5 ; 115.08,86.92 U400.AT24 ; U400.AT24 114.79,87.21 ; U400.AT24 115.08,87.5 ; U400.AT24 115.38,87.21 ; 114.17,85.99 U400.AP26 ; U400.AP26 114.17,86.57 ; U400.AP26 113.88,86.28 ; U400.AP26 114.46,86.28 ; 114.6,96.93 U400.AR10 ; U400.AR10 114.31,96.64 ; U400.AR10 114.6,96.35 ; 118.3,97.85 U400.BA8 ; U400.BA8 118.59,97.56 ; U400.BA8 118.3,97.26 ; U400.BA8 118,97.56 ; U400.AW26 116.91,86.57 ; U400.AW26 116.61,86.28 ; U400.AW26 116.91,85.99 ; U400.AW26 117.2,86.28 ; 118.11,87.21 U400.AY24 ; U400.AY24 117.82,87.59 v1(117.92,87.69) ; U400.AY24 117.82,86.92 ; U400.AY24 117.52,87.21 ; U400.AP9 114.14,96.81 ; U400.AP9 114.14,97.39 ; U400.AP9 114.43,97.1 ; U400.AP9 113.85,97.1 ; 118.93,98.21 U400.BC7 ; U400.BC7 119.22,98.5 ; U400.BC7 119.22,97.91 ; U400.BC9 119.98,97.1 ; U400.BC9 119.68,96.81 ; U400.BC9 119.39,97.1 ; U400.AW8 117.67,97.56 ; U400.AW8 117.08,97.56 ; U400.AW8 117.37,97.26 ; U400.AW8 117.37,97.85 ; U400.BE26 120.55,85.99 ; U400.BE26 120.26,86.28 ; U400.BE26 120.84,86.28 ; U400.BE26 120.55,86.57 ; 116.91,86.92 U400.AW24 117.2,87.21 ; U400.BA7 118.59,98.21 ; U400.BA7 118,98.21 ; U400.BA7 118.3,97.91 ; U400.BA7 118.3,98.5 ; U400.AW25 117.65,86.75 ; U400.AW25 117.07,86.75 ; U400.AW25 117.36,86.45 ; U400.AW25 117.36,87.04 ; 114.6,97.85 U400.AR8 ; U400.AR8 114.6,97.26 ; U400.AR8 114.89,97.56 ; U400.AR8 114.31,97.56 ; 115.53,97.85 U400.AU8 ; U400.AU8 115.23,97.56 ; U400.AU8 115.53,97.26 ; 119.22,96.93 U400.BC10 ; U400.BC10 118.93,96.64 ; U400.BC10 119.22,96.35 ; U400.BC10 119.51,96.64 ; 115.36,97.1 U400.AT9 ; U400.AT9 115.06,97.39 ; U400.AT9 114.77,97.1 ; U400.BE25 121.01,87.04 ; U400.BE25 120.71,86.75 ; U400.BE25 121.01,86.45 ; U400.BE25 121.3,86.75 ; U400.AW7 117.37,98.5 ; U400.AW7 117.67,98.21 ; U400.AW7 117.37,97.91 ; U400.AW7 117.08,98.21 ; 115.53,98.5 U400.AU7 ; U400.AU7 115.23,98.21 ; U400.AU7 115.82,98.21 ; U400.AU7 115.53,97.91 ; U400.BE24 120.84,87.21 ; U400.BE24 120.55,87.6 v1(120.63,87.69) ; U400.BE24 120.26,87.21 ; U400.BE24 120.55,86.92 ; U400.BF26 121.46,85.99 ; U400.BF26 121.17,86.28 ; U400.BF26 121.46,86.57 ; U400.AV7 116.45,98.5 ; U400.AV7 116.16,98.21 ; U400.AV7 116.45,97.91 ; U400.AV7 116.74,98.21 ; U400.AU25 115.54,87.04 ; U400.AU25 115.83,86.75 ; U400.AU25 115.25,86.75 ; U400.AU25 115.54,86.45 ; 118.27,86.45 U400.BA25 ; U400.BA25 117.98,86.75 ; U400.BA25 118.27,87.04 ; U400.BA25 118.57,86.75 ; U400.AW9 117.2,97.1 ; U400.AW9 116.91,96.81 ; U400.AW9 116.62,97.1 ; U400.AW9 116.91,97.39 ; 114.63,86.45 U400.AR25 ; U400.AR25 114.92,86.75 ; U400.AR25 114.33,86.75 ; U400.AR25 114.63,87.04 ; U400.AT26 115.38,86.28 ; U400.AT26 115.08,86.57 ; U400.AT26 114.79,86.28 ; U400.AT26 115.08,85.99 ; U400.BD8 120.15,97.25 ; 113.26,86.57 U400.AN26 113.55,86.28 ; U400.BD25 120.1,87.04 ; U400.BD25 120.1,86.45 ; U400.BD25 119.8,86.75 ; U400.BD25 120.39,86.75 ; 113.68,96.93 U400.AN10 ; U400.AN10 113.97,96.64 ; U400.AN10 113.39,96.64 ; U400.AN10 113.68,96.35 ; 113.51,97.1 U400.AN9 113.22,96.81 ; U400.AW10 117.08,96.64 ; U400.AW10 117.37,96.93 ; U400.AW10 117.37,96.35 ; U400.AU9 115.99,96.81 ; U400.AU9 116.28,97.1 ; U400.AU9 115.7,97.1 ; 120.9,97.1 U400.BE9 ; U400.BE9 120.61,96.81 ; U400.BE9 120.31,97.1 ; 115.99,86.92 U400.AU24 ; U400.AU24 115.99,87.5 ; U400.AU24 115.7,87.21 ; U400.AN24 113.26,86.82 ; U400.BF9 121.19,97.1
  BOTTOM w0.152: v1(118.68,102.89) 118.68,102.5 118.89,102.28 U400.BB2 ; U400.BF2 121.33,102.15 121.17,102.32 v1(121.17,102.34)
  BOTTOM w0.254: v1(116.59,103.05) 116.45,102.91 U400.AV2 ; v2(114.08,102.78) 114.01,102.71 U400.AP2 ; PR8826.2 112.1,111.63 112.1,111.43 112.65,110.87 v2(112.65,110.6) 113.3,109.95 R609.2
  vias: v1(111.39,93.38) v1(112.02,93.38) v1(113.22,96.5) v1(114.03,91.12) v1(114.14,97.7) v1(114.11,88.88) v1(114.16,93.4) v1(114.66,91.12) v1(114.74,88.88) v1(114.79,93.4) v1(115.04,99.01) v1(115.06,97.7) v1(115.98,99.01) v1(117.33,87.69) v1(117.76,85.45) v1(118.55,87.66) v1(118.7,85.43) v1(118.75,99.17) v1(118.76,97.7) v1(118.76,96.5) v1(118.85,92.26) v1(118.85,90.73) v1(118.85,89.18) v1(118.99,95.88) v1(119.49,92.26) v1(119.49,90.73) v1(119.48,89.19) v1(119.62,95.88) v1(119.68,96.5) v1(120.02,87.71) v1(120.12,92.26) v1(120.12,90.73) v1(120.12,89.18) v1(120.56,85.45) v1(121.47,85.45) v2(112.5,91.12) v2(112.63,93.4) v2(112.57,88.85) v2(113.27,91.12) v2(113.34,88.85) v2(113.39,93.4) v2(117,110.17) v2(117.31,104.91) v2(117.66,110.9) v2(117.99,105.62) v2(117.97,104.93) v4(78.28,112.88) v4(78.36,115.3) v4(78.36,114.49) v4(78.36,113.75) v4(79.1,115.07) v4(79.05,112.81) v4(79.18,114.34) v4(79.18,113.57) v4(79.89,112.91) v4(79.97,115.32) v4(79.97,114.51) v4(79.97,113.77) v4(80.7,115.32) v4(80.65,113.06) v4(80.78,114.59) v4(80.78,113.82) v4(81.49,115.32) v4(81.52,114.53) v4(81.52,113.77) v4(82.23,112.1) v4(82.18,109.73) v4(82.3,114.48) v4(82.3,113.75) v4(82.25,112.96) v4(82.25,111.33) v4(82.25,110.55) v4(82.38,115.27) v4(83.04,114.51) v4(83.04,113.72) v4(83.04,112.91) v4(83.04,112.17) v4(83.02,110.55) v4(83.14,115.27) v4(83.07,111.36) v4(83.8,114.51) v4(83.8,113.72) v4(83.8,112.91) v4(83.93,115.27) v4(83.88,112.07) v4(83.88,111.33) v4(84.57,114.51) v4(84.57,113.72) v4(84.57,112.91) v4(84.64,112.04) v4(84.72,115.27) v4(85.4,113.52) v4(85.48,115.12) v4(85.48,114.38) v4(86.22,115.12) v4(86.29,114.38)
+VCC_GT: length 84.7
  TOP w0.254: PR8835.2 37.52,108.59 v2(37.6,108.59)
  IN1 w0.254: v2(37.6,108.59) 36.46,108.59 34.87,107 34.87,103.55 33.85,102.53 33.85,99.59 34.03,99.41 34.03,93.79 v2(35.95,91.87)
  IN2 w0.254: v2(35.95,91.87) 36.3,91.52 43.4,91.52 43.73,91.18 54.06,91.18 54.9,92.03 57.81,92.03 60.28,94.49 65.12,94.49 67.8,97.17 69.1,97.17 v4(71.04,99.12)
  BOTTOM w0.079: U400.H15 97.69,93.38 ; 98.03,90.93 98.03,90.93
  BOTTOM w0.127: 103.81,97.56 U400.U8 ; U400.U8 103.52,97.26 ; U400.U8 103.22,97.56 ; U400.V9 103.69,97.1 ; U400.V9 103.98,96.81 ; U400.V9 103.98,97.39 ; U400.V9 104.27,97.1 ; U400.L8 100.11,97.56 ; U400.L8 99.82,97.89 ; U400.L8 99.53,97.56 ; U400.L8 99.82,97.26 ; 97.7,95.27 U400.H12 98.03,94.9 ; 99.82,96.93 U400.L10 ; U400.L10 99.82,96.35 ; U400.L10 100.11,96.64 ; U400.T9 103.35,97.1 ; U400.T9 102.76,97.1 ; U400.T9 103.05,96.81 ; U400.T9 103.05,97.39 ; U400.W8 104.73,97.56 ; U400.W8 104.15,97.56 ; U400.W8 104.44,97.85 ; U400.W8 104.44,97.26 ; 98.03,94.67 U400.H14 98.03,93.98 ; 98.68,92.79 U400.J17 99.03,92.44 ; U400.N9 100.91,97.1 ; U400.N9 101.21,97.39 ; U400.N9 101.5,97.1 ; U400.N9 101.21,96.81 ; U400.U10 103.81,96.64 ; U400.U10 103.52,96.35 ; U400.U10 103.52,96.93 ; U400.U10 103.22,96.64 ; 99.33,96.5 U400.K11 ; U400.K11 99.63,96.21 ; U400.K11 99.33,95.92 ; U400.K11 U400.J11 ; U400.T8 102.59,97.26 ; U400.T8 102.89,97.56 ; U400.T8 102.3,97.56 ; 98.03,91.16 U400.H18 97.72,91.5 ; U400.M9 100.28,96.81 ; U400.M9 100.58,97.1 ; U400.M9 99.99,97.1 ; U400.M9 100.28,97.39 ; U400.T10 102.59,96.35 ; U400.T10 102.89,96.64 ; U400.T10 102.59,96.93 ; 101.84,97.1 U400.R9 ; U400.R9 102.13,97.39 ; U400.R9 102.42,97.1 ; U400.N8 101.04,97.56 ; U400.N8 100.75,97.85 ; U400.N8 100.45,97.56 ; U400.N8 100.75,97.26 ; 97.71,92.44 U400.H17 98.03,92.79 ; 99.03,94.33 U400.J14 98.68,94.67 ; 98.03,95.91 U400.H11 97.69,96.21 ; 101.67,97.26 U400.P8 ; U400.P8 101.96,97.56 ; U400.P8 101.38,97.56 ; U400.P2 101.96,102.04 101.96,102.62 v1(102.04,102.7) ; U400.N10 101.04,96.64 ; U400.N10 100.75,96.93 ; U400.N10 100.45,96.64 ; U400.N10 100.75,96.35 ; U400.H20 98.03,90.93 ; 99.03,90.56 U400.J20 98.68,90.9 ; 104.61,97.1 U400.W9 104.9,97.39
  BOTTOM w0.254: U400.K2 99.17,102.08 v1(99.17,102.32)
  vias: v1(91.27,93.81) v1(91.45,96.9) v1(91.9,93.81) v1(92.1,98.43) v1(92.08,96.9) v1(92.26,95.71) v1(92.54,93.81) v1(92.74,98.43) v1(92.72,96.9) v1(92.87,95.71) v1(93.17,93.81) v1(93.2,91.95) v1(93.37,98.43) v1(93.35,96.9) v1(93.51,95.71) v1(93.81,93.81) v1(93.81,91.92) v1(94.46,95.72) v1(94.46,93.81) v1(94.46,91.92) v1(94.9,96.75) v1(95.76,95.72) v1(95.76,93.81) v1(95.76,91.92) v1(95.76,90.14) v1(96.22,96.75) v1(96.41,95.72) v1(96.41,93.81) v1(96.41,91.92) v1(96.59,98.72) v1(97.09,96.75) v1(97.06,90.14) v1(97.51,99.37) v1(97.51,98.72) v1(97.51,97.7) v1(97.71,95.72) v1(97.71,93.81) v1(97.71,91.92) v1(98.44,99.37) v1(98.44,98.72) v1(98.44,97.7) v1(98.36,95.72) v1(98.36,93.81) v1(98.36,91.92) v1(98.36,90.14) v1(99.36,98.72) v1(99.36,97.7) v1(100.31,98.69) v1(100.28,97.7) v1(100.28,96.5) v1(100.41,89.72) v1(100.59,93.1) v1(100.57,91.45) v1(101.05,89.74) v1(101.21,97.7) v1(101.21,96.5) v1(101.23,93.1) v1(101.2,91.45) v1(101.3,95.28) v1(103.06,97.66) v1(103.98,97.7) v1(104.91,97.74) v2(92.54,99.57) v2(93.18,99.57) v2(93.81,99.55) v4(70.9,103.89) v4(71.03,104.73) v4(71.01,103.06) v4(71.04,102.16) v4(71.04,101.15) v4(71.04,100.13) v4(71.64,102.64) v4(71.64,101.63) v4(71.64,100.61) v4(71.65,99.61) v4(71.71,103.92) v4(71.81,104.7) v4(72.12,103.26) v4(72.19,102.13) v4(72.18,101.1) v4(72.22,100.16) v4(72.43,104.21) v4(73.08,104.65) v4(73.21,103.84) v4(73.92,104.68) v4(73.97,103.87) v4(74.77,104.51) v4(74.77,103.77) v4(75.48,104.19) v4(75.69,103.46) v4(76.24,104.19)
+VCC_IO: length 112.4
  TOP w0.381: C608.2 112.5,87.75 v1(112.71,87.53) ; C607.2 111.62,87.31 v1(111.87,87.56) ; C609.2 126.14,91.74 v1(126.58,92.19) 126.16,92.61 C600.2 ; R7725.1 29.4,121.76 29.4,122.04 29.1,122.33 v2(29.1,122.33) ; v1(112.35,85.49) 111.83,86.01 C612.2 111.62,85.56 v1(111.44,85.37)
  IN1 w0.381: 91.5,117.86 90.16,119.2 83.48,119.2 80.43,122.24 77.06,122.24 76.44,122.87 74.03,122.87 72.89,124 70.75,124 70.1,124.66 63.84,124.66 63.75,124.57 58.83,124.57 58.25,123.98 52.88,123.98 52.46,123.56 49.65,123.56 43.92,117.83 33.86,117.83 30.51,114.48 v2(27.52,114.48)
  BOTTOM w0.127: U400.BJ24 123.29,86.92 ; U400.BJ24 123.29,87.5 ; U400.BJ24 122.99,87.21 ; 123.29,86.57 U400.BJ26 122.99,86.28 ; U400.AL26 112.35,86.57 ; U400.AL26 112.35,85.91 ; U400.AL26 112.64,86.28 ; U400.AL26 112.06,86.28 ; U400.AL24 112.35,87.51 ; U400.AL24 112.35,86.92 ; U400.AL24 112.06,87.21 ; U400.AL24 112.64,87.21 ; U400.BH24 122.37,86.92 ; U400.BH24 122.37,87.5 ; U400.BH24 122.67,87.21 ; U400.BH25 122.54,86.75 ; U400.BH25 122.83,87.04 ; U400.BH25 123.12,86.75 ; U400.BH25 122.83,86.45 ; U400.AM25 112.8,86.45 ; U400.AM25 112.8,87.04 ; U400.AM25 112.51,86.75 ; 111.44,87.5 U400.AK24 ; U400.AK24 111.44,86.92 ; U400.AK24 111.8,87.21 ; 122.37,86.57 U400.BH26 122.67,86.28 ; 111.6,86.75 U400.AL25 ; U400.AL25 112.19,86.75 ; U400.AL25 111.89,87.04 ; U400.AL25 111.89,86.45 ; 111.73,86.28 U400.AK26 111.44,86.57
  BOTTOM w0.254: U400.BP16 126.24,92.53 v1(126.58,92.19) 126.58,92.13 U400.BP18
  BOTTOM w0.381: v2(29.1,122.33) 29.1,121.99 27.44,120.33 27.44,116.44 27.52,116.36 v2(27.52,114.48) ; R543.1 111.33,107.39 111.33,109.13 C599.2 C598.2 111.35,111.09 v2(107.48,114.96)
  BOTTOM w3.048: 88.65,101.15 90.84,103.33 90.84,106.23
  vias: v1(122.33,85.45) v1(123.02,87.64) v1(123.33,85.5) v2(85.4,98.53) v2(86.03,98.53) v2(86.37,99.07) v2(86.67,98.51) v2(87.12,98.96) v2(87.82,98.95) v2(90.61,114.2) v2(91.24,114.2) v2(91.88,114.2) v2(92.51,114.2) v2(93.15,114.2) v2(93.78,114.2) v2(133.92,117.07) v2(134.55,117.07) v2(135.19,117.07) v2(135.82,117.07) v2(136.46,117.07) v2(137.09,117.07)
+VCC_SA: length 131.5
  TOP w0.254: PR8842.2 v2(32.96,101.91)
  TOP w0.381: v1(125.41,87.65) 125.41,87.58 125.81,87.17 C617.2
  IN1 w0.254: v2(123.5,93.78) 122.23,93.78 121.65,94.37 116.34,94.37 115.96,93.99 102.97,93.99 101.88,95.08 101.88,95.53 101.49,95.92 100.16,95.92 99.83,96.25 91.44,96.25 90.23,97.45 90.23,98.91 89.15,99.99 85.86,99.99 83.73,97.86 81.83,97.86 74.07,90.1 67.54,90.1 64.88,87.43 52.84,87.43 50.64,89.63 50.64,93.26 50.11,93.79 40.33,93.79 37.82,91.28 35.84,91.28 33.66,93.45 33.66,98.79 32.39,100.06 32.39,101.35 v2(32.96,101.91)
  BOTTOM w0.127: 124.47,97.56 U400.BL8 124.76,97.26 ; U400.BN25 125.56,86.45 ; U400.BN25 125.56,87.04 ; U400.BN25 125.27,86.75 ; U400.BN25 125.86,86.75 ; U400.BK8 123.84,97.85 ; U400.BK8 124.13,97.56 ; U400.BK8 123.55,97.56 ; U400.BK8 123.84,97.26 ; 124.47,96.64 U400.BL10 ; U400.BL10 125.06,96.64 ; U400.BL10 124.76,96.93 ; U400.BL10 124.76,96.35 ; U400.BH9 122.45,97.39 ; U400.BH9 122.45,96.81 ; U400.BH9 122.16,97.1 ; U400.BH9 122.75,97.1 ; 122.29,97.56 U400.BG8 121.99,97.26 ; 123.9,87.21 U400.BL24 124.2,86.92 ; U400.BL26 124.2,85.99 ; U400.BL26 123.9,86.28 ; U400.BL26 124.2,86.57 ; U400.BL26 124.49,86.28 ; 122.92,97.26 U400.BJ8 ; U400.BJ8 122.62,97.56 ; U400.BJ8 123.21,97.56 ; U400.BJ8 122.92,97.85 ; 124.3,96.81 U400.BL9 ; U400.BL9 124.01,97.1 ; U400.BL9 124.59,97.1 ; U400.BL9 124.3,97.39 ; U400.BM24 125.4,87.21 ; U400.BM24 125.11,86.92 ; U400.BM24 125.11,87.5 ; U400.BG10 122.29,96.64 ; U400.BG10 121.99,96.35 ; U400.BG10 121.99,96.93 ; U400.BK25 124.03,86.75 ; U400.BK25 123.74,87.04 ; U400.BK25 123.74,86.45 ; U400.BJ9 123.38,97.39 ; U400.BJ9 123.38,96.81 ; U400.BJ9 123.09,97.1 ; U400.BJ9 123.67,97.1 ; 122.62,96.64 U400.BJ10 ; U400.BJ10 122.92,96.93 ; U400.BJ10 123.21,96.64 ; U400.BJ10 122.92,96.35
  vias: v1(123.31,97.82) v1(123.81,87.51) v1(124.32,97.73) v2(123.55,95.56) v2(123.55,93.07) v2(123.55,92.39) v2(123.55,90.71) v2(123.55,89.64) v2(124.16,95.94) v4(117.94,124.06) v4(117.94,123.3) v4(118.42,122.65) v4(118.73,124.08) v4(118.73,123.32)
+VCC_TS: length 12.3
  TOP w0.203: R3421.1 R3422.1 33.99,130.44 v2(34.02,130.41)
  IN1 w0.381: 23.45,130.69 23.87,130.26 25.71,130.26 25.82,130.15 31.88,130.15 32.24,130.52 33.91,130.52 v2(34.02,130.41)
  vias: v2(23.07,131.95) v2(23.5,131.42)
+VCCA_XTAL: length 7.2
  IN2 w0.508: v2(147.79,98.24) 147.79,97.45 147.75,97.4 146.98,97.4 146.68,97.7 145.78,97.7 145.19,98.29 143.32,98.29 v2(142.88,98.73)
  BOTTOM w0.381: R607.1 147.79,97.78 v2(147.79,98.24)
  vias: v2(143.13,98.06)
+VCCAMPHYPLL_1.05V: length 11.7
  BOTTOM w0.508: R608.2 128.05,111.93 127.69,111.56 127.69,110.54 C476.1 128.17,108.64 C474.1 128.26,107.53 v2(128.05,107.32) 128.35,107.02 128.35,104.45 128.96,103.84 128.96,103.21 128.65,102.9 128.65,102.24 128.65,101.94 U400.BV2
+VCCDPHY: length 3.7
  BOTTOM w0.203: U400.CP25 138.45,87 141.86,87 C449.2
+VCCDSW_1.05V: length 1.3
  TOP w0.381: C458.2 127.55,86.69 127.29,86.95 127.29,87.15 v1(127.26,87.18)
  BOTTOM w0.305: v1(127.26,87.18) 127.26,87.31 U400.BT24
+VCCGT_+VCORE: length 30.4
  BOTTOM w0.127: U400.AE10 108.43,96.64 ; U400.AE10 108.14,96.35 ; U400.AE10 108.14,96.93 ; 112.75,97.26 U400.AM8 112.46,97.56 ; U400.AB9 106.46,97.1 ; U400.AB9 107.04,97.1 ; U400.AB9 106.75,96.81 ; U400.AB9 106.75,97.39 ; U400.AA9 105.83,96.81 ; U400.AA9 106.12,97.1 ; U400.AA9 105.53,97.1 ; U400.AA9 105.83,97.39 ; 106,97.56 U400.AB8 ; U400.AB8 106.29,97.26 ; U400.AB8 106.58,97.56 ; U400.AB8 106.29,97.85 ; U400.AE9 108.3,97.1 ; U400.AE9 108.6,97.39 ; U400.AE9 108.89,97.1 ; U400.AE9 108.6,96.81 ; 112,97.1 U400.AL9 ; U400.AL9 112.59,97.1 ; U400.AL9 112.29,97.39 ; U400.Y8 105.36,97.26 ; U400.Y8 105.66,97.56 ; U400.Y8 105.36,97.85 ; 109.23,97.1 U400.AG9 ; U400.AG9 109.52,97.39 ; U400.AG9 109.81,97.1 ; U400.AL8 111.54,97.56 ; U400.AL8 112.12,97.56 ; U400.AL8 111.83,97.26 ; U400.AL8 111.83,97.85 ; U400.AK9 111.66,97.1 ; U400.AK9 111.37,97.39 ; U400.AK9 111.08,97.1 ; U400.AK9 111.37,96.81 ; U400.AH9 110.74,97.1 ; U400.AH9 110.45,97.39 ; U400.AH9 110.15,97.1 ; U400.AH9 110.45,96.81 ; U400.AJ10 110.91,96.35 ; U400.AJ10 111.2,96.64 ; U400.AJ10 110.91,96.93 ; U400.AJ10 110.61,96.64 ; U400.AF8 109.35,97.56 ; U400.AF8 109.06,97.85 ; U400.AF8 109.06,97.26 ; U400.AF8 108.77,97.56 ; U400.AL10 111.54,96.64 ; U400.AL10 111.83,96.35 ; U400.AL10 111.83,96.93 ; U400.Y10 105.66,96.64 ; U400.Y10 105.36,96.93 ; U400.Y10 105.36,96.35 ; 107.38,97.1 U400.AD9 ; U400.AD9 107.97,97.1 ; U400.AD9 107.67,97.39 ; U400.AF10 108.77,96.64 ; U400.AF10 109.06,96.93 ; U400.AF10 109.06,96.35 ; U400.AC8 107.5,97.56 ; U400.AC8 107.21,97.26 ; U400.AC8 107.21,97.85 ; U400.AC8 106.92,97.56 ; 110.91,97.85 U400.AJ8 ; U400.AJ8 110.61,97.56 ; U400.AJ8 111.2,97.56 ; U400.AJ8 110.91,97.26 ; 106.29,96.35 U400.AB10 ; U400.AB10 106.29,96.93 ; U400.AB10 106.58,96.64 ; U400.AB10 106,96.64 ; U400.AE8 108.43,97.56 ; U400.AE8 108.14,97.85 ; U400.AE8 108.14,97.26 ; U400.AE8 107.84,97.56 ; U400.AG8 109.69,97.56 ; U400.AG8 110.28,97.56 ; U400.AG8 109.98,97.26 ; U400.AG8 109.98,97.85
  BOTTOM w0.152: U400.AK2 111.57,102.45 v1(112.02,102.9) ; U400.AF2 109.13,102.45 109.15,102.47 109.15,102.77 v1(109.3,102.93) ; v1(106.64,102.75) 106.69,102.7 U400.AB2
  BOTTOM w0.203: U400.V2 104.35,101.98 104.35,102.6 v1(104.42,102.68)
  BOTTOM w0.381: C592.2 102.98,106.86 v2(102.62,107.22) 101.58,108.26 C586.2
  vias: v1(105.82,97.72) v1(105.82,96.47) v1(106.75,97.7) v1(106.75,96.5) v1(107.67,97.7) v1(108.6,97.7) v1(108.6,96.5) v1(109.52,97.7) v1(110.45,97.7) v1(110.45,96.5) v1(111.37,97.7) v1(111.37,96.5) v1(112.29,97.7) v2(109.08,106) v2(110.7,104.32)
+VCCLDOSRAM: length 3.8
  TOP w0.254: C447.2 130.95,87.39 130.48,87.86 v1(130.48,87.99) ; C448.2 129.84,87.38 v1(129.84,88.03)
  BOTTOM w0.254: U400.BY23 130.14,88.38 129.84,88.09 v1(129.84,88.03) 129.84,87.85 130.11,87.58 U400.BY24
  BOTTOM w0.305: U400.CA23 130.79,88.3 v1(130.48,87.99) 130.48,87.89 U400.CA24
+VCCSFR: length 152.8
  TOP w0.254: U4701.M6 208.64,52.31 v2(208.76,52.43) 208.94,52.61 209.66,52.61 210.35,51.92 C4728.2
  IN1 w0.508: 125.19,108.21 127.85,108.21 129.21,109.57 131.7,109.57 132.11,109.98 136.72,109.98 139.48,112.75 142.01,112.75 142.4,113.15 148.26,113.15 149.37,114.25 157.05,114.25 158.45,112.86 160.64,112.86 165.91,107.59 167.42,107.59 168.37,106.64 177.78,106.64 177.84,106.58 179.72,106.58 v2(180.15,107)
  IN2 w0.508: v2(208.76,52.43) 207.71,53.48 207.71,54.37 206.16,55.92 203.39,55.92 203.19,56.12 201.53,56.12 200.26,57.4 199.49,57.4 198.65,58.24 196.67,58.24 195.83,59.07 194.56,59.07 193.71,58.21 192.43,58.21 191.57,59.07 188.47,59.07 187.06,60.48 186.77,60.48 184.66,62.59 184.66,63.91 183.79,64.78 183.79,65.83 183.26,66.36 183.26,68.93 182.16,70.03 182.16,71.04 182.16,71.04 182.16,72.14 180.39,73.92 180.39,74.03 179.92,74.5 179.92,75.68 v2(180.19,75.96)
  BOTTOM w0.127: 127.24,95.98 U400.BT11 127.54,96.27 ; U400.BR11 126.89,96.27 ; U400.BR11 126.59,95.98 ; U400.BR11 127.18,95.98 ; 126.24,96.27 U400.BP11 126.53,95.98
  BOTTOM w0.178: U400.BP2 126.21,102.77 v2(126.75,103.31)
  BOTTOM w0.508: v2(105.56,109.43) 105.9,109.08 R614.1 ; R613.1 v2(106.87,109.43) ; R400.2 v2(107.85,109.64) 107.92,109.71 R611.2 ; v2(180.19,75.96) 181.39,75.96 182.9,77.48 182.9,79.02 183.96,80.08 183.96,85.12 184.16,85.32 184.16,88.72 185.8,90.37 185.8,93.44 184.92,94.33 184.92,96.3 180.27,100.94 180.27,106.88 v2(180.15,107) ; v2(94.71,109.11) R606.2
  vias: v1(126.62,96.39) v1(127.19,96.55) v2(123.76,106.95) v2(124.16,107.44) v2(124.52,107.98)
+VCCST: length 281.1
  TOP w0.254: PR8804.1 v2(42.4,92.26) ; v2(39.73,92.31) 40.33,92.91 ; 40.33,92.91 PR8801.1 PR8803.1 PC8801.1 26.36,92.91 v2(26.25,93.02) ; 40.33,92.91 PR8802.1 ; PR9600.1 179.34,113.89 v2(179.08,114.15)
  IN1 w0.254: v2(26.25,93.02) 25.44,93.02 16.14,102.33 16.14,103.36 15.86,103.64 15.86,107.56 19.01,110.71 19.01,114.22 19.6,114.81 20.94,114.81 25.5,119.37 25.5,122.09 23.78,123.8 23.78,127.89 24.8,128.92 25.6,128.92 26.02,129.34 28.62,129.34 28.63,129.35 31.4,129.35 31.94,128.81 33.81,128.81 35.34,130.34 38.65,130.34 38.82,130.51 41.64,130.51 41.78,130.37 42.62,130.37 43.18,129.82 44.69,129.82 44.96,130.09 51.87,130.09 52.16,130.38 57.82,130.38 58.57,129.63 72.13,129.63 72.87,130.37 73.74,130.37 74.61,129.51 75.02,129.51 75.35,129.83 75.96,129.83 75.98,129.85 75.98,129.88 79.08,132.97 79.08,133.58 81.02,135.53 85.29,135.53 87.79,133.03 v2(88.15,133.03) ; v2(158.38,121.65) 159.36,120.66 159.36,119.28 160.05,118.59 160.05,116.68 160.36,116.37 160.36,114.14 159.94,113.72 158.86,113.72 157.46,115.12 149.33,115.12 148.95,114.74 145.14,114.74 144.26,115.63 143.3,115.63 142.59,114.91 140.75,114.91 137.98,112.15 v2(136.79,112.15)
  IN2 w0.254: v2(179.08,114.15) 179.08,113.75 178.62,113.29 176.54,113.29 175.36,112.11 172.55,112.11 171.83,112.83 169.11,112.83 165.32,116.63 163.39,116.63 v2(158.38,121.65) 157.91,122.12 155.98,122.12 155.7,122.4 151.66,122.4 151.11,121.84 143.42,121.84 142.45,120.87 141.86,120.87 141.41,121.33 135.4,121.33 135.05,121.68 133.68,121.68 133.48,121.49 132.26,121.49 131.66,122.1 121.46,122.1 117.65,118.28 115.29,118.28 115.01,118 109.84,118 108.97,117.13 105.87,117.13 99.94,123.05 91.22,123.05 88.15,126.13 v2(88.15,133.03)
  BOTTOM w0.254: v2(42.4,92.26) 41.61,93.05 40.47,93.05 v2(39.73,92.31)
  vias: v2(126.78,109.83) v2(127.03,110.42) v2(136.13,112.15)
+VCCST_ON: length 91.1
  TOP w0.254: PR9601.1 138.67,112.97 138.67,114.1 138.03,114.74 137.55,114.74 v2(137.52,114.76) ; PQ9601.2 179.92,112.17 179.69,112.4 179.69,113.11 179.38,113.42 179.13,113.42 v2(178.39,114.15) ; PU9600.4 123.86,115.59 127.48,119.2 130.63,119.2 133.1,121.67 134.18,121.67 v2(134.67,121.19) 134.98,120.88 142.58,120.88 147.7,125.99 158.52,125.99 158.96,126.42 v2(158.96,126.5)
  BOTTOM w0.254: v2(137.52,114.76) 137.52,115.12 138.03,115.63 138.03,117.33 136.94,118.42 135.77,118.42 134.7,119.48 134.7,120.88 134.67,120.92 v2(134.67,121.19) ; v2(158.96,126.5) 158.96,126.47 160.28,125.15 161.07,125.15 162.95,123.28 162.95,120.58 163.43,120.1 164.27,120.1 164.93,119.43 164.93,115.82 168.29,112.46 173.23,112.46 174,113.24 174,113.98 174.25,114.23 176.34,114.23 176.94,113.62 178.11,113.62 178.39,113.9 v2(178.39,114.15)
+VCCSTG: length 84.9
  TOP w0.254: v2(156.83,122.73) 153.52,122.73 v2(151.95,121.16) ; v2(175.2,113.72) PR9604.1
  IN1 w0.254: v2(132.16,112.4) 133.08,112.4 133.82,113.14 135.03,113.14 136.13,114.23 138.88,114.23 140.07,115.42 142.02,115.42 142.73,116.13 147.78,116.13 151.95,120.3 v2(151.95,121.16) ; v2(121.06,108.21) 120.18,109.1 115.92,109.1 114.95,110.06 110.38,110.06 109.34,111.1 107.42,111.1 107.16,110.85 101.58,110.85 v2(100.95,110.22)
  IN2 w0.254: v2(156.83,122.73) 158.37,122.73 163.95,117.14 165.53,117.14 169.32,113.34 172.04,113.34 172.77,112.62 174.09,112.62 v2(175.2,113.72)
  BOTTOM w0.254: R7738.1 104,106.84 103.56,107.27 103.56,108.11 102.82,108.85 R7737.1 102.8,109.91 102.04,110.67 101.41,110.67 v2(100.95,110.22) 100.95,108.26 101.94,107.27 R7736.1
  vias: v2(121.7,108.21) v2(131.58,112.65)
+VCCSTG_ON: length 80.4
  TOP w0.254: v2(173.51,113.44) 173.97,113.44 174.36,113.05 175.33,113.05 175.57,112.81 175.57,112.3 175.88,111.99 PQ9603.2 ; PU9601.4 134.23,112.33 134.05,112.16 133.31,112.16 PR9605.2 133,113.26 PR9617.1 132.69,113.57 131.02,113.57 130.26,112.81 127.52,112.81 127.03,113.3 125.53,113.3 124.72,114.1 124.72,115.94 127.63,118.84 130.77,118.84 132.45,120.52 142.73,120.52 147.84,125.63 158.78,125.63 159.59,126.45 v2(159.59,126.52)
  BOTTOM w0.254: v2(159.59,126.52) 159.74,126.52 160.55,125.71 161.02,125.71 163.31,123.42 163.31,120.73 163.58,120.45 164.42,120.45 165.29,119.58 165.29,115.96 168.44,112.82 172.88,112.82 v2(173.51,113.44)
+VIN: length 39.6
  TOP w0.305: PR8130.1 92.95,31.18 92.95,31.7 v2(94.8,33.56)
  TOP w0.381: PQ8202.1 101.88,35.93 95.86,35.93 94.8,34.88 v2(94.8,33.56) 95.92,32.44 PD8201.1
  BOTTOM w0.254: v2(174.29,23.51) 174.29,23.23 174.88,22.64 174.88,21.32 175.48,20.72 PR8610.1
  BOTTOM w0.381: v2(94.8,33.56) 94.8,34.5 95.78,35.47 103.53,35.47 105.44,33.56 112,33.56 112.12,33.43
  vias: v2(122.54,34.22) v2(123.17,34.22) v2(124.82,34.19) v2(130.41,32.85) v2(130.82,32.29) v2(131.19,33.19) v2(131.43,32.47) v2(131.91,33.13) v2(132.06,32.47)
+VIN_1.0V_DEEP_SUS: length 1
  BOTTOM w0.102: v2(127.12,129.47) 127.81,128.79 v4(127.86,128.79)
  vias: v4(128.6,128.79)
+VIN_1.8VPCU: length 13.8
  BOTTOM w1.27: 161.68,17.99 164.83,17.99 167.22,20.37 167.22,25.38 167.72,25.89 PC9307.1
  vias: v2(160.47,18.02) v2(160.97,22.64) v2(161.24,22.04)
+VIN_3VPCU:
  vias: v2(182.11,22.68) v2(182.11,22.05) v2(182.75,22.68) v2(182.75,22.05)
+VIN_5VPCU: length 0.8
  BOTTOM w0.254: v2(194.8,25.96) 194.42,25.58 PR8626.1
  vias: v2(188.34,22.71) v2(188.34,22.07) v2(188.28,21.42) v2(188.36,20.78) v2(188.89,20.4) v2(189.04,24.36) v2(189,21.04) v2(189.68,23.54)
+VIN_BLIGHT:
  vias: v2(46.64,125.76) v2(46.69,126.4)
+VIN_BLIGHT_L: length 4.8
  TOP w0.381: R3411.2 45.43,129.51 44.82,130.12 C3413.1 44.49,130.12 44.12,130.5 44.12,131.51 v2(43.78,131.84)
+VIN_CPU_GPU: length 213
  TOP w0.508: v2(61.69,54.63) 62.33,53.99 104.59,53.99 105.91,52.67 141.17,52.67 141.77,53.27 150.83,53.27 152.96,55.39 157.87,55.39 158.12,55.14 166.11,55.14 166.7,54.55 167.35,54.55 170.27,57.47 v2(171.32,57.47) ; v2(166.08,76.25) 163.91,76.25 162.39,74.73 161.98,74.73 160.97,73.72 160.35,73.72 158.61,71.97 158.61,70.67 160.03,69.25 163.23,69.25 v2(163.76,69.77) ; v2(69.98,74.37) 56.71,74.37 53.02,78.06 53.02,82.53 53.7,83.22 53.7,89.18 52.25,90.64 C7842.2 52.25,103.01 51.18,104.08 PR8807.1
  BOTTOM w0.254: CN7701.30 165.54,76.03 165.64,75.92 165.79,75.92 166.08,76.2 v2(166.08,76.25)
  BOTTOM w0.508: v2(171.32,57.47) 170.86,57.93 170.86,58.45 165.11,64.19 165.11,65.99 163.76,67.34 v2(163.76,69.77) ; v2(61.69,54.63) 62.44,55.38 62.97,55.38 65.74,58.15 65.74,62.97 68.46,65.69 68.46,68.03 69.68,69.25
+VIN_DDR: length 21.2
  TOP w0.203: v2(145.42,12.47) 146.2,11.69 151.29,11.69 151.45,11.53 v2(151.45,11.11)
  BOTTOM w0.203: v2(145.42,12.47) 145.02,12.47 PR8704.2 ; v2(151.45,11.11) 151.45,13.68 154.97,17.21 154.97,19.82 153.02,21.77 PC8704.1
  vias: v2(152.1,22.98) v2(152.11,22.34)
+VIN_VCC_CORE:
  vias: v2(54.54,128.14) v2(55.17,128.14) v2(55.81,128.14) v2(58.23,94.83) v2(58.28,97.59) v2(58.91,97.59) v2(58.94,94.82) v2(59.24,97.03) v2(59.55,97.59) v2(59.9,97.03) v2(60.18,97.59) v4(59.09,117.76) v4(59.85,117.76) v4(60.61,117.76) v4(61.37,117.76) v4(62.09,117.96) v4(62.06,117.2) v4(62.75,111.21) v4(62.75,110.44) v4(62.82,117.94) v4(62.8,117.2) v4(62.77,109.68) v4(62.77,108.92) v4(106.31,123.04) v4(107.12,123.02)
AGND: length 6.2
  TOP w0.203: U3600.19 220.59,8.64 v2(220.66,8.57) ; U3600.13 218.18,9.13 218.04,8.98 v2(218.04,8.56)
  TOP w0.381: v2(225.83,15.16) 226.2,15.53 C3601.1 ; v2(222.21,9.28) 222.6,8.89 C3621.1 C3620.2 ; v2(219.12,7.7) 218.84,7.98 C3610.1
  vias: v2(221.5,15.52) v2(222,15.97) v2(222.51,16.92) v2(224.14,22.18) v2(224.33,22.81) v2(224.67,21.49) v2(224.72,20.84) v2(224.66,18) v2(224.76,22.12) v2(224.97,22.72) v2(225.03,9.3) v2(225.05,8.64) v2(225.6,22.74) v2(225.69,9.28) v2(227.77,19.31) v2(227.9,12.55) v2(228.3,17.46) v2(228.41,15.42) v2(228.56,11) v2(229.72,22.24) v2(229.95,22.92) v2(230.72,22.92) v2(231.48,22.94) v2(238.36,21.87)
