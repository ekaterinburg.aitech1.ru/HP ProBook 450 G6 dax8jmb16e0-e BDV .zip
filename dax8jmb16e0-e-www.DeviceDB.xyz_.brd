# Allegro board dax8jmb16e0-e-www.DeviceDB.xyz_.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
BSH-030-01-L-D-A-TR-60P-RUV
  round 1.016 hole 1.016 unplated: (-10.063,-2.666) (10.063,-2.666)
  rect 0.279x2.261 smd: 1(7.25,2.864) 2(7.25,-2.864) 3(6.75,2.864) 4(6.75,-2.864) 5(6.25,2.864) 6(6.25,-2.864) 7(5.75,2.864) 8(5.75,-2.864) 9(5.25,2.864) 10(5.25,-2.864) 11(4.75,2.864) 12(4.75,-2.864) 13(4.25,2.864) 14(4.25,-2.864) 15(3.75,2.864) 16(3.75,-2.864) 17(3.25,2.864) 18(3.25,-2.864) 19(2.75,2.864) 20(2.75,-2.864) 21(2.25,2.864) 22(2.25,-2.864) 23(1.75,2.864) 24(1.75,-2.864) 25(1.25,2.864) 26(1.25,-2.864) 27(0.75,2.864) 28(0.75,-2.864) 29(0.25,2.864) 30(0.25,-2.864) 31(-0.25,2.864) 32(-0.25,-2.864) 33(-0.75,2.864) 34(-0.75,-2.864) 35(-1.25,2.864) 36(-1.25,-2.864) 37(-1.75,2.864) 38(-1.75,-2.864) 39(-2.25,2.864) 40(-2.25,-2.864) 41(-2.75,2.864) 42(-2.75,-2.864) 43(-3.25,2.864) 44(-3.25,-2.864) 45(-3.75,2.864) 46(-3.75,-2.864) 47(-4.25,2.864) 48(-4.25,-2.864) 49(-4.75,2.864) 50(-4.75,-2.864) 51(-5.25,2.864) 52(-5.25,-2.864) 53(-5.75,2.864) 54(-5.75,-2.864) 55(-6.25,2.864) 56(-6.25,-2.864) 57(-6.75,2.864) 58(-6.75,-2.864) 59(-7.25,2.864) 60(-7.25,-2.864)
C0201
  rect 0.203x0.381 smd: 1(-0.225,0) 2(0.225,0)
C0402
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
C0402_2
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
C0603
  rect 0.686x0.813 smd: 1(0.6,0) 2(-0.6,0)
C0805
  rect 0.864x1.372 smd: 1(0.88,0) 2(-0.88,0)
C3528
  rect 1.6x2.591 smd: 1(1.5,0) 2(-1.5,0)
CC1808
  rect 2.159x2.286 smd: 1(-2.349,0) 2(2.349,0)
CC7343
  rect 2.413x2.819 smd: 1(-3.2,0) 2(3.2,0)
CC7343-3H
  rect 2.388x2.896 smd: 1(-3.05,0) 2(3.05,0)
CHOKE-DLP0NSN900HL2L
  rect 0.305x0.305 smd: 1(-0.25,-0.3) 2(-0.25,0.3) 3(0.25,0.3) 4(0.25,-0.3)
CHOKE-DLP11SN900HL2L-4P-1
  rect 0.711x0.305 smd: 1(-0.625,0.275) 2(0.625,0.275) 3(0.625,-0.275) 4(-0.625,-0.275)
CHOKE-ETQP4L
  rect 2.896x4.293 smd: 1(-4.216,0) 2(4.216,0)
CHOKE-PCMC063T-3R3MN-SMT
  rect 1.854x3.505 smd: 1(-3.275,0) 2(3.275,0)
D-1X0_6-0_6H
  rect 0.559x0.61 smd: 1(-0.425,0) 2(0.425,0)
D-3_8X2_5
  rect 1.6x1.905 smd: 1(-2.15,0) 2(2.15,0)
D-4_3X2_7
  rect 2.057x2.057 smd: 1(-1.865,0) 2(1.865,0)
D-SOD323-1_7X1_25-PMEG4005AEA
  rect 0.61x0.61 smd: 1(-1.1,0) 2(1.1,0)
D-SOD323-1_85X1_25-0_95H
  rect 0.559x0.813 smd: 1(-1.15,0) 2(1.15,0)
DDR4-D4AR0-26010-1P40-RVS-SMT
  round 1.092 hole 1.092 unplated: (-34.4,0)
  round 1.6 hole 1.6 unplated: (34.4,0)
  rect 0.254x1.753 smd: 1(33.375,4.1) 2(33.125,-4.1) 3(32.875,4.1) 4(32.625,-4.1) 5(32.375,4.1) 6(32.125,-4.1) 7(31.875,4.1) 8(31.625,-4.1) 9(31.375,4.1) 10(31.125,-4.1) 11(30.875,4.1) 12(30.625,-4.1) 13(30.375,4.1) 14(30.125,-4.1) 15(29.875,4.1) 16(29.625,-4.1) 17(29.375,4.1) 18(29.125,-4.1) 19(28.875,4.1) 20(28.625,-4.1) 21(28.375,4.1) 22(28.125,-4.1) 23(27.875,4.1) 24(27.625,-4.1) 25(27.375,4.1) 26(27.125,-4.1) 27(26.875,4.1) 28(26.625,-4.1) 29(26.375,4.1) 30(26.125,-4.1) 31(25.875,4.1) 32(25.625,-4.1) 33(25.375,4.1) 34(25.125,-4.1) 35(24.875,4.1) 36(24.625,-4.1) 37(24.375,4.1) 38(24.125,-4.1) 39(23.875,4.1) 40(23.625,-4.1) 41(23.375,4.1) 42(23.125,-4.1) 43(22.875,4.1) 44(22.625,-4.1) 45(22.375,4.1) 46(22.125,-4.1) 47(21.875,4.1) 48(21.625,-4.1) 49(21.375,4.1) 50(21.125,-4.1) 51(20.875,4.1) 52(20.625,-4.1) 53(20.375,4.1) 54(20.125,-4.1) 55(19.875,4.1) 56(19.625,-4.1) 57(19.375,4.1) 58(19.125,-4.1) 59(18.875,4.1) 60(18.625,-4.1) 61(18.375,4.1) 62(18.125,-4.1) 63(17.875,4.1) 64(17.625,-4.1) 65(17.375,4.1) 66(17.125,-4.1) 67(16.875,4.1) 68(16.625,-4.1) 69(16.375,4.1) 70(16.125,-4.1) 71(15.875,4.1) 72(15.625,-4.1) 73(15.375,4.1) 74(15.125,-4.1) 75(14.875,4.1) 76(14.625,-4.1) 77(14.375,4.1) 78(14.125,-4.1) 79(13.875,4.1) 80(13.625,-4.1) 81(13.375,4.1) 82(13.125,-4.1) 83(12.875,4.1) 84(12.625,-4.1) 85(12.375,4.1) 86(12.125,-4.1) 87(11.875,4.1) 88(11.625,-4.1) 89(11.375,4.1) 90(11.125,-4.1) 91(10.875,4.1) 92(10.625,-4.1) 93(10.375,4.1) 94(10.125,-4.1) 95(9.875,4.1) 96(9.625,-4.1) 97(9.375,4.1) 98(9.125,-4.1) 99(8.875,4.1) 100(8.625,-4.1) 101(8.375,4.1) 102(8.125,-4.1) 103(7.875,4.1) 104(7.625,-4.1) 105(7.375,4.1) 106(7.125,-4.1) 107(6.875,4.1) 108(6.625,-4.1) 109(6.375,4.1) 110(6.125,-4.1) 111(5.875,4.1) 112(5.625,-4.1) 113(5.375,4.1) 114(5.125,-4.1) 115(4.875,4.1) 116(4.625,-4.1) 117(4.375,4.1) 118(4.125,-4.1) 119(3.875,4.1) 120(3.625,-4.1) 121(3.375,4.1) 122(3.125,-4.1) 123(2.875,4.1) 124(2.625,-4.1) 125(2.375,4.1) 126(2.125,-4.1) 127(1.875,4.1) 128(1.625,-4.1) 129(1.375,4.1) 130(1.125,-4.1) 131(0.875,4.1) 132(0.625,-4.1) 133(0.375,4.1) 134(0.125,-4.1) 135(-0.125,4.1) 136(-0.375,-4.1) 137(-0.625,4.1) 138(-0.875,-4.1) 139(-1.125,4.1) 140(-1.375,-4.1) 141(-1.625,4.1) 142(-1.875,-4.1) 143(-2.125,4.1) 144(-2.375,-4.1) 145(-4.625,4.1) 146(-4.875,-4.1) 147(-5.125,4.1) 148(-5.375,-4.1) 149(-5.625,4.1) 150(-5.875,-4.1) 151(-6.125,4.1) 152(-6.375,-4.1) 153(-6.625,4.1) 154(-6.875,-4.1) 155(-7.125,4.1) 156(-7.375,-4.1) 157(-7.625,4.1) 158(-7.875,-4.1) 159(-8.125,4.1) 160(-8.375,-4.1) 161(-8.625,4.1) 162(-8.875,-4.1) 163(-9.125,4.1) 164(-9.375,-4.1) 165(-9.625,4.1) 166(-9.875,-4.1) 167(-10.125,4.1) 168(-10.375,-4.1) 169(-10.625,4.1) 170(-10.875,-4.1) 171(-11.125,4.1) 172(-11.375,-4.1) 173(-11.625,4.1) 174(-11.875,-4.1) 175(-12.125,4.1) 176(-12.375,-4.1) 177(-12.625,4.1) 178(-12.875,-4.1) 179(-13.125,4.1) 180(-13.375,-4.1) 181(-13.625,4.1) 182(-13.875,-4.1) 183(-14.125,4.1) 184(-14.375,-4.1) 185(-14.625,4.1) 186(-14.875,-4.1) 187(-15.125,4.1) 188(-15.375,-4.1) 189(-15.625,4.1) 190(-15.875,-4.1) 191(-16.125,4.1) 192(-16.375,-4.1) 193(-16.625,4.1) 194(-16.875,-4.1) 195(-17.125,4.1) 196(-17.375,-4.1) 197(-17.625,4.1) 198(-17.875,-4.1) 199(-18.125,4.1) 200(-18.375,-4.1) 201(-18.625,4.1) 202(-18.875,-4.1) 203(-19.125,4.1) 204(-19.375,-4.1) 205(-19.625,4.1) 206(-19.875,-4.1) 207(-20.125,4.1) 208(-20.375,-4.1) 209(-20.625,4.1) 210(-20.875,-4.1) 211(-21.125,4.1) 212(-21.375,-4.1) 213(-21.625,4.1) 214(-21.875,-4.1) 215(-22.125,4.1) 216(-22.375,-4.1) 217(-22.625,4.1) 218(-22.875,-4.1) 219(-23.125,4.1) 220(-23.375,-4.1) 221(-23.625,4.1) 222(-23.875,-4.1) 223(-24.125,4.1) 224(-24.375,-4.1) 225(-24.625,4.1) 226(-24.875,-4.1) 227(-25.125,4.1) 228(-25.375,-4.1) 229(-25.625,4.1) 230(-25.875,-4.1) 231(-26.125,4.1) 232(-26.375,-4.1) 233(-26.625,4.1) 234(-26.875,-4.1) 235(-27.125,4.1) 236(-27.375,-4.1) 237(-27.625,4.1) 238(-27.875,-4.1) 239(-28.125,4.1) 240(-28.375,-4.1) 241(-28.625,4.1) 242(-28.875,-4.1) 243(-29.125,4.1) 244(-29.375,-4.1) 245(-29.625,4.1) 246(-29.875,-4.1) 247(-30.125,4.1) 248(-30.375,-4.1) 249(-30.625,4.1) 250(-30.875,-4.1) 251(-31.125,4.1) 252(-31.375,-4.1) 253(-31.625,4.1) 254(-31.875,-4.1) 255(-32.125,4.1) 256(-32.375,-4.1) 257(-32.625,4.1) 258(-32.875,-4.1) 259(-33.125,4.1) 260(-33.375,-4.1)
  rect 3.505x4.597 smd: 261(33.8,12) 262(-33.8,12)
DFN1006H4-3-1X0_6-3P
  rect 0.406x0.254 smd: 1(0.35,0.225) 2(0.35,-0.225)
  rect 0.406x0.711 smd: 3(-0.35,0)
DFN-8L-3X3-65-5P-0_9H
  rect 0.508x0.356 smd: 1(1.4,-0.975) 2(1.4,-0.325) 3(1.4,0.325) 4(1.4,0.975)
  custom 0.57x0.57 smd: 5(-0.51,0)
DSM
  rect 1.016x0.508 smd: 1(-1.3,0) 2(1.321,0)
ECAP7X3_5-7_2
  rect 3.505x2.007 smd: 1(2.7,0) 2(-2.7,0)
F2_1X1_35-2_2-0_75H
  rect 0.991x1.499 smd: 1(-1.1,0) 2(1.1,0)
F4_55X3_24-5_23-1_8H
  rect 1.778x3.505 smd: 1(-2.615,0) 2(2.615,0)
FH34S-8S-0_5SH-8P-L
  rect 0.305x0.787 smd: 1(-1.75,2.5) 2(-1.25,2.5) 3(-0.75,2.5) 4(-0.25,2.5) 5(0.25,2.5) 6(0.75,2.5) 7(1.25,2.5) 8(1.75,2.5)
  rect 0.406x0.787 smd: 9(-2.75,0) 10(2.75,0)
FILTER-MCM2012B900GBE-4P
  rect 0.762x0.406 smd: 1(-0.925,0.4) 2(0.925,0.4) 3(0.925,-0.4) 4(-0.925,-0.4)
FPC-51519-02201-V01-22P-L
  rect 0.305x1.295 smd: 1(-5.25,5.65) 2(-4.75,5.65) 3(-4.25,5.65) 4(-3.75,5.65) 5(-3.25,5.65) 6(-2.75,5.65) 7(-2.25,5.65) 8(-1.75,5.65) 9(-1.25,5.65) 10(-0.75,5.65) 11(-0.25,5.65) 12(0.25,5.65) 13(0.75,5.65) 14(1.25,5.65) 15(1.75,5.65) 16(2.25,5.65) 17(2.75,5.65) 18(3.25,5.65) 19(3.75,5.65) 20(4.25,5.65) 21(4.75,5.65) 22(5.25,5.65)
  rect 1.803x2.21 smd: 23(-7.4,0) 24(7.4,0)
FPC-51625-0100T-V01-10P-L
  rect 0.305x0.838 smd: 1(-2.25,3.18) 2(-1.75,3.18) 3(-1.25,3.18) 4(-0.75,3.18) 5(-0.25,3.18) 6(0.25,3.18) 7(0.75,3.18) 8(1.25,3.18) 9(1.75,3.18) 10(2.25,3.18)
  rect 0.787x2.007 smd: 11(-3.95,0) 12(3.95,0)
FPC-CF5020FD0RT-05-NH-20P-L
  rect 0.305x0.94 smd: 1(-4.75,3.375) 2(-4.25,3.375) 3(-3.75,3.375) 4(-3.25,3.375) 5(-2.75,3.375) 6(-2.25,3.375) 7(-1.75,3.375) 8(-1.25,3.375) 9(-0.75,3.375) 10(-0.25,3.375) 11(0.25,3.375) 12(0.75,3.375) 13(1.25,3.375) 14(1.75,3.375) 15(2.25,3.375) 16(2.75,3.375) 17(3.25,3.375) 18(3.75,3.375) 19(4.25,3.375) 20(4.75,3.375)
  rect 1.651x1.397 smd: 21(-7.075,0) 22(7.075,0)
H-415WD-1
  round 7.01 hole 2.489: 1(0,0)
H-415WD-2
  custom 2x2 hole 2.311: 1(0,0)
H-C138D83PT
  round 3.505 hole 2.108: 1(0,0)
H-C217D98P2
  round 5.512 hole 2.489: 1(0,0)
H-C276D91P2
  round 7.01 hole 2.311: 1(0,0)
H-C276D98P2
  round 7.01 hole 2.489: 1(0,0)
H-C276I91D91P2
  round 7.01 hole 2.311: 1(0,0)
H-C315I252D252P2
  round 8.001 hole 6.401: 1(0,0)
H-O63X83D63X83N
  oval 1.6x2.108 hole 1.6x2.108 unplated: (0,0)
H-O122X83D122X83N
  oval 3.099x2.108 hole 3.099x2.108 unplated: (0,0)
H-O177X138D122X83PT
  oval 4.496x3.505 hole 3.099x2.108: 1(0,0)
H-O374X276D189X91P2
  oval 9.5x7.01 hole 4.801x2.311: 1(0,0)
H-TC150IC150BC197D150PB
  round 5.004 hole 3.81: 1(0,0)
H-TC197IC122D122PT
  round 3.099 hole 3.099: 1(0,0)
H-TC236BC91D91PT
  round 5.994 hole 2.311: 1(0,0)
H-TC315BC276D91P2
  round 8.001 hole 2.311: 1(0,0)
H-TC315IC91BC276D91P2
  round 8.001 hole 2.311: 1(0,0)
HDMI-HMRF2-AK520C-20P-SMT
  round 0.813 hole 0.559: 1(-4.5,2.05) 2(-4,3.6) 3(-3.5,2.05) 4(-3,3.6) 5(-2.5,2.05) 6(-2,3.6) 7(-1.5,2.05) 8(-1,3.6) 9(-0.5,2.05) 10(0,3.6) 11(0.5,2.05) 12(1,3.6) 13(1.5,2.05) 14(2,3.6) 15(2.5,2.05) 16(3,3.6) 17(3.5,2.05) 18(4,3.6) 19(4.5,2.05)
  oval 1.499x2.489 hole 0.889x1.905: 20(-9.15,0) 21(9.15,0)
  rect 1.854x3.505 hole 0.889x1.6: 22(-9.15,-4.45) 23(9.15,-5.05)
L2_5X2-1_2H
  rect 0.889x2.108 smd: 1(-0.85,0) 2(0.85,0)
L3_2X2_5-3_2
  rect 1.194x2.007 smd: 1(-1.6,0) 2(1.6,0)
L6_6X6_6-2_8H
  rect 2.362x3.505 smd: 1(-3.025,0) 2(3.025,0)
LGA12-2X2-5
  rect 0.305x0.406 smd: 1(-0.75,-0.8) 2(-0.25,-0.8) 3(0.25,-0.8) 4(0.75,-0.8) 7(0.75,0.8) 8(0.25,0.8) 9(-0.25,0.8) 10(-0.75,0.8)
  rect 0.406x0.305 smd: 5(0.8,-0.25) 6(0.8,0.25) 11(-0.8,0.25) 12(-0.8,-0.25)
LGA12-2X2-5-HP2DCTR
  rect 0.305x0.406 smd: 1(-0.75,-0.763) 2(-0.25,-0.763) 3(0.25,-0.763) 4(0.75,-0.763) 7(0.75,0.763) 8(0.25,0.763) 9(-0.25,0.763) 10(-0.75,0.763)
  rect 0.406x0.254 smd: 5(0.763,-0.25) 6(0.763,0.25) 11(-0.763,0.25) 12(-0.763,-0.25)
MSOP8-4_9-65
  rect 0.406x1.448 smd: 1(-0.975,-2.325) 2(-0.325,-2.325) 3(0.325,-2.325) 4(0.975,-2.325) 5(0.975,2.325) 6(0.325,2.325) 7(-0.325,2.325) 8(-0.975,2.325)
NGFF-NFSB0-S6710-TPH4-KB-SMT
  round 1.194 hole 1.194 unplated: (-10,0)
  round 1.702 hole 1.702 unplated: (10,0)
  rect 0.305x1.549 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 8(-7.5,-2.275) 9(-7.25,5.275) 10(-7,-2.275) 11(-6.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 24(-3.5,-2.275) 25(-3.25,5.275) 26(-3,-2.275) 27(-2.75,5.275) 28(-2.5,-2.275) 29(-2.25,5.275) 30(-2,-2.275) 31(-1.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 59(5.25,5.275) 60(5.5,-2.275) 61(5.75,5.275) 62(6,-2.275) 63(6.25,5.275) 64(6.5,-2.275) 65(6.75,5.275) 66(7,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
NGFF-NFSE0-S6710-TPH4-KE-SMT
  round 1.194 hole 1.194 unplated: (-10,0)
  round 1.702 hole 1.702 unplated: (10,0)
  rect 0.305x1.549 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 8(-7.5,-2.275) 9(-7.25,5.275) 10(-7,-2.275) 11(-6.75,5.275) 12(-6.5,-2.275) 13(-6.25,5.275) 14(-6,-2.275) 15(-5.75,5.275) 16(-5.5,-2.275) 17(-5.25,5.275) 18(-5,-2.275) 19(-4.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 59(5.25,5.275) 60(5.5,-2.275) 61(5.75,5.275) 62(6,-2.275) 63(6.25,5.275) 64(6.5,-2.275) 65(6.75,5.275) 66(7,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
NGFF-NFSM0-S6710-TPH4-75P-KM
  round 1.194 hole 1.194 unplated: (-10,0)
  round 1.702 hole 1.702 unplated: (10,0)
  rect 0.279x1.549 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 8(-7.5,-2.275) 9(-7.25,5.275) 10(-7,-2.275) 11(-6.75,5.275) 12(-6.5,-2.275) 13(-6.25,5.275) 14(-6,-2.275) 15(-5.75,5.275) 16(-5.5,-2.275) 17(-5.25,5.275) 18(-5,-2.275) 19(-4.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 24(-3.5,-2.275) 25(-3.25,5.275) 26(-3,-2.275) 27(-2.75,5.275) 28(-2.5,-2.275) 29(-2.25,5.275) 30(-2,-2.275) 31(-1.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
O-X8J-1-1P2
  round 7.01 hole 2.794: 1(0,0)
O-X8J-2-1P2
  round 7.01 hole 2.794: 1(0,0)
PG-TSDSON-8-8P-R
  rect 0.787x0.33 smd: 1(1.5,-0.975) 2(1.5,-0.325) 3(1.5,0.325) 4(1.5,0.975)
  custom 0.573x0.573 smd: 5(-0.72,0)
  rect 0.66x0.33 smd: 6(-1.575,0.325) 7(-1.575,-0.325) 8(-1.575,-0.975)
POWER-3_1X3_1-65-5P
  rect 0.406x0.406 smd: 1(1.55,-0.975) 2(1.55,-0.325) 3(1.55,0.325) 4(1.55,0.975)
  custom 0.625x0.625 smd: 5(-0.5,0)
POWER-5_2X5_55-1_27-5P
  rect 0.66x0.508 smd: 1(2.755,-1.905) 2(2.755,-0.635) 3(2.755,0.635) 4(2.755,1.905)
  custom 1.15x1.15 smd: 5(0,0)
POWER-5X6-1_27-7P-0_8H
  rect 0.66x0.635 smd: 1(-1.905,-2.84) 5(1.905,2.84) 6(0.635,2.84) 7(-0.635,2.84) 8(-1.905,2.84)
  custom 0.488x0.488 smd: 2(0,-2.18)
  rect 3.988x2.667 smd: 9(0,0.795)
POWER-5X6-1_27-10P
  rect 0.61x0.61 smd: 1(-1.905,-2.75) 2(-0.635,-2.75) 3(0.635,-2.75) 4(1.905,-2.75) 5(1.905,2.75) 6(0.635,2.75) 7(-0.635,2.75)
  rect 0.61x1.676 smd: 8(-1.905,2.21)
  rect 4.191x1.041 smd: 9(0,-1.535)
  custom 0.617x0.617 smd: 10(0,0)
QFN8-1_2X1-4
  rect 0.178x0.381 smd: 1(-0.4,-0.46) 3(0.4,-0.46) 5(0.4,0.46) 6(0,0.46) 7(-0.4,0.46)
  rect 0.178x0.508 smd: 2(0,-0.398)
  rect 0.381x0.178 smd: 4(0.56,0) 8(-0.56,0)
QFN12-3X2-5-13P
  rect 0.254x0.711 smd: 1(-0.25,-1.5) 2(0.25,-1.5) 7(0.25,1.5) 8(-0.25,1.5)
  rect 0.711x0.254 smd: 3(1,-0.75) 4(1,-0.25) 5(1,0.25) 6(1,0.75) 9(-1,0.75) 10(-1,0.25) 11(-1,-0.25) 12(-1,-0.75)
  rect 0.838x1.854 smd: 13(0,0)
QFN13-2X3-5
  rect 0.254x1.499 smd: 1(-0.5,-0.55) 2(0.5,-0.55) 8(0,0.55)
  rect 0.711x0.254 smd: 3(1.45,-0.75) 4(1.45,-0.25) 5(1.45,0.25) 6(1.45,0.75) 10(-1.45,0.75) 11(-1.45,0.25) 12(-1.45,-0.25) 13(-1.45,-0.75)
  rect 0.254x0.711 smd: 7(0.5,0.95) 9(-0.5,0.95)
QFN13-4X3-45
  custom 0.337x0.337 smd: 1(0.25,-1.68)
  rect 1.702x0.457 smd: 2(1,-0.5) 12(-1,-0.5)
  rect 1.702x0.838 smd: 3(1,0.38) 11(-1,0.38)
  rect 0.787x0.203 smd: 4(1.45,1.13) 10(-1.45,1.13)
  rect 0.254x0.787 smd: 5(0.9,1.95) 6(0.45,1.95) 7(0,1.95) 8(-0.45,1.95) 9(-0.9,1.95)
  rect 0.787x0.254 smd: 13(-1.45,-1.125)
QFN20-3X3-45-21P
  custom 0.062x0.062 smd: 1(-0.9,-1.375) 5(0.9,-1.375) 6(1.375,-0.9) 10(1.375,0.9) 11(0.9,1.375) 15(-0.9,1.375) 16(-1.375,0.9) 20(-1.375,-0.9)
  rect 0.254x0.66 smd: 2(-0.45,-1.375) 3(0,-1.375) 4(0.45,-1.375) 12(0.45,1.375) 13(0,1.375) 14(-0.45,1.375)
  rect 0.66x0.254 smd: 7(1.375,-0.45) 8(1.375,0) 9(1.375,0.45) 17(-1.375,0.45) 18(-1.375,0) 19(-1.375,-0.45)
  rect 1.295x1.295 smd: 21(0,0)
QFN23-4X4-5-20P
  rect 0.254x0.457 smd: 1(-1.25,-1.825) 2(-0.75,-1.825) 3(-0.25,-1.825) 4(0.25,-1.825) 5(0.75,-1.825) 6(1.25,-1.825) 12(1.25,1.825) 13(0.75,1.825) 14(0.25,1.825) 15(-0.25,1.825) 16(-0.75,1.825) 17(-1.25,1.825)
  custom 0.346x0.346 smd: 7(1.825,-1.25)
  custom 0.249x0.249 smd: 10(1.825,0.75)
  rect 0.457x0.254 smd: 18(-1.825,1.25) 19(-1.825,0.75) 20(-1.825,0.25) 21(-1.825,-0.25) 22(-1.825,-0.75) 23(-1.825,-1.25)
QFN28-4X4-4-29P-ANX7411
  rect 0.203x0.991 smd: 1(-1.2,-2.1) 2(-0.8,-2.1) 3(-0.4,-2.1) 4(0,-2.1) 5(0.4,-2.1) 6(0.8,-2.1) 7(1.2,-2.1) 15(1.2,2.1) 16(0.8,2.1) 17(0.4,2.1) 18(0,2.1) 19(-0.4,2.1) 20(-0.8,2.1) 21(-1.2,2.1)
  rect 0.991x0.203 smd: 8(2.1,-1.2) 9(2.1,-0.8) 10(2.1,-0.4) 11(2.1,0) 12(2.1,0.4) 13(2.1,0.8) 14(2.1,1.2) 22(-2.1,1.2) 23(-2.1,0.8) 24(-2.1,0.4) 25(-2.1,0) 26(-2.1,-0.4) 27(-2.1,-0.8) 28(-2.1,-1.2)
  rect 2.591x2.591 smd: 29(0,0)
QFN28-4X4-4-38P
  custom 0.05x0.05 smd: 1(-1.2,-2) 2(-0.8,-2) 3(-0.4,-2) 4(0,-2) 5(0.4,-2) 6(0.8,-2) 7(1.2,-2) 8(2,-1.2) 9(2,-0.8) 10(2,-0.4) 11(2,0) 12(2,0.4) 13(2,0.8) 14(2,1.2) 15(1.2,2) 16(0.8,2) 17(0.4,2) 18(0,2) 19(-0.4,2) 20(-0.8,2) 21(-1.2,2) 22(-2,1.2) 23(-2,0.8) 24(-2,0.4) 25(-2,0) 26(-2,-0.4) 27(-2,-0.8) 28(-2,-1.2)
  rect 2.591x2.591 smd: 29(0,0)
  round 0.508 hole 0.254: 30(-1,-1) 31(0,-1) 32(1,-1) 33(1,0) 34(1,1) 35(0,1) 36(-1,1) 37(-1,0) 38(0,0)
QFN32-4X4-4-33P-0_9H
  custom 0.051x0.051 smd: 1(-1.4,-2.1) 8(1.4,-2.1) 9(2.1,-1.4) 16(2.1,1.4) 17(1.4,2.1) 24(-1.4,2.1) 25(-2.1,1.4) 32(-2.1,-1.4)
  rect 0.203x0.991 smd: 2(-1,-2.1) 3(-0.6,-2.1) 4(-0.2,-2.1) 5(0.2,-2.1) 6(0.6,-2.1) 7(1,-2.1) 18(1,2.1) 19(0.6,2.1) 20(0.2,2.1) 21(-0.2,2.1) 22(-0.6,2.1) 23(-1,2.1)
  rect 0.991x0.203 smd: 10(2.1,-1) 11(2.1,-0.6) 12(2.1,-0.2) 13(2.1,0.2) 14(2.1,0.6) 15(2.1,1) 26(-2.1,1) 27(-2.1,0.6) 28(-2.1,0.2) 29(-2.1,-0.2) 30(-2.1,-0.6) 31(-2.1,-1)
  rect 2.692x2.692 smd: 33(0,0)
QFN32-5X5-5-33P-SLB9645VQ
  rect 0.254x0.711 smd: 1(-1.75,-2.4) 2(-1.25,-2.4) 3(-0.75,-2.4) 4(-0.25,-2.4) 5(0.25,-2.4) 6(0.75,-2.4) 7(1.25,-2.4) 8(1.75,-2.4) 17(1.75,2.4) 18(1.25,2.4) 19(0.75,2.4) 20(0.25,2.4) 21(-0.25,2.4) 22(-0.75,2.4) 23(-1.25,2.4) 24(-1.75,2.4)
  rect 0.711x0.254 smd: 9(2.4,-1.75) 10(2.4,-1.25) 11(2.4,-0.75) 12(2.4,-0.25) 13(2.4,0.25) 14(2.4,0.75) 15(2.4,1.25) 16(2.4,1.75) 25(-2.4,1.75) 26(-2.4,1.25) 27(-2.4,0.75) 28(-2.4,0.25) 29(-2.4,-0.25) 30(-2.4,-0.75) 31(-2.4,-1.25) 32(-2.4,-1.75)
  rect 3.607x3.607 smd: 33(0,0)
QFN40-5X5-4-41P-SMB349NT
  rect 0.203x0.991 smd: 1(-1.8,-2.6) 2(-1.4,-2.6) 3(-1,-2.6) 4(-0.6,-2.6) 5(-0.2,-2.6) 6(0.2,-2.6) 7(0.6,-2.6) 8(1,-2.6) 9(1.4,-2.6) 10(1.8,-2.6) 21(1.8,2.6) 22(1.4,2.6) 23(1,2.6) 24(0.6,2.6) 25(0.2,2.6) 26(-0.2,2.6) 27(-0.6,2.6) 28(-1,2.6) 29(-1.4,2.6) 30(-1.8,2.6)
  rect 0.991x0.203 smd: 11(2.6,-1.8) 12(2.6,-1.4) 13(2.6,-1) 14(2.6,-0.6) 15(2.6,-0.2) 16(2.6,0.2) 17(2.6,0.6) 18(2.6,1) 19(2.6,1.4) 20(2.6,1.8) 31(-2.6,1.8) 32(-2.6,1.4) 33(-2.6,1) 34(-2.6,0.6) 35(-2.6,0.2) 36(-2.6,-0.2) 37(-2.6,-0.6) 38(-2.6,-1) 39(-2.6,-1.4) 40(-2.6,-1.8)
  rect 3.607x3.607 smd: 41(0,0)
QFN40-6X4-4-41P-0_8H
  custom 0.05x0.05 smd: 1(-1.4,-2.975) 2(-1,-2.975) 3(-0.6,-2.975) 4(-0.2,-2.975) 5(0.2,-2.975) 6(0.6,-2.975) 7(1,-2.975) 8(1.4,-2.975) 9(1.975,-2.2) 10(1.975,-1.8) 11(1.975,-1.4) 12(1.975,-1) 13(1.975,-0.6) 14(1.975,-0.2) 15(1.975,0.2) 16(1.975,0.6) 17(1.975,1) 18(1.975,1.4) 19(1.975,1.8) 20(1.975,2.2) 21(1.4,2.975) 22(1,2.975) 23(0.6,2.975) 24(0.2,2.975) 25(-0.2,2.975) 26(-0.6,2.975) 27(-1,2.975) 28(-1.4,2.975) 29(-1.975,2.2) 30(-1.975,1.8) 31(-1.975,1.4) 32(-1.975,1) 33(-1.975,0.6) 34(-1.975,0.2) 35(-1.975,-0.2) 36(-1.975,-0.6) 37(-1.975,-1) 38(-1.975,-1.4) 39(-1.975,-1.8) 40(-1.975,-2.2)
  rect 2.692x4.699 smd: 41(0,0)
QFN40-6X6-5-41P-0_6H
  rect 0.305x0.991 smd: 1(-2.25,-3.1) 2(-1.75,-3.1) 3(-1.25,-3.1) 4(-0.75,-3.1) 5(-0.25,-3.1) 6(0.25,-3.1) 7(0.75,-3.1) 8(1.25,-3.1) 9(1.75,-3.1) 10(2.25,-3.1) 21(2.25,3.1) 22(1.75,3.1) 23(1.25,3.1) 24(0.75,3.1) 25(0.25,3.1) 26(-0.25,3.1) 27(-0.75,3.1) 28(-1.25,3.1) 29(-1.75,3.1) 30(-2.25,3.1)
  rect 0.991x0.305 smd: 11(3.1,-2.25) 12(3.1,-1.75) 13(3.1,-1.25) 14(3.1,-0.75) 15(3.1,-0.25) 16(3.1,0.25) 17(3.1,0.75) 18(3.1,1.25) 19(3.1,1.75) 20(3.1,2.25) 31(-3.1,2.25) 32(-3.1,1.75) 33(-3.1,1.25) 34(-3.1,0.75) 35(-3.1,0.25) 36(-3.1,-0.25) 37(-3.1,-0.75) 38(-3.1,-1.25) 39(-3.1,-1.75) 40(-3.1,-2.25)
  rect 4.597x4.597 smd: 41(0,0)
QFN44-6X5-4-45P
  custom 0.05x0.05 smd: 1(-2.2,-2.45) 12(2.2,-2.45) 13(2.95,-1.8) 22(2.95,1.8) 23(2.2,2.45) 34(-2.2,2.45) 35(-2.95,1.8) 44(-2.95,-1.8)
  rect 0.203x0.711 smd: 2(-1.8,-2.45) 3(-1.4,-2.45) 4(-1,-2.45) 5(-0.6,-2.45) 6(-0.2,-2.45) 7(0.2,-2.45) 8(0.6,-2.45) 9(1,-2.45) 10(1.4,-2.45) 11(1.8,-2.45) 24(1.8,2.45) 25(1.4,2.45) 26(1,2.45) 27(0.6,2.45) 28(0.2,2.45) 29(-0.2,2.45) 30(-0.6,2.45) 31(-1,2.45) 32(-1.4,2.45) 33(-1.8,2.45)
  rect 0.711x0.203 smd: 14(2.95,-1.4) 15(2.95,-1) 16(2.95,-0.6) 17(2.95,-0.2) 18(2.95,0.2) 19(2.95,0.6) 20(2.95,1) 21(2.95,1.4) 36(-2.95,1.4) 37(-2.95,1) 38(-2.95,0.6) 39(-2.95,0.2) 40(-2.95,-0.2) 41(-2.95,-0.6) 42(-2.95,-1) 43(-2.95,-1.4)
  rect 4.648x3.658 smd: 45(0,0)
R0201
  rect 0.203x0.381 smd: 1(-0.225,0) 2(0.225,0)
R0402
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
R0603
  rect 0.686x0.813 smd: 1(0.6,0) 2(-0.6,0)
R0805
  rect 0.864x1.372 smd: 1(0.88,0) 2(-0.88,0)
R1206
  rect 1.219x1.626 smd: 1(1.4,0) 2(-1.4,0)
RJ45-2RJ3Y35-108211F-12P
  round 1.194 hole 0.889: 1(-3.57,3.3) 2(-2.55,4.4) 3(-1.53,3.3) 4(-0.51,4.4) 5(0.51,3.3) 6(1.53,4.4) 7(2.55,3.3) 8(3.57,4.4)
  round 1.295 hole 0.991: 9(7.075,4.28) 10(7.075,2.78) 11(-7.075,4.28) 12(-7.075,2.78)
  oval 0.991x1.803 hole 0.61x1.397: 13(-8.15,-5.6) 15(8.15,-5.6)
  oval 0.991x2.388 hole 0.61x2.007: 14(-8.15,0) 16(8.15,0)
S0201
  rect 0.343x0.381 smd: 1(-0.225,0) 2(0.225,0)
S0402
  custom 0.125x0.125 smd: 1(0.39,0) 2(-0.39,0)
S0603
  rect 1.041x0.813 smd: 1(0.6,0) 2(-0.6,0)
S0805
  rect 1.346x1.372 smd: 1(0.88,0) 2(-0.88,0)
S1206
  rect 2.032x1.626 smd: 1(1.4,0) 2(-1.4,0)
SC70-2_1-65-6P
  rect 1.27x0.279 smd: 1(1.02,-0.65) 2(1.02,0) 3(1.02,0.65) 4(-1.02,0.65) 5(-1.02,0) 6(-1.02,-0.65)
SIMCRAD-CPMPAT7-08GLBS1-8P
  rect 0.889x1.194 smd: 1(-4.44,13.6) 2(-1.9,13.6) 3(0.64,13.6) 4(3.18,13.6) 5(-3.17,13.6) 6(-0.63,13.6) 7(1.91,13.6) 8(4.45,13.6)
  rect 1.295x1.803 smd: 9(-7.45,9.6) 10(7.45,9.6) 11(-7.45,0) 12(7.45,0)
SOIC8-6-1_27-24AA02
  rect 0.61x1.549 smd: 1(-1.905,-2.7) 2(-0.635,-2.7) 3(0.635,-2.7) 4(1.905,-2.7) 5(1.905,2.7) 6(0.635,2.7) 7(-0.635,2.7) 8(-1.905,2.7)
SON8-3X3-65-7P
  rect 0.305x0.508 smd: 1(-0.975,-1.35) 2(-0.325,-1.35) 3(0.325,-1.35) 4(0.975,-1.35) 5(0.975,1.35)
  rect 1.6x0.508 smd: 8(-0.325,1.35)
  rect 2.388x1.6 smd: 9(0,0)
SON14-3X2-4-15P-SMT
  custom 0.05x0.05 smd: 1(-1.2,-1.076) 2(-0.8,-1.076) 3(-0.4,-1.076) 4(0,-1.076) 5(0.4,-1.076) 6(0.8,-1.076) 7(1.2,-1.076) 8(1.2,1.076) 9(0.8,1.076) 10(0.4,1.076) 11(0,1.076) 12(-0.4,1.076) 13(-0.8,1.076) 14(-1.2,1.076)
  rect 2.489x0.889 smd: 15(0,0)
SOT23-2_8-95-3P-1_45H
  rect 1.194x0.559 smd: 1(1.5,0.95) 2(1.5,-0.95) 3(-1.5,0)
SOT23-5-2_8-95-5P-G708
  rect 1.194x0.533 smd: 1(1.5,-0.95) 2(1.5,0) 3(1.5,0.95) 4(-1.5,0.95) 5(-1.5,-0.95)
SOT23-6-2_794-9395-6P
  rect 1.346x0.508 smd: 1(1.32,-0.94) 2(1.32,0) 3(1.32,0.94) 4(-1.32,0.94) 5(-1.32,0) 6(-1.32,-0.94)
SOT23_213-3_3-2
  rect 1.27x1.016 smd: 1(1.016,1.016) 2(1.016,-1.016) 3(-1.016,0)
SOT323_213-2_1-1_3-1_1H
  rect 0.889x0.711 smd: 1(0.95,0.65) 2(0.95,-0.65) 3(-0.95,0)
SOT323_213-2_1-1_3-2N7002W
  rect 0.787x0.61 smd: 1(0.8,0.65) 2(0.8,-0.65) 3(-0.8,0)
SOT323_213-2_1-1_3-3P
  rect 0.559x0.61 smd: 1(0.925,0.65) 2(0.925,-0.65) 3(-0.925,0)
SOT353-1-2_125-65-5P
  rect 1.245x0.279 smd: 1(1.045,-0.65) 2(1.045,0) 3(1.045,0.65) 4(-1.045,0.65) 5(-1.045,-0.65)
SOT353-2_1-65-5P-1_1H
  rect 1.194x0.305 smd: 1(1.05,-0.65) 2(1.05,0) 3(1.05,0.65) 4(-1.05,0.65) 5(-1.05,-0.65)
SOT363-2_1-65-6P
  rect 0.889x0.356 smd: 1(0.8,-0.65) 2(0.8,0) 3(0.8,0.65) 4(-0.8,0.65) 5(-0.8,0) 6(-0.8,-0.65)
SOT523_213-1_6-1-0_6H
  rect 0.457x0.406 smd: 1(0.675,0.5) 2(0.675,-0.5) 3(-0.675,0)
SPAD-415WD-1NP
  round 8.001 smd: 1(0,0)
SPAD-415WD-2NP
  round 8.509 smd: 1(0,0)
SSOP5-2_1-65-5P-0_9H
  rect 0.787x0.406 smd: 1(0.95,-0.65) 2(0.95,0) 3(0.95,0.65) 4(-0.95,0.65) 5(-0.95,-0.65)
TP2050
  round 0.508 smd: 1(0,0)
TP2650
  round 0.66 smd: 1(0,0)
TP2675
  round 0.66 smd: 1(0,0)
TQFN32-3X6-4-41P-0_8H
  custom 0.05x0.05 smd: 1(-2,-1.5) 2(-1.6,-1.5) 3(-1.2,-1.5) 4(-0.8,-1.5) 5(-0.4,-1.5) 6(0,-1.5) 7(0.4,-1.5) 8(0.8,-1.5) 9(1.2,-1.5) 10(1.6,-1.5) 11(2,-1.5) 12(3,-0.8) 13(3,-0.4) 14(3,0) 15(3,0.4) 16(3,0.8) 17(2,1.5) 18(1.6,1.5) 19(1.2,1.5) 20(0.8,1.5) 21(0.4,1.5) 22(0,1.5) 23(-0.4,1.5) 24(-0.8,1.5) 25(-1.2,1.5) 26(-1.6,1.5) 27(-2,1.5) 28(-3,0.8) 29(-3,0.4) 30(-3,0) 31(-3,-0.4) 32(-3,-0.8)
  rect 4.597x1.803 smd: 33(0,0)
  round 0.61 hole 0.305: 34(-1.5,-0.5) 35(-0.5,-0.5) 36(0.5,-0.5) 37(1.5,-0.5) 38(1.5,0.5) 39(0.5,0.5) 40(-0.5,0.5) 41(-1.5,0.5)
TRF-N1010G-25P
  rect 0.635x1.778 smd: 1(-5.5,-4.54) 2(-4.5,-4.54) 3(-3.5,-4.54) 4(-2.5,-4.54) 5(-1.5,-4.54) 6(-0.5,-4.54) 7(0.5,-4.54) 8(1.5,-4.54) 9(2.5,-4.54) 10(3.5,-4.54) 11(4.5,-4.54) 12(5.5,-4.54) 13(5.5,4.45) 14(4.5,4.45) 15(3.5,4.45) 16(2.5,4.45) 17(1.5,4.45) 18(0.5,4.45) 19(-0.5,4.45) 20(-1.5,4.45) 21(-2.5,4.45) 22(-3.5,4.45) 23(-4.5,4.45) 24(-5.5,4.45)
  rect 0.889x0.787 smd: 25(-6.82,0)
UB3-54956-00902-V02-9P
  round 1.295 hole 0.711: 1(3.5,9.2) 2(1,9.2) 3(-1,9.2) 4(-3.5,9.2) 5(-4,7.7) 6(-2,7.7) 7(0,7.7) 8(2,7.7) 9(4,7.7)
  oval 1.499x2.591 hole 0.889x2.007: 10(6.4,8.45) 11(-6.4,8.45)
  oval 1.499x2.108 hole 0.889x1.499: 12(-7.85,0) 13(7.85,0)
UB31-AUSB0152-P604A-24P
  round 0.813 hole 0.813 unplated: (-3.45,0)
  oval 0.813x0.762 hole 0.813x0.762 unplated: (3.45,0)
  custom 0.076x0.076 smd: 1(-3.2,0.69) 4(3.2,0.69)
  rect 0.508x0.305 smd: 2(-1,0.69) 3(1,0.69)
  oval 0.991x1.6 hole 0.508x1.092: 5(-4.475,0.4) 6(4.475,0.4)
  oval 0.991x2.007 hole 0.508x1.499: 7(-6.075,-1.935) 8(6.075,-1.935) 9(-6.075,-5.8) 10(6.075,-5.8)
  custom 0.064x0.064 smd: A1(-2.75,-0.06) A12(2.75,-0.06)
  rect 0.254x0.61 smd: A2(-2.25,-0.06) A3(-1.75,-0.06) A4(-1.25,-0.06) A5(-0.75,-0.06) A6(-0.25,-0.06) A7(0.25,-0.06) A8(0.75,-0.06) A9(1.25,-0.06) A10(1.75,-0.06) A11(2.25,-0.06)
  oval 1.143x0.66 hole 0.889x0.406: B1(3.2,-1.135) B12(-3.2,-1.135)
  round 0.61 hole 0.457: B2(2.5,-2.035) B3(1.7,-2.035) B4(1.3,-1.135) B5(0.85,-2.035) B6(0.4,-1.135) B7(-0.4,-1.135) B8(-0.85,-2.035) B9(-1.3,-1.135) B10(-1.7,-2.035) B11(-2.5,-2.035)
UDFN10-2_5X1-5
  rect 0.254x0.508 smd: 1(-1,-0.4) 2(-0.5,-0.4) 4(0.5,-0.4) 5(1,-0.4) 6(1,0.4) 7(0.5,0.4) 9(-0.5,0.4) 10(-1,0.4)
  rect 0.457x0.508 smd: 3(0,-0.4) 8(0,0.4)
UMT_213-3-1_3
  rect 1.016x0.762 smd: 1(0.991,0.66) 2(0.991,-0.66) 3(-0.991,0)
unnamed#2
  round 1.016 smd: 1(0,0)
WQFN20-3X3-4-21P
  rect 0.203x0.991 smd: 1(-0.8,-1.6) 2(-0.4,-1.6) 3(0,-1.6) 4(0.4,-1.6) 5(0.8,-1.6) 11(0.8,1.6) 12(0.4,1.6) 13(0,1.6) 14(-0.4,1.6) 15(-0.8,1.6)
  rect 0.991x0.203 smd: 6(1.6,-0.8) 7(1.6,-0.4) 8(1.6,0) 9(1.6,0.4) 10(1.6,0.8) 16(-1.6,0.8) 17(-1.6,0.4) 18(-1.6,0) 19(-1.6,-0.4) 20(-1.6,-0.8)
  rect 1.702x1.702 smd: 21(0,0)
XTL-2_05X1_65-1_4X1_1-0_6H
  rect 0.889x0.787 smd: 1(-0.7,-0.55) 2(0.7,-0.55) 3(0.7,0.55) 4(-0.7,0.55)
XTL-2X1_6-1_35X1_05
  rect 0.838x0.762 smd: 1(-0.675,-0.525) 2(0.675,-0.525) 3(0.675,0.525) 4(-0.675,0.525)
XTL-3_2X1_5-2_5-SMT
  rect 0.991x1.6 smd: 1(-1.25,0) 2(1.25,0)

## Nets
1V0A_PG: PR8110.2 PR9203.2
1V8A_PG: PR8108.2 PU9300.13(PG)
2V5_PG: PR8716.1 R3301.2 R3302.2 R3303.2
3V_5V_PG: PR8123.2 PR8603.1 PR8627.1
+1.0V_STG: C639.2 R403.2 R622.1 U400.BG1(VCCSTG1) U400.BG2(VCCSTG2) U400.BG3(VCCSTG1)
+1.2V_VCCPLL_OC: PC9607.1 PC9608.1 PQ9604.1(S) PR9612.1 R620.2
+1.2V_VCCPLL_OC_ON: PQ9605.2(G) PR9611.2 PU9602.4(Y)
+1.2VSUS: C597.2 C602.2 C603.2 C604.2 C605.2 C606.2 C613.2 C614.2 C615.2 C616.2 C2801.1 C2802.1 C2803.1 C2804.1 C2805.1 C2806.1 C2807.1 C2808.1 C2809.1 C2810.1 C2811.1 C2812.1 C2813.1 C2814.1 C2815.1 C2816.1 C2830.1 C2832.1 C2834.1 C2836.1 C2838.1 C2840.1 C2841.1 C2843.1 C2845.1 C2846.1 C2847.1 C2848.1 C2850.1 C2852.1 C2853.1 C2854.1 C5822.2 C5823.1 C5824.2 C5825.2 C5826.1 C7852.2 C7853.2 C7854.2 C7869.2 C7870.2 EC2800.1 EC2801.1 EC2802.1 EC2803.1 EC2804.1 EC2805.1 EC2806.1 EC2807.2 EC2808.2 EC2809.1 EC2810.2 EC2811.1 EC2812.1 EC2813.2 EC2814.1 EC2815.1 EC2821.1 EC2823.1 JDIM2800.12(DM0) JDIM2800.33(DM1) JDIM2800.54(DM2) JDIM2800.75(DM3) JDIM2800.96(DM8) JDIM2800.111(VDD1) JDIM2800.112(VDD2) JDIM2800.117(VDD3) JDIM2800.118(VDD4) JDIM2800.123(VDD5) JDIM2800.124(VDD6) JDIM2800.129(VDD7) JDIM2800.130(VDD8) JDIM2800.135(VDD9) JDIM2800.136(VDD10) JDIM2800.141(VDD11) JDIM2800.142(VDD12) JDIM2800.147(VDD13) JDIM2800.148(VDD14) JDIM2800.153(VDD15) JDIM2800.154(VDD16) JDIM2800.159(VDD17) JDIM2800.160(VDD18) JDIM2800.163(VDD19) JDIM2800.178(DM4) JDIM2800.199(DM5) JDIM2800.220(DM6) JDIM2800.241(DM7) JDIM2801.12(DM0) JDIM2801.33(DM1) JDIM2801.54(DM2) JDIM2801.75(DM3) JDIM2801.96(DM8) JDIM2801.111(VDD1) JDIM2801.112(VDD2) JDIM2801.117(VDD3) JDIM2801.118(VDD4) JDIM2801.123(VDD5) JDIM2801.124(VDD6) JDIM2801.129(VDD7) JDIM2801.130(VDD8) JDIM2801.135(VDD9) JDIM2801.136(VDD10) JDIM2801.141(VDD11) JDIM2801.142(VDD12) JDIM2801.147(VDD13) JDIM2801.148(VDD14) JDIM2801.153(VDD15) JDIM2801.154(VDD16) JDIM2801.159(VDD17) JDIM2801.160(VDD18) JDIM2801.163(VDD19) JDIM2801.178(DM4) JDIM2801.199(DM5) JDIM2801.220(DM6) JDIM2801.241(DM7) PC9606.1 PQ9604.3(D) PR8708.1 PR8725.1 R544.2 R2800.1 R2802.1 R2803.1 R2804.1 R2805.1 R2806.1 R2807.1 R2808.1 R2809.1 R2810.1 R2811.1 R2812.2 R2829.1 R2830.1 R2831.1 R2832.1 R2833.1 R2834.1 R2835.1 R2836.1 R2837.1 R2838.1 R2839.2 R9648.1 U400.AD36(VDDQ1) U400.AH32(VDDQ2) U400.AH36(VDDQ3) U400.AM36(VDDQ4) U400.AN32(VDDQ5) U400.AW32(VDDQ6) U400.AY36(VDDQ7) U400.BE32(VDDQ8) U400.BH36(VDDQ9) U400.R32(VDDQ10) U400.Y36(VDDQ11) U5800.1(CEXT) U5800.20(VDD33#2) U5800.28(VDD33#1)
+1.2VSUS_S: PC8716.1 PC8717.1 PC8718.1 PC8719.1 PC8720.1 PC8721.1 PL8701.2 PR8710.2 PR8725.2
+1.05V_DEEP_SUS: C436.2 C437.2 C441.1 C443.2 C444.2 C445.2 C446.2 C451.1 C452.2 C453.2 C454.2 C455.2 C456.2 C460.2 C461.2 C464.2 C468.2 C469.2 C7857.2 C7859.2 CN7700.43(VCC_OBS_AB) CN7700.44(VCC_OBS_CD) PC9217.1 PC9600.1 PC9603.1 PQ9600.3(D) PQ9602.3(D) PR9213.1 PU9201.1(VIN#1) PU9201.2(VIN#2) PU9201.9(VIN#3) R587.1 R604.2 R607.2 R608.1 R7716.1 U400.BP14(VCCA_BCLK_1P05) U400.BP20(VCCPRIM_1P051) U400.BP22(VCCPRIM_1P052) U400.BR12(VCCA_19P2_1P05) U400.BR14(VCCAPLL_1P051) U400.BR15(VCCAPLL_1P052) U400.BR20(VCCPRIM_1P053) U400.BT12(VCCAPLL_1P053) U400.BT18(VCCPRIM_1P054) U400.BT19(VCCPRIM_1P055) U400.BT22(VCCPRIM_1P056) U400.BU12(VCCA_SRC_1P05) U400.BU14(VCCAPLL_1P054) U400.BU15(VCCPRIM_CORE1) U400.BU18(VCCPRIM_1P057) U400.BU19(VCCPRIM_1P058) U400.BU22(VCCPRIM_CORE2) U400.BV12(VCCPRIM_MPHY_1P051) U400.BV14(VCCPRIM_MPHY_1P052) U400.BV15(VCCPRIM_CORE3) U400.BV16(VCCPRIM_CORE4) U400.BV18(VCCPRIM_CORE5) U400.BV19(VCCPRIM_CORE6) U400.BV20(VCCPRIM_CORE7) U400.BV22(VCCPRIM_CORE8) U400.BW12(VCCPRIM_MPHY_1P053) U400.BW14(VCCPRIM_MPHY_1P054) U400.BW16(VCCPRIM_1P059) U400.BW18(VCCPRIM_1P0510) U400.BW19(VCCPRIM_1P0511) U400.BW20(VCCPRIM_CORE9) U400.BW22(VCCPRIM_CORE10) U400.BY12(VCCPRIM_MPHY_1P055) U400.BY14(VCCPRIM_MPHY_1P056) U400.BY16(VCCPRIM_1P0512) U400.BY20(VCCPRIM_1P0513) U400.CA12(VCCPRIM_CORE11) U400.CA14(VCCPRIM_1P0514) U400.CA16(VCCPRIM_CORE12) U400.CA18(VCCPRIM_CORE13) U400.CA19(VCCPRIM_CORE14) U400.CA20(VCCPRIM_CORE15) U400.CB12(VCCPRIM_CORE16) U400.CB14(VCCPRIM_CORE17) U400.CB15(VCCPRIM_CORE18) U400.CC12(VCCDUSB_1P05)
+1.05V_DEEP_SUS_S: PC9211.2 PC9212.2 PC9213.1 PC9223.2 PC9224.2 PL9201.2 PR9206.2 PR9213.2
+1.05V_LAN_R: C4005.1 C4006.1 C4007.1 C4008.1 C4009.1 C4010.1 C4011.1 C4012.1 L4000.2 U4000.3(AVDD10(NC)) U4000.8(AVDD10_2) U4000.22(DVDD10(NC)) U4000.30(AVDD10)
+1.05V_LAN_REGOUT: C4004.1 L4000.1 U4000.24(REGOUT(NC))
+1.8V: C3619.2 L3604.1 PR8104.2 PR9512.2 R504.2 R506.2 R508.2 R510.2 R512.1 R515.1 R517.1 R519.2 R520.2 R521.1 R529.1 R532.2 U3600.29(CPVDD)
+1.8V_DEEP_SUS: C432.2 C440.2 C457.2 C459.2 PR8105.1 PR9511.1 R444.2 R494.2 R495.2 R497.1 R500.2 R574.2 R4143.2 R4144.1 R4719.1 R4721.1 U400.CC15(VCCPRIM_1P81) U400.CC18(VCCPRIM_1P82) U400.CC19(VCCPRIM_1P83) U400.CD15(VCCPRIM_1P84) U400.CD16(VCCPRIM_1P85) U400.CD18(VCCPRIM_1P86) U400.CD19(VCCPRIM_1P87) U400.CP17(VCCPRIM_1P88) U400.CP23(VCCPRIM_1P89)
+1.8VPCU: PC9522.1 PC9523.1 PR9314.2 PU9502.1(VIN1#1) PU9502.2(VIN1#2) PU9502.6(VIN2#1) PU9502.7(VIN2#2)
+2.5VSUS: C2824.1 C2825.1 C2849.1 C2851.1 JDIM2800.257(VPP1) JDIM2800.259(VPP2) JDIM2801.257(VPP1) JDIM2801.259(VPP2) PR8717.1
+2.5VSUS_S: PC8724.1 PC8726.1 PC8727.1 PL8702.2 PR8717.2 PR8722.2
+3.3V_8270C: PC8638.1 PU8601.10(VCC)
+3V: C2826.1 C2827.1 C2842.1 C2844.1 C3505.1 C3506.1 C3507.1 C3508.1 C3624.2 C3625.1 C3626.2 C3627.1 C5205.1 C5206.1 C5404.1 C6204.1 C7604.1 C7609.2 C7619.1 C7855.2 CN6200.1 CN7601.1 F3402.2 F5200.2 JDIM2800.255(VDDSPD) JDIM2801.255(VDDSPD) PR8100.2 PR8102.2 PR8119.2 PR8816.1 PR9503.2 Q401.2(G) Q401.5(G) Q4101.2(G) Q5402.2(G) Q5402.5(G) R414.1 R415.2 R416.2 R447.1 R450.1 R463.2 R479.2 R483.2 R484.2 R485.2 R486.1 R487.2 R488.2 R489.2 R492.2 R493.2 R526.2 R528.2 R533.1 R541.2 R554.1 R555.2 R556.1 R557.1 R558.1 R560.1 R568.1 R593.2 R594.2 R595.2 R597.2 R630.1 R2814.2 R2815.2 R2816.2 R2823.1 R2824.1 R2825.1 R3412.1 R3414.1 R3415.1 R3504.2 R3506.2 R3507.2 R3512.1 R3513.1 R3610.2 R3613.1 R3620.1 R3623.2 R4001.1 R4305.2 R4310.2 R4717.1 R4718.1 R4720.1 R4722.1 R4756.1 R5012.1 R5013.1 R5108.1 R5300.1 R5402.1 R5405.2 R5407.1 R5408.1 R6213.1 R7628.1 R7637.2 R7713.2 R7714.2 R7719.2 R9647.1 U401.5(VCC) U3400.4(IN) U3400.5(IN1) U3501.11(VDD) U3501.30(VDDIO) U3600.1(DVDD) U3600.8(DVDD-IO) U5400.1(VCC) U7600.10(VCC33) U7601.5(IN)
+3V_+1.8V_CR: C7610.1 C7611.1 C7612.1 C7613.1 C7614.2 C7620.1 R7610.2 R7613.1 U7600.7(VCCO_33_18) U7600.15(VCC_33_18#1) U7600.22(VCC_33_18#2) U7600.28(VCCIO)
+3V_ALW: C7500.1 C7600.2 CN7600.20 PC8617.1 PD8500.1 PD8501.1 PR8107.1 PR8718.2 PR9300.1 PU8102.5(VCC) PU8600.17(LDO) Q7500A.2(G) Q7500B.2(G) R598.1 R3312.2 R4146.2 R7501.1 R7502.1 R7503.1 R7504.1 R7505.1 U7500.1(VDD)
+3V_CAM: C3421.1 C3422.1 C7861.2 CN3400.35 R3418.2
+3V_DEEP_SUS: C403.2 C431.2 C433.2 C434.2 C435.2 C438.2 C442.2 C462.2 C463.2 C467.2 C475.1 C477.1 C4222.1 L402.1 PR8103.1 PR8120.1 PR8248.1 PR9502.2 Q4000.2(G) Q4700.2(G) Q4700.5(G) R417.1 R418.1 R419.1 R420.1 R421.1 R422.1 R423.2 R424.1 R426.2 R429.2 R431.2 R443.1 R468.2 R473.2 R474.2 R476.2 R477.2 R478.1 R490.2 R496.2 R531.2 R535.1 R536.2 R548.1 R549.1 R571.2 R584.1 R625.2 R626.2 R628.1 R659.1 R660.2 R4108.1 R4116.1 R4706.2 R4729.1 R4764.1 R5600.2 R7701.2 R7728.1 U400.BP23(VCCPRIM_3P31) U400.BV23(VCCSPI) U400.BW23(VCCPRIM_3P32) U400.CB16(VCCPRIM_3P33) U400.CB22(VCCPRIM_3P34) U400.CB23(VCCPRIM_3P35) U400.CC22(VCCPRIM_3P36) U400.CC23(VCCPRIM_3P37) U400.CD22(VCCPRIM_3P38) U400.CD23(VCCPRIM_3P39) U400.CP29(VCCPRIM_3P310) U402.5(VCC) U4201.5(VCC)
+3V_ECACC: C4718.1 C4719.2 R4736.1 U4701.D1(AVCC)
+3V_RTC: C428.1 C429.1 C470.2 C471.1 C4701.1 C4702.1 D400.3(COMMON ANODE) R461.2 R599.2 R601.2 U400.BR23(VCCRTC) U4701.L4(VBAT)
+3V_RTC_0: C7629.1 CN7601.3 R602.2
+3V_RTC_1: D400.1(CATHODE1) Q7702.2(G) R602.1 R9649.1
+3V_RTC_2: D400.2(CATHODE2) R598.2
+3V_SENSOR: CN7602.7 Q7602.2(G) Q7602.5(G) R7629.1 R7630.1 U7601.1(VOUT)
+3V_SSD: C4302.2 C4303.2 C4304.2 C4305.2 C4312.2 C4313.2 CN4300.2(3.3VAUX_2) CN4300.4(3.3VAUX_4) CN4300.14(3.3VAUX_14) CN4300.16(3.3VAUX_16) CN4300.18(3.3VAUX_18) CN4300.70(3.3VAUX_70) CN4300.72(3.3VAUX_72) CN4300.74(3.3VAUX_74) EC4300.2 R4300.2 R4310.1
+3V_THR: C5405.1 R5403.1 U5401.5(VCC)
+3V_VCC: C4712.1 C4713.2 C4714.2 C4715.2 C4716.2 PQ8004.2(G) PR8011.1 R4731.1 U4701.A7(VCC1#1) U4701.B1(VCC1#2) U4701.D12(VCC1#4) U4701.M8(VCC1#3)
+3V_VCC_READER: C7605.1 C7607.1 C7615.1 CN7601.4 CN7601.5 U7600.12(SD_SKT_VDD1)
+3V_WLAN_C: R4142.1 U4100.1(VOUT)
+3V_WLAN_EN: Q4109.6(D) R4139.1 U4100.4(EN)
+3V_WLAN_P: C4100.1 C4101.1 C4102.2 C4104.1 C4105.1 CN4100.2(3.3VAUX_1) CN4100.4(3.3VAUX_2) CN4100.72(3.3VAUX_3) CN4100.74(3.3VAUX_4) Q4104.2 R4101.1 R4104.1 R4107.1 R4117.2 R4142.2
+3V_WWAN_P: C4200.1 C4201.1 C4202.2 C4203.1 C4204.2 C4205.1 C4207.2 C7851.2 CN4200.2(3V3#1) CN4200.4(3V3#2) CN4200.70(3V3#3) CN4200.72(3V3#4) CN4200.74(3V3#5) R4200.1 R4210.1 R4214.1
+3VLANVCC: C4015.1 C4016.1 C4017.1 C4018.1 C4019.1 C4020.1 C4021.1 C4022.1 PR9500.1 Q4000.5(G) R4003.2 R4007.1 R4008.1 U4000.11(AVDD33(NC)) U4000.23(VDDREG(VDD33)) U4000.32(AVDD33)
+3VLCD_CON: C3405.1 C3406.1 C3407.1 C3408.1 C3409.2 C3410.2 CN3400.23 CN3400.24 L3400.2
+3VPCU: C450.2 C465.2 C4109.2 C4717.1 C5000.1 C5821.1 C7826.2 CN7701.20 F7600.2 L4700.2 PC8222.2 PC8503.2 PC8802.1 PC9221.1 PC9500.1 PC9501.1 PC9503.1 PQ8010.1(EMITTER) PQ8011.1(EMITTER) PQ8500.2(BASE) PQ8505.1(EMITTER) PQ8506.1(EMITTER) PR8121.2 PR8122.2 PR8125.1 PR8126.1 PR8226.2 PR8233.2 PR8236.2 PR8238.2 PR8512.2 PR8622.1 PR8715.1 PR8800.2 PR8805.1 PR8806.1 PR8825.1 PR8865.2 PR9214.1 PR9306.2 PR9309.2 PU8201.4(+VS) PU9201.3(VBIAS) PU9202.5(VCC) PU9500.6(VIN2#1) PU9500.7(VIN2#2) PU9501.1(VIN1#1) PU9501.2(VIN1#2) PU9501.6(VIN2#1) PU9501.7(VIN2#2) Q7501.5(G) R453.2 R454.2 R455.2 R456.1 R653.2 R3302.1 R3417.1 R3424.2 R3624.1 R4136.1 R4137.2 R4139.2 R4141.1 R4200.2 R4203.1 R4249.1 R4250.1 R4700.2 R4704.1 R4705.1 R4723.1 R4724.1 R4725.1 R4726.1 R4727.1 R4728.2 R4731.2 R4732.2 R4733.2 R4734.2 R4735.2 R4740.2 R4742.2 R4743.2 R4744.1 R4745.2 R4752.1 R4753.1 R4760.2 R4769.2 R4770.1 R4771.1 R4772.2 R5000.2 R5001.2 R5008.2 R5016.5(R10) R5016.10(R1) R5304.2 R5403.2 R5404.1 R5809.2 R6103.1 R6109.2 R7509.2 U400.BR24(VCCDSW_3P31) U400.BT23(VCCDSW_3P32) U4100.5(IN) U4202.5(VCC) U4700.5(VCC) U5801.5(VIN)
+3VPCU_G: CN7602.6 F7600.1
+3VPCU_PD: C6100.2 C6101.2 C6102.1 R5807.1 R5808.1 R6101.1 R6102.2 R6106.1 R6108.1 R6116.1 R7711.2 TP6100.1 U6100.31(VDDD) U6100.32(VDDIO)
+3VPCU_WWAN: C7860.2 C7871.2 CN3400.36 R3417.2
+3VSUS: C5810.2 C5811.1 C5812.2 Q5800.2(G) Q5800.5(G) R5801.1 R5802.1 R5803.1 R5804.2 R5806.1 R5809.1 R5810.2 U5800.6(VDD33#3) U5800.17(VDD_DCI) U5801.1(VOUT)
+5V: C3500.1 C3608.2 C3609.1 C4400.1 C4401.1 C4402.1 C4403.1 C5400.1 C5401.2 C7856.2 C7867.2 CN4400.1 CN4400.2 CN4400.3 CN5400.3 F3400.2 L3605.2 PR8101.2 PR9501.1 PR9514.1 Q5002.1(S) Q6100.2(G) R580.2 R3627.1 R5011.2 R5400.1 U3500.3(IN)
+5V_ALW: PC8639.2 PU8601.9(LDO)
+5V_CAM: C7872.2 CN3400.27 CN3400.28 F3400.1
+5V_HDMIC: C3501.1 C3502.1 C3503.1 C3519.1 CN3500.18(+5V) R3510.1 R3511.1 U3500.1(OUT)
+5V_LED_KBLIGHT: C5001.2 CN5001.6 CN5001.7 CN5001.8 Q5002.3(D)
+5V_USBP1: C5700.1 C5701.1 C5702.2 C5706.1 C5708.1 C5709.1 C5710.2 CN5700.1 CN5701.1 U5701.1(VOUT) VC5700.2 VC5702.2
+5VPCU: C5707.1 C6300.1 C6301.1 C6305.1 C7606.1 C7833.2 C7834.2 C7835.2 C7836.2 C7837.2 C7838.2 C7839.2 C7840.2 C7841.2 CN7600.1 CN7600.2 CN7600.3 CN7600.4 CN7600.5 CN7600.6 CN7600.7 PC8103.2 PC8715.2 PC8908.2 PC8921.2 PC9002.2 PC9025.2 PC9502.1 PC9512.1 PC9513.1 PC9531.1 PCN8000.5(LED+) PR8623.1 PR8624.1 PR8711.2 PR9201.1 PR9602.1 PR9606.1 PR9615.1 PU8100.8(VCC) PU8700.12(VDD) PU8900.8(VCC) PU8901.8(VCC) PU9000.8(VCC) PU9001.8(VCC) PU9500.1(VIN1#1) PU9500.2(VIN1#2) PU9500.4(VBIAS) PU9501.4(VBIAS) PU9502.4(VBIAS) PU9600.5(VCC) PU9601.5(VCC) PU9602.5(VCC) R6110.2 R6114.2 R6115.1 R6319.2 R6323.1 R7617.1 U5701.5(VIN) U6302.A1(VIN #1) U6302.A2(VIN #2) VC5701.1
+V3.3DX_1.5DX_ADO: C466.2 C478.1 L402.2 U400.BT20(VCCHDA)
+VCC_CORE: C481.1 C482.2 C483.1 C485.1 C486.1 C490.2 C491.2 C492.2 C493.2 C494.1 C495.1 C496.1 C497.1 C508.2 C509.2 C510.2 C518.2 C519.2 C520.2 C521.2 C522.2 C523.2 C524.2 C525.1 C526.1 C527.1 C528.1 C529.1 C530.1 C531.1 C532.1 C533.1 C534.1 C535.1 C536.1 C537.1 C538.2 C539.2 C540.2 C541.2 C7846.2 C7847.2 C7848.2 C7849.2 C7858.2 C7865.2 PC8910.1 PC8923.1 PC8927.1 PC8928.1 PL8902.2 PL8903.2 PR8826.2 PR8905.2 PR8919.2 R609.2 R616.1 R618.1 R619.1 U400.AN9(VCCCORE5) U400.AN10(VCCCORE1) U400.AN24(VCCCORE2) U400.AN26(VCCCORE3) U400.AN27(VCCCORE4) U400.AP2(VCCCORE6) U400.AP9(VCCCORE9) U400.AP24(VCCCORE7) U400.AP26(VCCCORE8) U400.AR5(VCCCORE13) U400.AR6(VCCCORE14) U400.AR7(VCCCORE15) U400.AR8(VCCCORE16) U400.AR10(VCCCORE10) U400.AR25(VCCCORE11) U400.AR27(VCCCORE12) U400.AT9(VCCCORE19) U400.AT24(VCCCORE17) U400.AT26(VCCCORE18) U400.AU5(VCCCORE24) U400.AU6(VCCCORE25) U400.AU7(VCCCORE26) U400.AU8(VCCCORE27) U400.AU9(VCCCORE28) U400.AU24(VCCCORE20) U400.AU25(VCCCORE21) U400.AU26(VCCCORE22) U400.AU27(VCCCORE23) U400.AV2(VCCCORE30) U400.AV5(VCCCORE32) U400.AV7(VCCCORE33) U400.AV10(VCCCORE29) U400.AV27(VCCCORE31) U400.AW5(VCCCORE39) U400.AW6(VCCCORE40) U400.AW7(VCCCORE41) U400.AW8(VCCCORE42) U400.AW9(VCCCORE43) U400.AW10(VCCCORE34) U400.AW24(VCCCORE35) U400.AW25(VCCCORE36) U400.AW26(VCCCORE37) U400.AW27(VCCCORE38) U400.AY24(VCCCORE44) U400.AY26(VCCCORE45) U400.BA5(VCCCORE48) U400.BA7(VCCCORE49) U400.BA8(VCCCORE50) U400.BA25(VCCCORE46) U400.BA27(VCCCORE47) U400.BB2(VCCCORE51) U400.BB26(VCCCORE52) U400.BC5(VCCCORE56) U400.BC6(VCCCORE57) U400.BC7(VCCCORE58) U400.BC9(VCCCORE59) U400.BC10(VCCCORE53) U400.BC26(VCCCORE54) U400.BC27(VCCCORE55) U400.BD5(VCCCORE63) U400.BD8(VCCCORE64) U400.BD10(VCCCORE60) U400.BD25(VCCCORE61) U400.BD27(VCCCORE62) U400.BE9(VCCCORE69) U400.BE24(VCCCORE65) U400.BE25(VCCCORE66) U400.BE26(VCCCORE67) U400.BE27(VCCCORE68) U400.BF2(VCCCORE70) U400.BF9(VCCCORE73) U400.BF24(VCCCORE71) U400.BF26(VCCCORE72) U400.BG27(VCCCORE74)
+VCC_GT: C547.1 C548.1 C549.2 C550.2 C551.1 C552.1 C553.1 C554.2 C555.1 C556.1 C557.2 C558.1 C559.2 C560.1 C561.1 C562.1 C563.1 C564.2 C565.2 C566.2 C567.2 C568.2 C569.2 C570.2 C571.2 C572.2 C573.2 C574.2 C575.2 C576.2 C577.2 C578.2 C579.2 C580.2 C581.2 C582.2 C583.2 C584.2 C585.2 C7866.2 PC9009.1 PC9010.1 PL9000.2 PR8835.2 PR9006.2 R615.1 R617.1 U400.A5(VCCGT8) U400.A6(VCCGT9) U400.A8(VCCGT10) U400.A11(VCCGT1) U400.A12(VCCGT2) U400.A14(VCCGT3) U400.A15(VCCGT4) U400.A17(VCCGT5) U400.A18(VCCGT6) U400.A20(VCCGT7) U400.B3(VCCGT39) U400.B4(VCCGT40) U400.B6(VCCGT41) U400.B8(VCCGT42) U400.B11(VCCGT35) U400.B14(VCCGT36) U400.B17(VCCGT37) U400.B20(VCCGT38) U400.C2(VCCGT49) U400.C3(VCCGT51) U400.C6(VCCGT52) U400.C7(VCCGT53) U400.C8(VCCGT54) U400.C11(VCCGT43) U400.C12(VCCGT44) U400.C14(VCCGT45) U400.C15(VCCGT46) U400.C17(VCCGT47) U400.C18(VCCGT48) U400.C20(VCCGT50) U400.D4(VCCGT62) U400.D7(VCCGT63) U400.D11(VCCGT55) U400.D12(VCCGT56) U400.D14(VCCGT57) U400.D15(VCCGT58) U400.D17(VCCGT59) U400.D18(VCCGT60) U400.D20(VCCGT61) U400.E4(VCCGT64) U400.F5(VCCGT69) U400.F6(VCCGT70) U400.F7(VCCGT71) U400.F8(VCCGT72) U400.F11(VCCGT65) U400.F14(VCCGT66) U400.F17(VCCGT67) U400.F20(VCCGT68) U400.G11(VCCGT73) U400.G12(VCCGT74) U400.G14(VCCGT75) U400.G15(VCCGT76) U400.G17(VCCGT77) U400.G18(VCCGT78) U400.G20(VCCGT79) U400.H5(VCCGT87) U400.H6(VCCGT88) U400.H7(VCCGT89) U400.H8(VCCGT90) U400.H11(VCCGT80) U400.H12(VCCGT81) U400.H14(VCCGT82) U400.H15(VCCGT83) U400.H17(VCCGT84) U400.H18(VCCGT85) U400.H20(VCCGT86) U400.J7(VCCGT95) U400.J8(VCCGT96) U400.J11(VCCGT91) U400.J14(VCCGT92) U400.J17(VCCGT93) U400.J20(VCCGT94) U400.K2(VCCGT98) U400.K11(VCCGT97) U400.L7(VCCGT100) U400.L8(VCCGT101) U400.L10(VCCGT99) U400.M9(VCCGT102) U400.N7(VCCGT104) U400.N8(VCCGT105) U400.N9(VCCGT106) U400.N10(VCCGT103) U400.P2(VCCGT107) U400.P8(VCCGT108) U400.R9(VCCGT109) U400.T8(VCCGT111) U400.T9(VCCGT112) U400.T10(VCCGT110) U400.U8(VCCGT114) U400.U10(VCCGT113) U400.V9(VCCGT116) U400.W8(VCCGT117) U400.W9(VCCGT118)
+VCC_IO: C598.2 C599.2 C600.2 C601.2 C607.2 C608.2 C609.2 C610.2 C611.2 C612.2 PR9212.1 R543.1 R7725.1 U400.AK24(VCCIO1) U400.AK26(VCCIO2) U400.AL24(VCCIO3) U400.AL25(VCCIO4) U400.AL26(VCCIO5) U400.AL27(VCCIO6) U400.AM25(VCCIO7) U400.AM27(VCCIO8) U400.BH24(VCCIO9) U400.BH25(VCCIO10) U400.BH26(VCCIO11) U400.BH27(VCCIO12) U400.BJ24(VCCIO13) U400.BJ26(VCCIO14) U400.BP16(VCCIO15) U400.BP18(VCCIO16)
+VCC_SA: C617.2 C618.2 C619.2 C620.2 C621.2 C622.2 C623.2 C624.2 C625.2 C626.2 C627.2 C628.2 C629.2 C630.2 C632.2 C633.2 C634.2 C635.2 C636.2 C637.2 C7863.2 C7864.2 PC9027.1 PC9028.1 PC9029.1 PC9030.1 PC9031.1 PL9001.2 PR8842.2 PR9021.2 U400.BG8(VCCSA2) U400.BG10(VCCSA1) U400.BH9(VCCSA3) U400.BJ8(VCCSA5) U400.BJ9(VCCSA6) U400.BJ10(VCCSA4) U400.BK8(VCCSA9) U400.BK25(VCCSA7) U400.BK27(VCCSA8) U400.BL8(VCCSA13) U400.BL9(VCCSA14) U400.BL10(VCCSA10) U400.BL24(VCCSA11) U400.BL26(VCCSA12) U400.BM24(VCCSA15) U400.BN25(VCCSA16)
+VCC_TS: C3404.1 C3420.1 C3423.1 CN3400.40 R3419.2 R3420.1 R3421.1 R3422.1
+VCCA_XTAL: C472.1 C473.1 R607.1 U400.CP5(VCCA_XTAL_1P05)
+VCCAMPHYPLL_1.05V: C474.1 C476.1 R608.2 U400.BV2(VCCAMPHYPLL_1P05)
+VCCDPHY: C449.2 U400.CP25(VCCDPHY_EC_1P24)
+VCCDSW_1.05V: C458.2 U400.BT24(VCCDSW_1P05)
+VCCGT_+VCORE: C586.2 C587.2 C588.2 C589.2 C590.2 C591.2 C592.2 C593.2 C594.2 C595.2 C596.2 R615.2 R616.2 R617.2 R618.2 R619.2 U400.AA9(VCCGT11) U400.AB2(VCCGT13) U400.AB8(VCCGT14) U400.AB9(VCCGT15) U400.AB10(VCCGT12) U400.AC8(VCCGT16) U400.AD9(VCCGT17) U400.AE8(VCCGT19) U400.AE9(VCCGT20) U400.AE10(VCCGT18) U400.AF2(VCCGT22) U400.AF8(VCCGT23) U400.AF10(VCCGT21) U400.AG8(VCCGT24) U400.AG9(VCCGT25) U400.AH9(VCCGT26) U400.AJ8(VCCGT28) U400.AJ10(VCCGT27) U400.AK2(VCCGT29) U400.AK9(VCCGT30) U400.AL8(VCCGT32) U400.AL9(VCCGT33) U400.AL10(VCCGT31) U400.AM8(VCCGT34) U400.V2(VCCGT115) U400.Y8(VCCGT120) U400.Y10(VCCGT119)
+VCCLDOSRAM: C447.2 C448.2 U400.BY23(VCCDPHY_1P241) U400.BY24(VCCDPHY_1P242) U400.CA23(VCCDPHY_1P243) U400.CA24(VCCDPHY_1P244)
+VCCSFR: C638.1 C640.2 C4728.2 R400.2 R405.2 R465.1 R606.2 R611.2 R613.1 R614.1 R621.1 U400.BP2(VCCST2) U400.BP11(VCCST1) U400.BR11(VCCPLL1) U400.BT11(VCCPLL2) U4701.M6(VREF_PECI)
+VCCST: PC8801.1 PC9601.1 PC9602.1 PQ9600.1(S) PR8801.1 PR8802.1 PR8803.1 PR8804.1 PR9600.1 R621.2
+VCCST_ON: PQ9601.2(G) PR9601.1 PU9600.4(Y)
+VCCSTG: PC9604.1 PC9605.1 PQ9602.1(S) PR9604.1 R622.2 R7736.1 R7737.1 R7738.1
+VCCSTG_ON: PQ9603.2(G) PR9605.2 PR9617.1 PU9601.4(Y)
+VIN: C7800.2 C7801.2 C7802.2 C7803.2 C7804.2 C7805.2 C7806.2 C7807.2 C7808.2 C7809.2 C7810.2 C7811.2 EC9701.1 EC9702.1 EC9703.1 EC9704.1 PC8200.2 PC8206.1 PC8207.1 PC8208.1 PC8209.2 PC8225.1 PC8600.2 PC8621.2 PC8703.1 PC9308.1 PD8200.1 PD8201.1 PL8200.2 PL8201.2 PL8700.2 PQ8200.1(S1) PQ8200.2(S2) PQ8200.3(S3) PQ8202.1(E1) PQ8203.5(D) PR8130.1 PR8200.2 PR8202.2 PR8600.2 PR8610.1 PR8611.2 PR8630.2 PR9301.2 RR9700.2
+VIN_1.0V_DEEP_SUS: PC9201.1 PC9202.1 PC9203.1 PC9204.1 PC9207.2 PC9208.2 PL9200.1 PR9200.1 PU9200.7(IN#1) PU9200.22(IN#4)
+VIN_1.8VPCU: C7868.2 PC9300.2 PC9302.1 PC9303.1 PC9304.1 PC9305.1 PC9306.2 PC9307.1 PR9301.1 PU9300.1(VIN)
+VIN_3VPCU: C7862.2 PC8601.2 PC8602.2 PC8603.2 PC8604.2 PC8605.2 PC8606.2 PC8607.1 PR8600.1 PU8600.2(IN#1) PU8600.3(IN#2) PU8600.4(IN#3) PU8600.5(IN#4)
+VIN_5VPCU: PC8622.2 PC8623.2 PC8624.2 PC8625.2 PC8626.2 PC8627.2 PC8628.1 PC8642.1 PR8611.1 PR8626.1 PR8630.1 PU8601.1(VIN) RR9700.1
+VIN_BLIGHT: C3401.2 C3403.1 C7850.2 F3401.1 R3411.1
+VIN_BLIGHT_L: C3413.1 CN3400.1 CN3400.2 R3411.2
+VIN_CPU_GPU: C7812.2 C7813.2 C7814.2 C7815.2 C7816.2 C7817.2 C7818.2 C7819.2 C7820.2 C7821.2 C7822.2 C7823.2 C7842.2 CN7701.30 PC8907.1 PL8200.1 PL8201.1 PL8900.1 PL8901.1 PR8807.1
+VIN_DDR: PC8702.2 PC8704.1 PC8705.1 PC8706.1 PC8707.1 PC8708.1 PC8709.1 PL8700.1 PQ8700.5(D) PR8704.2
+VIN_VCC_CORE: C7843.2 C7844.2 C7845.2 F3401.2 PC8900.2 PC8901.1 PC8902.1 PC8903.1 PC8904.1 PC8905.1 PC8906.1 PC8914.2 PC8915.1 PC8916.1 PC8917.1 PC8918.1 PC8919.1 PC8920.1 PC9000.1 PC9001.1 PC9003.2 PC9004.1 PC9005.1 PC9006.1 PC9007.1 PC9018.2 PC9019.1 PC9020.1 PC9021.1 PC9022.1 PC9023.1 PC9035.1 PC9036.1 PC9200.1 PL8900.2 PL8901.2 PL9200.2 PQ8900.3(D1#1) PQ8900.4(D1#2) PQ8900.9(D1#3) PQ8901.3(D1#1) PQ8901.4(D1#2) PQ8901.9(D1#3) PQ9000.2(D1) PQ9001.5 PQ9001.6 PQ9001.7 PQ9001.8
AGND: C3601.1 C3603.1 C3610.1 C3615.1 C3616.2 C3620.2 C3621.1 C3628.2 C3629.2 C3640.1 CN3601.4 CN3601.5 EC3600.1 EC3601.1 EC3602.1 EC3603.1 EC3605.1 EC3606.1 EC3607.1 EC3608.1 EC3610.1 EC3613.1 R3612.1 R3618.1 U3600.13(RING2/MIC2-L) U3600.19(AVSS1) U3600.31(AVSS2)
