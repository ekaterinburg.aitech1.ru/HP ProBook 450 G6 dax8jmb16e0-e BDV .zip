# Allegro board dax8jmb16e0-e-www.DeviceDB.xyz_.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
ESPI_ALERT#: length 76.1
  TOP w0.102: U4701.L3 207.69,50.36 208.01,50.04 208.01,50.04 208.02,50.04 208.26,50.04 208.73,49.56 209.81,49.56 v2(209.81,49.56) 209.82,49.56 210.13,49.56 210.98,48.71 R4721.2 210.98,48.42 211.18,48.23 212.95,48.23 TP4710.1
  BOTTOM w0.102: v2(209.81,49.56) 207.8,47.54 207.8,47.33 206.23,45.76 203.52,45.76 203.27,45.51 201.54,45.51 201.28,45.77 199.49,45.77 198.16,47.09 198.16,47.99 195.16,51 195.16,55.49 195.06,55.58 191.42,55.58 190.64,54.8 190.64,54.25 189.65,53.26 188.5,53.26 188.03,52.79 185.96,52.79 184.94,53.81 183.93,53.81 182.41,55.33 180.2,55.33 179.2,54.34 176.92,54.34 173.46,57.8 173.46,58.95 172.04,60.37 171.17,60.37 167.12,64.41 167.12,65.58 164.53,68.17 164.53,71.53 164.03,72.02 CN7701.4
ESPI_LPC#: length 20.1
  TOP w0.102: v1(134.38,92.69) 134.82,92.25 134.94,92.25 135.6,91.59 138.67,91.59 138.88,91.38 140.96,91.38 141.17,91.59 142,91.59 142.59,92.18 143.42,92.18 143.79,92.55 v2(143.88,92.55) 144.98,92.55 145.23,92.8 145.45,92.8 145.94,93.29 148.71,93.29 R445.1 150.12,92.28 150.12,92.38 150.25,92.51 151.34,92.51 151.48,92.38 R443.2
  BOTTOM w0.079: v1(134.38,92.69) 134.38,93.01 U400.CG15
EXT_PWR_GATE#: length 167.6
  TOP w0.102: v2(185.07,88.31) 185.07,88.2 182.44,85.57 181.5,85.57 181.05,85.12 181.05,84.6 180.11,83.67 175.49,83.67 174.9,83.08 173.25,83.08 172.55,82.38 171.92,82.38 167.3,77.76 162.22,77.76 160.13,75.67 160.13,75.03 159.36,74.26 159.31,74.26 156.02,70.98 146.56,70.98 146.22,70.64 146.22,69.96 R660.1 146.33,69.45 146.33,67.58 145.49,66.73 137.23,66.73 136.05,67.9 136.05,69.04 136.84,69.83 136.84,70.56 135.54,71.87 135.54,75.44 133.28,77.7 133.28,78.31 133.1,78.49 132.53,78.49 v2(132.03,79) ; v2(128.12,122.74) 127.53,122.14 R3310.1
  IN1 w0.114: v2(178.8,108.08) 178.6,107.88 168.97,107.88 168.42,108.43 166.01,108.43 161.03,113.41 161.03,116.64 160.72,116.95 160.72,118.87 160.03,119.56 160.03,120.94 158.38,122.59 157.57,122.59 157.29,122.3 156.66,122.3 155.84,123.12 151.41,123.12 148.38,120.1 144.31,120.1 142.62,121.79 142.06,121.79 141.35,121.09 135.37,121.09 134.05,122.41 128.45,122.41 v2(128.12,122.74)
  BOTTOM w0.102: v2(185.07,88.31) 185.65,88.31 187.07,89.73 187.07,93.97 186.19,94.85 186.19,96.59 182.23,100.55 182.23,106.86 180.68,108.41 179.13,108.41 v2(178.8,108.08) ; U400.CC37 132.2,79.44 132.03,79.27 132.03,79 v2(132.03,79)
EXT_SMI#: length 115.7
  TOP w0.102: U4701.J4 v3(206.53,50.68)
  IN1 w0.076: v3(206.53,50.68) 206.85,51 206.85,52.77 206.65,52.96 205.71,52.96 205.22,53.45 205.22,53.99 204.96,54.26 204.46,54.26 204.25,54.47 204.25,54.76 204.09,54.92 201.81,54.92 201.66,55.06 201.66,55.76 200.42,57 198.33,57 197.92,56.6 197.14,56.6
  IN1 w0.114: 197.14,56.6 194.88,56.6 193.56,57.91 192.61,57.91 191.18,59.34 188.04,59.34 186.73,58.03 186,58.03 185.94,57.98 184.49,57.98 184.19,58.27 184.19,65.46 184.49,65.75 184.49,76.28 184.19,76.58 184.19,79.21 186.03,81.04 186.03,85.5 185.28,86.26 185.28,86.62 183.87,88.02 183.87,88.63 181.61,90.89 181.61,91.35 178.08,94.88 167.62,94.88 167.22,94.48 165.89,94.48 165.75,94.62 163.8,94.62 161.95,92.77 158.1,92.77 157.84,92.51 157.36,92.51 v2(157.07,92.79)
  BOTTOM w0.079: 144.75,96.86 143.16,96.86 142.57,97.45 142.57,97.84 141.78,98.63 141.44,98.63 141.29,98.78 140.95,98.78 140.1,99.62 139.81,99.62 139.59,99.4 138.7,99.4 138.6,99.36 138.35,99.1 U400.CP6
  BOTTOM w0.102: v2(157.07,92.79) 156.96,92.91 156.96,93.38 156.14,94.19 154.87,94.19 154.34,94.73 153.46,94.73 152.24,95.95 151.59,95.95 151.49,95.84 150.49,95.84 R536.1 149.64,96.69 146.46,96.69 146.29,96.86 144.75,96.86
FAN1_PWM: length 273.4
  TOP w0.076: U4701.G8 204.9,53.61 v3(204.58,53.28)
  TOP w0.102: Q5400.5 49.36,64.98 50.17,64.17 52.21,64.17 52.77,63.61 54.39,63.61 56.74,61.26 56.74,60.24 56.62,60.12 56.62,57.16 57.82,55.96 57.82,54.89 57.52,54.6 51.99,54.6 49.59,52.2 49.59,47.15 45.37,42.93 45.37,39.35 49.9,34.82 53.61,34.82 54.26,34.17 59.61,34.17 59.85,33.93 59.85,33.41 59.72,33.28 59.72,30.73 58.54,29.55 57.81,29.55 v2(57.06,28.79)
  IN1 w0.127: v2(57.06,28.79) 60.62,28.79 61.69,29.85 77.04,29.85 77.99,30.79 81.74,30.79 82.13,30.4 87.8,30.4 88.43,31.02 101.79,31.02 101.8,31.01 102.98,31.01 103.38,31.41 112.79,31.41 113.24,30.96 117.03,30.96 120.57,27.42 123.57,27.42 125.16,29.01 126.55,29.01 127.39,28.17 127.39,27.62 128.15,26.85 129.04,26.85 129.75,26.14 129.75,21.92 130.29,21.38 130.29,20.34 130.65,19.98 133.3,19.98 135.4,17.88 135.4,16.89 137.44,14.85 137.44,13.36 138.36,12.44 143.55,12.44 147.33,8.66 149.79,8.66 150.62,7.83 151.75,7.83 152.05,8.13 154.29,8.13 157.25,11.09 159.85,11.09 160.56,11.8 163.11,11.8 163.86,12.55 173.26,12.55 173.72,13.01 185.66,13.01 185.73,13.09 186.29,13.09 188.57,10.81 190.75,10.81 191.57,11.63 192.92,11.63 193.82,12.53 194.69,12.53 195.81,13.65 197.09,13.65 197.85,14.41 197.85,16.37 203.1,21.62 203.1,33.52 205.98,36.39 v2(205.98,39.25)
  IN2 w0.076: 207.37,46.44 207.38,46.45 207.38,47.68 206.21,48.85 206.21,50.19 206.39,50.36 206.93,50.36 207.01,50.44 207.01,51.38 206.74,51.65 206.39,51.65 206,52.04 205.66,52.04 205.34,52.36 205.34,52.77 204.82,53.28 v3(204.58,53.28)
  IN2 w0.127: 207.37,46.44 207.37,46.43 207.37,40.64 v2(205.98,39.25)
FAN1_PWM_Y: length 5.1
  TOP w0.102: R5401.2 47.73,70.29 47.33,69.88 C5402.1 47.11,70.24 47.01,70.34 v2(47.01,70.63) 46.83,70.63 v2(46.39,71.07)
  BOTTOM w0.102: CN5400.4 47,69.16 47.23,69.39 47.23,70.41 v2(47.01,70.63)
FBVDD_PWROK: length 23.2
  TOP w0.102: R557.2 155.7,97.29 155.53,97.46 154.17,97.46 153.78,97.85 153.53,97.85 153.23,98.15 153.23,98.4 153.12,98.51 152.55,98.51 152.35,98.71 151.3,98.71 v2(151.19,98.81) 150.88,98.5 149.93,98.5 149.57,98.86 146.6,98.86 146.39,98.66 143.64,98.66 142.59,99.71 141.45,99.71 141.36,99.8 139.37,99.8 137.27,97.7 137.27,97.59 v1(136.42,96.74)
  BOTTOM w0.079: U400.CK9 136.26,96.91 v1(136.42,96.74)
FN_KEY_LED#: length 236.4
  TOP w0.102: R5003.1 42.95,50.72 C5025.2 43.98,50.72 44.09,50.83 44.51,50.83 45.16,50.18 46.48,50.18 46.77,49.89 47.51,49.89 48.82,48.59 48.82,47.46 44.61,43.25 44.61,39.04 48.11,35.54 48.11,34.87 50.05,32.92 55.58,32.92 56.01,32.49 v2(58.5,32.49) ; R4760.1 197.06,55.15 197.27,55.36 199.13,55.36 199.43,55.06 200.05,55.06 v2(200.31,54.79) 200.43,54.91 U4701.A10
  IN2 w0.114: v2(200.31,54.79) 200.06,54.54 198.25,54.54 197.97,54.82 196.31,54.82 194.14,52.65 194.14,48.63 195.21,47.56 195.21,46.67 195.59,46.29 195.81,46.29 196.02,46.08 196.02,45.15 196.05,45.12 196.05,44.44 197.42,43.07 197.42,40.9 198.84,39.48 198.84,35.79 197.11,34.05 197.11,31.83 196.7,31.42 196.7,31.06 197.1,30.66 197.1,23.38 195.09,21.37 195.09,19.78 194.51,19.2 193.44,19.2 192.61,18.37 188.81,18.37 188.13,17.69 183.12,17.69 182.42,16.99 176.87,16.99 176.28,16.41 175.15,16.41 174.36,17.2 169.82,17.2 169.28,16.66 157.72,16.66 157.39,16.33 154.65,16.33 154.22,15.9 151.49,15.9 151.1,15.5 144.21,15.5 142.87,16.84 141.64,16.84 141.11,17.37 141.11,17.85 139.11,19.86 134.92,19.86 132.7,22.07 132.41,22.07 131.71,22.77 131.71,25.91 129.53,28.09 129,28.09 128.33,28.77 127.65,28.77 125.41,31.01 120.89,31.01 118.44,33.46 113.53,33.46 112.45,34.54 105.17,34.54 104.61,35.1 89.01,35.1 88.04,34.13 83.84,34.13 82.73,35.24 69.97,35.24 67.78,33.05 66.96,33.05 66.03,32.12 61.43,32.12 61,32.54 58.55,32.54 v2(58.5,32.49)
FPR_LOCK#: length 170.3
  IN1 w0.114: v2(170.54,92.51) 171.24,93.2 174.02,93.2 177.81,89.41 177.81,85.14 178.01,84.94 180.3,84.94 181.69,83.55 181.69,80.69 183.28,79.1 183.28,73.39 182.57,72.67 182.57,69.86 180.64,67.94 180.64,63.91 181.77,62.78 181.77,58.31 185.83,54.25 187.4,52.69 188.17,52.69 190.44,50.42 193.08,50.42 193.83,49.66 195.77,49.66 197.37,48.06 197.37,46.94 199.13,45.17 199.13,43.27 199.96,42.44 199.96,35.82 199.85,35.71 199.85,22.99 194.45,17.59 193.4,17.59 193.34,17.53 185.83,17.53 185.02,18.34 175.61,18.34 174.49,19.47 174.49,20.03 173.85,20.67 v2(173.7,20.67)
  IN2 w0.114: v2(170.54,92.51) 170.04,92 168.41,92 168.13,91.73 162.86,91.73 162.22,91.09 160.28,91.09 159.95,91.42 158.26,91.42 157.84,91 157.57,91 156.92,91.65 156.64,91.65 156.22,92.08 155.08,92.08 155.01,92.15 152.2,92.15 151.47,91.42 150.74,91.42 148.91,93.26 145.65,93.26 144.87,92.48 142.46,92.48 141.72,93.23 140.39,93.23 v2(140.17,93.45)
  BOTTOM w0.079: v2(140.17,93.45) 140.17,93.53 139.69,94 139.15,94 138.94,93.79 138.69,93.79 138.59,93.83 138.27,93.83 138.22,93.8 137.79,93.8 U400.CN14
  BOTTOM w0.102: v2(173.7,20.67) 173.49,20.46 173.49,19.74 174.76,18.48 176.65,18.48 176.89,18.23 C5207.1 177.17,17.8 177.17,17.12 176.92,16.86 R5207.1 177.14,16.62 177.21,16.69 179.21,16.69 179.69,16.22 179.69,14.92 179.45,14.68 CN5201.6
FPR_OFF: length 147.2
  TOP w0.102: v2(132.63,77.98) 132.63,77.89 134.03,76.5 134.03,70.1 134.32,69.81 134.53,69.81 134.85,69.5 R463.1 135.42,69.5 135.64,69.28 135.64,68 137.12,66.51 145.56,66.51 146.87,67.83 v2(146.87,68.24)
  IN2 w0.114: v2(173.08,20.82) 173.24,20.82 173.52,21.09 174.6,21.09 175.46,20.24 178.19,20.24 178.44,19.99 178.44,19.42 178.67,19.19 181.16,19.19 181.53,19.57 181.53,21.33 181.26,21.6 181.26,23.53 183.46,25.73 183.46,36.01 184.26,36.81 187.86,36.81 188.52,36.16 191.15,36.16 194.39,39.4 194.39,40.29 194.82,40.72 194.82,41.86 193.07,43.61 193.07,44.37 191.37,46.07 191.37,48.49 187.56,52.3 186.29,52.3 181.02,57.57 181.02,60.47 178.3,63.19 178,63.19 177.68,63.51 177.68,64.27 176.46,65.49 172.51,65.49 171.47,66.53 168.86,66.53 168.56,66.83 162.41,66.83 162.01,66.42 160,66.42 159.9,66.52 156.98,66.52 155.22,68.28 153.99,68.28 153.25,69.02 148.18,69.02 147.93,68.76 147.4,68.76 v2(146.87,68.24)
  BOTTOM w0.079: v2(132.63,77.98) 132.63,78.53 132.42,78.74 132.42,79.32 132.47,79.43 132.47,79.73 U400.CC36
  BOTTOM w0.102: v2(173.08,20.82) 173.17,20.73 173.17,19.78 174.67,18.27 176.25,18.27 C5207.2 176.44,18.06 176.27,17.89 176.04,17.89 175.48,17.33 175.48,16.8 176.01,16.27 177.08,16.27 177.3,16.49 179.13,16.49 179.48,16.13 179.48,15 178.95,14.46 CN5201.7
G_SDO: length 5
  TOP w0.102: R5305.1 76.21,129.79 v2(76.21,129.49) 76.21,128.95 R5303.2 75.91,128.97 75.49,129.39 73.97,129.39 73.72,129.65 U5301.3
GC6_FB_EN_Q: length 19.7
  BOTTOM w0.079: 143.93,99.62 142.89,100.67 141.94,100.67 141.61,101 139.17,101 138.95,100.78 138.61,100.78 138.44,100.61 137.68,100.61 U400.CN3
  BOTTOM w0.102: R649.1 v2(154.02,96.95) 153.55,97.42 153.55,97.98 153.07,98.46 149.94,98.46 149.55,98.85 146.89,98.85 146.76,98.98 144.58,98.98 143.93,99.62
GPD7: length 13.9
  TOP w0.102: v2(134.88,74.28) v2(134.88,73.46) 134.88,72.46 R654.2 135.61,71.11 R653.1
  BOTTOM w0.079: U400.BV35 128.75,80.27 128.75,78.38 131,76.13 132.99,76.13 133.22,75.91
  BOTTOM w0.102: v2(134.88,74.28) 134.86,74.28 133.23,75.91 133.22,75.91
GPIO40: length 10.9
  TOP w0.076: U4701.E5 v3(203.93,51.33)
  TOP w0.102: v3(205.23,49.38) 205.23,48.86 205.33,48.76 205.48,48.76 205.48,48.75 205.57,48.75 205.82,48.5 205.82,48.15 205.81,48.13 205.81,47.54 205.91,47.44 207.25,47.44 v2(207.59,47.1) 207.8,46.89 208.16,46.89 208.61,46.45 208.61,46.14 208.98,45.76 209.82,45.76 R4765.1
  IN2 w0.076: v3(205.23,49.38) 205.16,49.38 204.73,49.82 204.73,50.34 204.91,50.52 204.91,50.92 204.82,51.01 204.26,51.01 v3(203.93,51.33)
GPP_A11: length 12.3
  TOP w0.102: R495.1 136,73.36 136,74.05 v2(136.2,74.25) 136.2,75.93 133.86,78.27 133.86,79 133.02,79.84 132.57,79.84 131.38,81.03 131.38,81.72 v1(131.1,82)
  BOTTOM w0.079: U400.CA32 131.03,82.23 131.1,82.16 v1(131.1,82)
GPP_B23: length 16
  BOTTOM w0.079: U400.CC34 131.86,80.96 131.83,80.48 131.81,80.41 131.77,80.33 131.77,80.1 131.81,80.02 131.81,79.86 131.81,79.79 131.76,79.69 131.71,79.64 131.64,79.57 131.53,79.27 131.49,79.16 131.48,79.13 131.48,77.98 131.89,77.56 133.83,77.56 135.03,76.37 136.22,76.37 136.77,75.82 v2(137.16,75.82)
  BOTTOM w0.102: v2(137.16,75.82) 137.87,75.82 139.17,74.51 139.17,73.77 140.02,72.92 140.02,71.91 R429.1
GPP_D12: length 7.7
  BOTTOM w0.079: U400.CP22 138.37,89.02 138.59,88.79 138.66,88.76 139.73,88.76 139.76,88.78 140.42,88.78
  BOTTOM w0.102: 140.42,88.78 141.44,88.78 141.87,89.21 145.15,89.21 TP410.1
GPP_D15: length 5
  BOTTOM w0.079: R485.1 140.14,88.12 139.81,87.79 139.37,87.79 139.19,87.97 138.65,87.97 138.6,87.94 138.33,87.94 137.91,88.09 137.41,88.09 U400.CM23
GPP_D19: length 6.4
  BOTTOM w0.102: TP425.1 143.91,87.27 143.53,87.27 143.41,87.4 138.44,87.4 U400.CP24
GPP_F1: length 16.5
  TOP w0.102: v1(136.39,90.63) 137.45,90.63 137.97,90.11 142.35,90.11 143.56,91.31 v2(144.42,91.31) 144.5,91.4 145.66,91.4 146.37,90.68 149.06,90.68 149.1,90.64 149.21,90.64 149.21,90.64 150.76,90.64 150.92,90.79 R519.1
  BOTTOM w0.079: U400.CK19 136.16,90.86 v1(136.39,90.63)
GPP_F2: length 15.3
  TOP w0.102: v1(134.53,91.65) 135.09,91.09 137.63,91.09 138.4,90.32 142.21,90.32 142.58,90.7 142.58,90.72 143.62,91.75 145.61,91.75 146.14,91.22 v2(146.53,91.22) 146.67,91.09 147.6,91.09 R520.1
  BOTTOM w0.079: U400.CG17 134.53,91.83 v1(134.53,91.65)
GPP_F4: length 16.7
  TOP w0.102: v1(135.13,89.6) 135.15,89.6 135.66,89.09 137.7,89.09 137.9,88.88 140.11,88.88 140.48,88.51 142.01,88.51 143.74,90.24 144.51,90.24 145.3,89.45 146.26,89.45 147.17,88.53 148,88.53 v2(148.25,88.79) 148.73,89.27 R471.2
  BOTTOM w0.079: v1(135.13,89.6) 135.13,89.68 U400.CJ20
GPP_F6: length 23.5
  TOP w0.102: v1(134.11,90.65) 134.36,90.39 134.39,90.39 134.76,90.03 135.82,90.03 136.35,89.5 137.94,89.5 138.08,89.35 140.27,89.35 140.67,88.95 141.83,88.95 143.55,90.67 144.69,90.67 145.38,89.98 146.08,89.98 146.38,90.28 148.73,90.28 148.83,90.18 150.99,90.18 151.67,89.5 v2(152.59,89.5) 153.13,88.96 153.75,88.96 154.41,89.61 R470.2
  BOTTOM w0.079: v1(134.11,90.65) 134.11,91 U400.CG19
GPS_XMIT_OFF#: length 94.5
  TOP w0.102: v2(187.14,87.64) 187.01,87.64 185.87,86.5 185.04,86.5 184.02,85.48 182.81,85.48 180.58,83.25 175.67,83.25 175.08,82.66 173.42,82.66 172.72,81.96 172.09,81.96 167.47,77.34 162.39,77.34 161.32,76.27 161.32,75.27 160.83,74.78 160.18,74.78 159.45,74.05 159.4,74.05 156.07,70.72 156.07,70.33 155.34,69.59 154.15,69.59 153.17,68.61 149.28,68.61 148.81,68.14 148.81,67.8 148.09,67.08 146.41,67.08 145.6,66.27 137.06,66.27 135.17,68.15 134.43,68.15 133.91,68.67 133.91,69.22 134.19,69.5 R416.1 133.81,70.01 133.81,76.14 132,77.95 v2(132,78)
  IN2 w0.114: v2(187.14,87.64) 187.41,87.64 189.7,85.35 189.7,84.56 190.77,83.48 190.77,78.02 v2(191.04,77.75)
  BOTTOM w0.079: U400.CC35 132.04,80.47 131.99,80.42 131.96,80.35 131.94,80.29 131.94,80.14 131.98,80.05 131.98,79.86 131.98,79.75 131.9,79.59 131.79,79.47 131.64,79.1 131.64,78.35 v2(132,78)
  BOTTOM w0.102: CN4200.26 194.7,79.18 194.47,78.95 193.17,78.95 192.42,78.2 191.8,78.2 191.35,77.75 v2(191.04,77.75)
GPU_EVENT#: length 9.5
  BOTTOM w0.102: U400.CR26 138.84,86.42 140.34,86.42 140.6,86.17 144,86.17 144.13,86.04 145.27,86.04 145.65,86.42 145.65,87.36 146.54,88.25 R533.2
H_CPU_SVIDALRT#: length 7.8
  BOTTOM w0.079: U400.AA3 106.28,101.41 106.3,101.51 106.3,101.59 106.23,101.81 106.23,101.87 106.28,102.07 106.28,102.09 106.28,102.35 106.02,102.61 106.02,103.33 106.19,103.5 106.19,106.43 v2(106.86,107.1) 107.68,107.1 R612.1
H_PRDY#: length 124.1
  TOP w0.102: v2(41,120.45) 41,120.05 41.06,119.99 41.06,117.42 40.97,117.33 39.89,117.33 39.76,117.45 CN7700.5
  IN2 w0.114: v2(103.59,108.95) 102.69,108.95 102.51,109.12 101.73,109.12 101.09,109.75 95.64,109.75 95.15,110.24 84.45,110.24 78.46,104.25 78.12,104.25 69.99,96.13 68.24,96.13 65.56,93.45 60.71,93.45 60.37,93.1 57.4,90.14 43.1,90.14 42.24,90.99 35.9,90.99 35.28,91.61 35.28,92.27 36.62,93.61 36.62,94.59 37.02,94.99 37.02,101.42 42.14,106.54 42.14,108.33 42.6,108.79 42.6,111.96 42.41,112.15 42.41,114.21 42.93,114.73 42.93,119.19 41.66,120.45 v2(41,120.45)
  BOTTOM w0.079: 104.54,106.15 104.54,105.49 104.46,105.42 104.46,104.02 104.95,103.54 104.95,102.43 104.9,102.39 U400.W1
  BOTTOM w0.102: 104.54,106.15 104.54,106.76 103.96,107.33 103.96,108.58 v2(103.59,108.95)
H_PREQ#: length 127.1
  TOP w0.102: CN7700.3 40.26,119.8 39.3,120.76 R7716.2 39.78,121.54 39.78,122.03 40.05,122.29 41.14,122.29 v2(41.48,121.95)
  IN2 w0.114: v2(41.48,121.95) 41.48,120.96 43.16,119.28 43.16,114.64 42.63,114.12 42.63,112.24 42.83,112.05 42.83,108.7 42.37,108.23 42.37,106.44 38.24,102.31 38.24,95.88 36.84,94.49 36.84,93.51 35.51,92.18 35.51,91.7 35.99,91.22 42.34,91.22 43.19,90.37 57.31,90.37 60.62,93.67 65.46,93.67 68.14,96.35 69.89,96.35 78.02,104.48 78.37,104.48 84.53,110.64 94.34,110.64 94.42,110.72 97.09,110.72 97.62,110.18 99.01,110.18 99.54,110.72 101.91,110.72 103.05,109.58 v2(103.56,109.58)
  BOTTOM w0.079: 104.8,106.13 104.8,105.5 104.63,105.32 104.63,104.14 105.16,103.61 105.16,101.81 U400.W2
  BOTTOM w0.102: 104.8,106.13 104.8,106.79 104.19,107.41 104.19,108.96 v2(103.56,109.58)
H_PWRGD: length 4.3
  BOTTOM w0.079: U400.AR2 114.36,101.86 114.36,102.3 114.5,102.45 114.5,102.91 113.62,103.79 113.62,105.03 113.52,105.13 R457.2
H_TCK: length 126.6
  TOP w0.102: v2(21.62,103.66) 21.62,107.59 20.23,108.99 20.23,111.04 21.82,112.63 21.82,113.88 22.69,114.76 24.54,114.76 26.76,116.98 CN7700.57
  IN1 w0.114: v2(34.58,91.68) 33.17,91.68 21.62,103.24 v2(21.62,103.66)
  IN2 w0.079: 102.59,100.51 102.59,99.7 102.94,99.35 v1(102.94,99.19)
  IN2 w0.114: v2(34.58,91.68) 34.58,91.67 35.77,90.48 39.86,90.48 41.12,89.22 57.78,89.22 58.24,89.68 61.09,92.53 65.94,92.53 68.62,95.21 70.37,95.21 78.49,103.34 78.84,103.34 84.83,109.33 92.2,109.33 92.85,108.69 99.37,108.69 v2(100.43,107.63) 100.43,107.3 100.81,106.92 101.12,106.92 101.84,106.2 102.69,106.2 103.59,105.3 103.59,104.13 102.74,103.28 102.74,100.8 102.59,100.65 102.59,100.51
  BOTTOM w0.079: v1(102.94,99.19) 102.61,98.86 U400.T6
  BOTTOM w0.102: R401.2 R402.1 100.32,107.74 v2(100.43,107.63)
H_TDI: length 114
  TOP w0.102: Q7700.4 26.67,109.34 26.45,109.12 25.48,109.12 24.42,108.06 v2(24.42,107.88)
  IN2 w0.114: v1(103.98,99.02) 103.64,98.68 103.64,98.13 103.48,97.97 103.48,97.41 103.18,97.11 101.02,97.11 100.74,97.39 100.74,98.02 100.47,98.3 95.49,98.3 94.87,98.92 92,98.92 90.71,97.62 80.86,97.62 72.73,89.5 70.98,89.5 68.3,86.82 63.46,86.82 59.12,82.48 57.06,82.48 55.94,81.36 49.97,81.36 49.41,81.91 47.17,81.91 46.62,81.36 45.45,81.36 44.1,82.71 35.51,82.71 28.11,90.12 28.11,95.11 28.96,95.97 28.96,102.24 24.42,106.79 v2(24.42,107.88)
  BOTTOM w0.079: U400.U6 103.82,98.86 v1(103.98,99.02)
H_TDO: length 115.6
  TOP w0.102: Q7701.4 27.65,107.21 24.54,104.1 24.54,93.31 26.83,91.02 41.04,91.02 44.69,87.37 44.69,84.38 47.8,81.26 v2(47.81,81.26)
  IN2 w0.114: v2(47.81,81.26) 48.17,80.9 56.13,80.9 57.25,82.02 59.31,82.02 63.65,86.36 68.49,86.36 71.17,89.04 72.92,89.04 81.05,97.17 90.86,97.17 91.52,97.83 95.53,97.83 96.15,97.21 99.09,97.21 99.71,96.6 99.71,96.35 100.13,95.93 104.3,95.93 104.45,96.09 104.45,96.75 104.59,96.89 104.84,96.89 105.34,97.39 105.34,99.21 v1(104.9,99.65)
  BOTTOM w0.079: v1(104.9,99.65) 105.04,99.51 U400.Y5
H_TMS: length 108.8
  TOP w0.102: Q7700.1 25.37,107 24.11,105.74 24.11,93.13 26.65,90.59 40.32,90.59 44.27,86.64 44.27,84.5 45.98,82.79 v2(45.98,82.2)
  IN2 w0.114: v2(45.98,82.2) 46.26,82.48 49.49,82.48 50.15,81.82 55.75,81.82 56.87,82.94 58.93,82.94 63.27,87.27 68.12,87.27 70.79,89.95 72.55,89.95 80.67,98.08 90.46,98.08 92.47,100.09 95.51,100.09 95.9,100.47 98.08,100.47 98.52,100.03 100.39,100.03 101.05,99.38 102.02,99.38 v1(102.23,99.16)
  BOTTOM w0.079: U400.T5 102.58,99.51 v1(102.23,99.16)
H_TRST#: length 119.3
  TOP w0.102: v2(25.69,104.53) 26.1,104.53 28.01,104.52 29.27,105.79 R7729.2 29.73,106.52 29.73,108.51 28.95,109.28 Q7701.1
  IN2 w0.114: v1(106.75,98.72) 106.33,98.3 106.33,96.4 105.65,95.72 100.04,95.72 99.44,96.32 94.68,96.32 94.5,96.5 94.5,96.98 94.19,97.29 91.29,97.29 90.94,96.94 81.15,96.94 73.02,88.81 71.27,88.81 68.59,86.13 63.74,86.13 59.41,81.79 57.35,81.79 56.23,80.68 43.19,80.68 41.38,82.48 35.42,82.48 27.88,90.02 27.88,95.21 28.74,96.07 28.74,101.42 25.99,104.17 25.99,104.22 v2(25.69,104.53)
  BOTTOM w0.079: v1(106.75,98.72) 106.61,98.86 U400.AB6 U400.Y6
H_VCCST_PWRGD: length 4
  BOTTOM w0.102: R458.1 122.69,107.84 v2(122.69,108.25) 122.69,108.64 Q402.3 123.87,109.13 124.11,108.9 124.11,108.69 R465.2
HD_SDIN0: length 3.5
  TOP w0.102: U3600.7 216.06,11.93 215.13,11 215.13,10.89 214.4,10.17 R3611.2
HDD_HALTLED: length 405.3
  TOP w0.102: R472.2 151.09,81.89 v2(151.12,81.89) ; v2(91.34,130.78) 91.19,130.64 90.31,130.64 89.52,129.84 89.52,128.5 85.53,124.5 80.1,124.5 78.82,123.23 73.83,123.23 73.23,123.83 69.78,123.83 64.64,128.96 50.69,128.96 v2(50.1,128.37) ; v2(183.07,83.81) 182.94,83.81 181.75,82.63 175.92,82.63 175.33,82.04 173.74,82.04 172.87,81.17 172.16,81.17 170.19,79.19 170.19,77.89 169.74,77.44 v2(169.74,77.26) ; v2(30.38,25.86) 30.38,25.42 C7627.1 30.8,25.29 34.25,25.29 v2(34.29,25.25)
  IN1 w0.114: v2(34.29,25.25) 34.29,25.25 35.59,25.25 38.29,27.95 38.29,32.94 37.32,33.9 37.32,49.12 37.68,49.48 37.68,60.28 37.95,60.55 38.54,60.55 38.71,60.72 38.71,61.15 37.82,62.04 37.82,75.51 37.45,75.88 37.45,81.46 28.2,90.71 28.2,92.09 26.61,93.69 25.72,93.69 17.6,101.8 17.6,103.75 16.7,104.65 16.7,107.46 20.72,111.47 20.72,113.64 26.17,119.09 26.17,122.36 24.45,124.08 24.45,127.62 25.08,128.25 25.87,128.25 26.3,128.68 28.61,128.68 29.08,128.2 31.28,128.2 31.87,127.61 35.28,127.61 35.78,127.11 37.73,127.11 38.93,128.31 39.8,128.31 40.32,128.82 49.65,128.82 v2(50.1,128.37) ; v2(157.62,129.49) 157.19,129.07 147.38,129.07 146.63,128.33 142.13,128.33 141.42,129.04 132.54,129.04 131.57,128.08 122.49,128.08 120.98,129.58 92.1,129.58 91.34,130.34 v2(91.34,130.78) ; v2(151.28,75.37) 150.83,74.92 150.83,74.27 151.27,73.84 153.07,73.84 153.3,74.07 153.3,75.27 153.5,75.47 154.55,75.47 155.16,74.86 158.03,74.86 159.46,76.3 164.86,76.3 166.05,75.11 166.83,75.11 168.74,77.02 169.5,77.02 v2(169.74,77.26)
  BOTTOM w0.102: v2(183.07,83.81) 182.69,84.19 182.69,86.69 182.52,86.86 182.52,89.17 183.93,90.58 183.93,93.23 183.45,93.72 183.45,95.92 178.8,100.57 178.8,106.26 174.54,110.52 167.54,110.52 162.73,115.33 162.73,116.09 157.77,121.04 157.77,122.03 158.41,122.66 158.41,124.99 157.18,126.21 157.18,129.06 v2(157.62,129.49) ; v2(30.38,25.86) 30.54,25.86 31.07,25.34 33.63,25.34 34.24,25.95 CN7601.22 ; R487.1 146.7,94.22 147.43,93.49 152.46,93.49 152.82,93.13 152.91,93.13 154.14,91.9 154.14,90.76 154.26,90.63 154.26,88.93 154.01,88.68 154.01,85.68 153.81,85.48 153.79,85.48 151.12,82.8 v2(151.12,81.89) 151.06,81.82 150.68,81.45 150.68,77.17 151.52,76.33 151.52,75.61 v2(151.28,75.37)
HDMI_HPD: length 57
  TOP w0.102: U3501.25 216.3,90.82 v2(216.57,91.09) ; v2(230.82,62.03) 230.56,61.77 VC3500.1 230.28,61.64 230.28,62.09 C3520.1 230.01,62.89 229.8,63.1 229.8,65.37 CN3500.19
  IN1 w0.114: v2(230.82,62.03) 230.56,61.78 230.56,61.24 230.01,60.69 229.75,60.69 229.52,60.46 228.99,60.46 228.91,60.53 228.05,60.53 225.3,63.28 225.3,65.2 224.98,65.53 224.98,73 224.44,73.54 224.44,76.03 215.98,84.48 215.98,85.94 215.27,86.65 215.27,92.92 216.31,93.96 217.51,93.96 217.79,93.68 217.79,93.38 217.29,92.87 217.29,92.11 216.57,91.39 v2(216.57,91.09)
HDMI_HPD_CON: length 87
  TOP w0.102: v2(211.05,90.96) 211.19,90.82 U3501.3
  IN2 w0.114: v2(157.72,93.02) 158,92.73 158.88,92.73 159.43,92.18 167.21,92.18 168.11,93.08 171.71,93.08 171.95,92.84 176.24,92.84 177.89,94.5 184.54,94.5 189.19,89.85 190.31,89.85 190.76,89.41 190.76,89 v2(190.33,88.58)
  BOTTOM w0.079: 144.64,97.09 143.17,97.09 142.74,97.52 142.74,97.91 141.85,98.8 141.51,98.8 141.36,98.94 141.02,98.94 140.17,99.79 139.74,99.79 139.52,99.57 138.66,99.57 138.5,99.49 138.37,99.36 137.72,99.36 U400.CN6
  BOTTOM w0.102: v2(157.72,93.02) 156.32,94.42 155.3,94.42 155.3,94.42 154.96,94.42 154.43,94.96 153.64,94.96 R539.1 151.59,97 150.33,97 150.23,96.89 146.59,96.89 146.39,97.09 144.64,97.09 ; v2(211.05,90.96) 211.35,91.26 211.35,91.76 209.43,93.68 207.59,93.68 206.13,92.22 203.64,92.22 202.35,90.93 200.76,90.93 199.37,89.54 192.87,89.54 191.91,88.58 v2(190.33,88.58)
HDMI_UP_CLK: length 54.7
  TOP w0.102: U3501.28 214.17,92.96 214.05,93.07 214.05,93.14 214.17,93.26 214.51,93.26 215.2,92.58 216.53,92.58 v2(216.74,92.36)
  IN1 w0.127: v2(216.74,92.36) 216.54,92.56 216.24,92.56 216.05,92.38 216.05,87.62 217.08,86.59 217.08,84.77 226.09,75.75 226.09,69.07 227.21,67.95 227.21,62.62 228.41,61.42 229,61.42 v2(229.19,61.62)
  BOTTOM w0.102: CN3500.15 230.95,68.51 230.95,66.68 229.01,64.75 227.64,64.75 227.41,64.52 227.41,64.22 227.51,64.12 C3518.1 227.39,63.59 227.39,62.99 R3510.2 227.49,62.51 227.36,62.39 227.36,61.68 227.57,61.47 229.05,61.47 v2(229.19,61.62)
HDMI_UP_DATA: length 55.8
  TOP w0.102: U3501.29 213.77,92.98 213.84,93.05 213.84,93.23 214.08,93.48 214.6,93.48 215.29,92.79 216.51,92.79 v2(216.74,93.02)
  IN1 w0.127: v2(229.19,60.96) 229.01,61.14 228.29,61.14 226.93,62.5 226.93,67.83 225.81,68.95 225.81,75.63 216.8,84.65 216.8,86.48 215.78,87.5 215.78,92.49 216.12,92.84 216.56,92.84 v2(216.74,93.02)
  BOTTOM w0.102: CN3500.16 230.73,67.89 230.73,66.77 228.93,64.97 227.55,64.97 227.2,64.61 227.2,64.28 227.04,64.12 C3517.1 227.17,63.61 227.17,62.96 R3511.2 227.04,62.51 227.15,62.4 227.15,61.59 227.48,61.26 228.89,61.26 v2(229.19,60.96)
HOOK2: length 5.2
  TOP w0.102: R7725.2 29.88,120.93 30.07,121.12 R7718.1 ; R7725.2 29.76,120.61 CN7700.45 ; R7725.2 29.88,121.36 29.88,122.43 29.8,122.52 v2(29.8,122.52)
HOOK3: length 355
  TOP w0.102: R7728.2 27.8,121.33 28.2,120.93 C7701.2 28.85,120.55 29.02,120.55 29.26,120.31 CN7700.47 ; R7728.2 v2(27.41,120.53) ; R7728.2 26.74,121.33 26.53,121.12 26.53,120.38 21.41,115.26 21.41,112.79 19.82,111.2 19.82,106.89 21.06,105.64 21.06,92.13 31.48,81.72 31.48,79.81 33.13,78.16 36.43,78.16 37.55,77.04 41.66,77.04 42.02,77.4 45.5,77.4 v2(46.42,76.48) ; v2(176.21,73.59) 176.16,73.54 R7727.2
  IN1 w0.127: v2(176.21,73.59) 175.7,74.1 175.12,74.1 174.86,73.84 174.86,73.34 173.12,71.6 173.12,70.82 174.58,69.36 174.58,68.62 173.93,67.98 172.64,67.98 170.51,65.85 170.51,65.24 170.87,64.88 170.87,63.05 171.84,62.08 172.2,62.08 177.67,56.61 178.76,56.61 181.08,54.29 181.08,53.9 182.25,52.74 182.66,52.74 185.9,49.5 186.78,49.5 187.86,48.42 188.01,48.42 189.13,47.31 191.34,47.31 195.8,42.85 195.8,40.36 196.05,40.12 196.05,39.2 195.47,38.62 195.47,36.1 195.59,35.98 195.59,31.26 196.47,30.37 196.47,26.26 194.55,24.34 194.55,22.41 192.5,20.36 192.3,20.36 191.43,19.49 187.94,19.49 186.76,20.68 185.07,20.68 184.87,20.87 184.11,20.87 183.93,20.69 182.54,20.69 182.25,20.4 182.25,19.64 181.47,18.85 176.03,18.85 175.14,19.74 175.14,20.31 174.71,20.75 174.71,22.3 174.25,22.75 173.36,22.75 173.07,22.46 172.78,22.46 172.3,21.99 172.3,21.69 168.79,18.18 163.68,18.18 163.39,18.47 157.84,18.47 156.83,17.46 146.9,17.46 146.59,17.76 142.68,17.76 138.74,21.7 138.74,22.43 137.36,23.82 135.06,23.82 133.97,24.91 133.97,27.54 133,28.5 132.4,28.5 129.11,31.8 121.19,31.8 119.47,33.52 114.31,33.52 113.66,34.17 104.33,34.17 103.67,34.83 93.44,34.83 93.32,34.71 87.84,34.71 86.55,33.42 83.09,33.42 82.88,33.63 66.12,33.63 65.93,33.44 61.41,33.44 60.13,34.71 49.57,34.71 44.99,39.3 44.99,43.31 46.33,44.65 46.33,50.16 47.76,51.59 47.76,63.11 46.79,64.08 46.79,69.73 47.86,70.81 47.86,74.72 48.12,74.97 48.12,75.87 47.5,76.48 v2(46.42,76.48)
HPOUT_JD: length 18.8
  TOP w0.381: CN3601.6 231.89,9.96 229.94,9.96 229.5,9.52 228.02,9.52 227.72,9.22 D3600.1 227.73,8.82 v2(228.51,8.82) ; R3614.2 219.77,7.17 v2(220.06,7.46)
  IN2 w0.381: v2(220.06,7.46) 220.01,7.51 220.01,8.71 221.21,9.91 223.15,9.91 223.3,9.76 224.52,9.76 224.75,9.99 226.02,9.99 227.19,8.82 v2(228.51,8.82)
HPOUT_L_C: length 3.2
  TOP w1.016: 226.91,13.59 227.16,13.85 227.16,16.68
  vias: v2(227.01,12.32)
HPOUT_R_C: length 13.6
  IN2 w1.016: v2(226.07,14.25) 226.07,11.38 v2(226.8,10.65) 227.59,9.86 234.54,9.86 CN3601.2
I2C_C1_CLK: length 255.7
  TOP w0.079: v1(135.77,94.77) 136.02,95.03 136.11,95.03 136.21,95.12 136.72,95.12 136.9,95.3
  TOP w0.102: 136.9,95.3 138.54,96.94 138.54,97.9 138.9,98.25 141.35,98.25 141.78,97.83 145.61,97.83 146.01,97.43 149.1,97.43 149.11,97.42 151.94,97.42 152.12,97.6 153.74,97.6 154.27,97.08 154.77,97.08 154.84,97 R488.1 155.28,97 155.42,96.87 155.42,96.69 156.44,95.67 156.88,95.67 159.24,98.04 162.57,98.04 162.74,97.86 165.99,97.86 166.56,98.43 166.56,99.7 166.2,100.06 166.2,101.53 v2(165.57,102.16)
  IN1 w0.114: v2(57.43,91.15) 57.62,91.35 64.22,91.35 66.2,93.33 72.73,93.33 83.22,103.82 83.22,105.5 88.76,111.03 v2(88.76,111.45)
  IN2 w0.114: v2(88.76,111.45) 88.78,111.47 102.22,111.47 103.12,110.57 108.17,110.57 110.82,113.22 115.7,113.22 117.26,114.78 119.11,114.78 120.4,116.08 122.58,116.08 124.85,118.35 130.93,118.35 131.08,118.2 140.11,118.2 140.57,117.74 143.75,117.74 144.64,118.63 154.36,118.63 v2(154.46,118.53) ; v2(66.78,67.98) 66.05,67.25 66.05,57.01 54.05,45.01 51.46,45.01 50.81,44.36 50.81,42.9 52.41,41.31 52.41,38.25 53.53,37.13 62.21,37.13 64.13,35.21 v2(64.13,34.54)
  BOTTOM w0.102: R6214.2 63.99,33.89 64.13,34.02 v2(64.13,34.54) ; v2(165.57,102.16) 165.57,105.09 164.27,106.38 163.34,106.38 161.55,108.17 161.55,109.04 154.92,115.67 154.92,117.91 154.46,118.37 v2(154.46,118.53) ; U400.CJ12 135.77,95 v1(135.77,94.77) ; v2(57.43,91.15) 57.66,90.92 57.66,76.32 59.35,74.62 62.46,74.62 66.52,70.56 66.52,68.24 v2(66.78,67.98)
I2C_C1_DATA: length 254.7
  TOP w0.102: v2(166.23,102.14) 166.43,101.94 166.43,100.13 166.79,99.77 166.79,98.35 166.08,97.64 162.65,97.64 162.49,97.81 159.34,97.81 156.99,95.46 155.43,95.46 154.41,96.48 153.72,96.48 153.4,96.8 R489.1 152.88,96.98 152.65,96.75 152.23,96.75 151.79,97.19 150.03,97.19 150.02,97.19 149.01,97.19 148.99,97.21 145.81,97.21 145.4,97.62 141.66,97.62 141.41,97.87 139.12,97.87 138.77,97.52 138.77,96.85 136.69,94.77 v1(136.35,94.77)
  IN1 w0.114: v2(88.32,111.91) 88.32,110.92 82.99,105.59 82.99,103.91 72.64,93.56 66.11,93.56 64.13,91.58 57.16,91.58 56.83,91.25 v2(56.83,90.94)
  IN2 w0.114: v2(154.75,119.11) 154.44,119.11 154.19,118.86 144.54,118.86 143.66,117.97 140.66,117.97 140.2,118.43 131.18,118.43 131.02,118.59 124.76,118.59 122.48,116.31 120.31,116.31 119.01,115.01 117.17,115.01 115.6,113.45 110.73,113.45 109.16,111.88 106.38,111.88 105.3,110.8 103.21,110.8 102.13,111.88 89.91,111.88 89.88,111.91 v2(88.32,111.91) ; v2(64.76,34.57) 64.76,34.95 62.35,37.36 54.34,37.36 53.43,38.27 53.43,41.07 52.84,41.66 52.84,44.1 53.12,44.38 53.74,44.38 66.28,56.92 66.28,66.76 v2(66.84,67.32)
  BOTTOM w0.102: v2(166.23,102.14) 166.23,104.72 164.36,106.59 163.43,106.59 161.76,108.26 161.76,109.12 155.15,115.73 155.15,118.06 154.87,118.35 154.87,118.99 v2(154.75,119.11) ; R6215.2 65.13,33.89 65.05,33.97 65.05,34.28 v2(64.76,34.57) ; v1(136.35,94.77) 136.35,95.07 U400.CK12 ; v2(66.84,67.32) 66.31,67.84 66.31,70.48 62.38,74.42 59.27,74.42 57.45,76.23 57.45,88.84 56.83,89.46 v2(56.83,90.94)
I2C_CLICK_SCL: length 6.6
  BOTTOM w0.102: v2(64.56,33.38) 64.56,32.14 64.13,31.71 R6214.1 64.12,31.59 C6205.1 63.66,30.19 63.66,29.01 63.01,28.36 CN6200.3
I2C_CLICK_SDA: length 5.9
  BOTTOM w0.102: CN6200.2 63.51,28.33 63.66,28.48 64.27,28.48 64.58,28.78 64.58,30.09 C6206.1 R6215.1 v2(65.98,31.71)
I2C_TS_SCL: length 263.8
  TOP w0.102: v2(33.44,131.38) 33.36,131.29 33.36,130.94 R3422.2
  IN1 w0.114: v2(87.46,111.92) 87.46,110.7 82.53,105.78 82.53,104.1 72.45,94.02 65.5,94.02 63.52,92.03 55.73,92.03 55.4,91.7 v2(53.88,91.7)
  IN2 w0.114: v2(87.46,111.92) 87.46,111.97 88.09,112.61 89.83,112.61 90.1,112.34 102.32,112.34 103.4,111.26 105.11,111.26 106.19,112.34 108.97,112.34 110.54,113.91 115.41,113.91 116.98,115.47 118.83,115.47 120.12,116.76 122.29,116.76 124.57,119.04 131.21,119.04 131.37,118.88 140.39,118.88 140.85,118.43 143.47,118.43 144.35,119.32 153.52,119.32 153.73,119.52 v2(153.73,120.2) ; v2(163.94,92.95) 163.4,92.41 159.52,92.41 158.97,92.96 158.49,92.96 157.42,94.04 154.67,94.04 153.75,93.11 151.77,93.11 151.66,93 150.47,93 149.13,94.35 148.88,94.35 148.18,95.04 145.9,95.04 144.56,96.38 143.34,96.38 142.84,95.88 142.84,95.65 141.86,94.68 141.11,94.68 140.68,95.1 v2(140.68,95.41)
  BOTTOM w0.079: U400.CN11 138.15,96.04 138.27,96.16 138.35,96.19 138.53,96.19 138.62,96.15 138.97,96.15 139.03,96.21 139.79,96.21 139.87,96.3 140.53,96.3 140.62,96.21 140.62,95.47 v2(140.68,95.41)
  BOTTOM w0.102: CN3400.21 33.15,131.77 33.44,131.48 v2(33.44,131.38) 33.01,130.94 32.98,130.94 32.24,130.21 31.71,129.68 31.71,129.09 32.09,128.71 33.64,128.71 35.34,127.01 35.34,125.86 34.87,125.39 33.65,125.39 32.07,123.81 30.7,123.81 29.63,122.74 27.7,122.74 26.89,121.93 26.89,104.53 24.61,102.25 24.61,94.59 25.83,93.36 25.83,90.7 26.95,89.59 36.81,89.59 37.45,88.96 40.57,88.96 41.26,88.26 49.7,88.26 53.13,91.7 v2(53.88,91.7) ; v2(163.94,92.95) 163.51,93.38 163.51,94.26 163.97,94.73 163.97,99.01 163.35,99.63 163.35,101.92 164.29,102.86 164.29,104.86 163.83,105.32 162.9,105.32 160.49,107.73 160.49,108.6 153.86,115.23 153.86,117.45 153.34,117.97 153.34,119.02 153.6,119.28 153.6,119.59 153.73,119.72 v2(153.73,120.2)
I2C_TS_SDA: length 263.5
  TOP w0.102: v2(32.81,131.38) 32.67,131.24 R3421.2
  IN1 w0.114: v2(87.03,111.45) 87.03,110.6 82.3,105.87 82.3,104.2 72.35,94.25 65.41,94.25 63.42,92.26 53.98,92.26 v2(53.88,92.36)
  IN2 w0.114: v2(153.22,119.74) 153.1,119.62 144.34,119.62 143.37,118.66 140.95,118.66 140.49,119.11 131.46,119.11 131.3,119.27 124.48,119.27 122.2,116.99 120.02,116.99 118.73,115.7 116.37,115.7 116.08,115.42 114.44,115.42 113.15,114.13 109.73,114.13 108.16,112.57 106.1,112.57 105.02,111.49 103.5,111.49 102.41,112.57 90.19,112.57 89.91,112.85 87.79,112.85 87.03,112.09 v2(87.03,111.45) ; v2(141.17,95.96) 141.1,95.89 141.1,95.13 141.33,94.91 141.77,94.91 142.61,95.75 142.61,95.98 143.24,96.61 144.65,96.61 145.99,95.27 148.28,95.27 148.93,94.62 149.17,94.62 150.56,93.23 151.56,93.23 151.68,93.34 153.47,93.34 154.42,94.29 157.48,94.29 158.58,93.19 159.07,93.19 159.62,92.64 162.95,92.64 v2(163.3,92.99)
  BOTTOM w0.079: v2(141.17,95.96) 140.66,96.46 139.8,96.46 139.72,96.38 138.96,96.38 138.9,96.32 138.66,96.32 138.57,96.35 138.28,96.35 138.2,96.33 138.15,96.28 137.88,96.19 137.4,96.19 U400.CM11
  BOTTOM w0.102: v2(163.3,92.99) 163.3,94.35 163.77,94.82 163.77,98.92 163.14,99.55 163.14,102 164.09,102.95 164.09,104.77 163.75,105.11 162.82,105.11 160.28,107.65 160.28,108.51 153.65,115.14 153.65,117.28 153.14,117.79 153.14,119.66 v2(153.22,119.74) ; v2(53.88,92.36) 54.28,91.96 54.28,91.53 54.04,91.29 53.01,91.29 49.77,88.05 41.13,88.05 40.48,88.7 37.19,88.7 36.56,89.34 26.89,89.34 25.62,90.61 25.62,93.27 24.39,94.5 24.39,102.34 26.67,104.62 26.67,122.02 27.59,122.94 29.54,122.94 30.61,124.01 31.98,124.01 33.57,125.6 34.79,125.6 35.14,125.95 35.14,126.92 33.55,128.5 32.01,128.5 31.51,129 31.51,129.9 32.02,130.4 32.15,130.4 32.81,131.07 32.81,131.14 32.86,131.18 32.86,131.32 v2(32.81,131.38) 32.65,131.54 CN3400.22
I_ADP_ADC0: length 259
  TOP w0.102: R4766.2 197.62,46.06 196.83,45.26 195.46,45.26 194.97,45.75 194.97,46.7 194.57,47.1 191.63,47.1 191.25,47.48 188.48,47.48 187.9,48.06 185.68,48.06 185.07,47.45 181.67,47.45 180.38,46.15 145.77,46.15 145.14,45.52 104.64,45.52 101.73,48.43 57.17,48.43 56.19,49.41 56.19,49.99 55.92,50.27 53.91,50.27 53.7,50.48 51.99,50.48 v2(51.97,50.45)
  IN1 w0.114: v2(51.97,50.45) 50.63,50.45 49.64,49.46 49.64,48.19 47.45,46 47.45,43.9 46.11,42.56 46.11,39.76 50.04,35.84 70.11,35.84 70.73,35.22 82.88,35.22 83.56,34.54 86.08,34.54 87.38,35.84 92.62,35.84 92.73,35.95 114.89,35.95 116.19,34.64 119.99,34.64 121.71,32.92 129.57,32.92 132.39,30.1 132.93,30.1 133.34,29.7 v2(133.34,29.42)
  BOTTOM w0.102: v2(133.34,29.42) 133.05,29.14 PR8229.1
I_ADP_ADC0_R: length 10.9
  TOP w0.076: R4766.1 199.09,46.73 199.67,46.73 200.42,47.48 201.58,47.48 202.08,47.99 v2(202.42,47.99)
  TOP w0.102: U4701.F2 204.05,49.71 203.74,50.02 203.41,50.02 203.28,49.89 203.28,48.05 v2(203.39,47.95) 203.39,46.85 203.02,46.48 C4726.2
  BOTTOM w0.102: v2(203.39,47.95) 202.46,47.95 v2(202.42,47.99)
I_DCHG_ADC1: length 127.9
  TOP w0.102: v2(206.6,46.7) 206.18,46.28 R4708.2
  IN1 w0.114: v2(206.6,46.7) 206.14,46.24 206.14,40.1 206.46,39.78 206.46,36.35 203.47,33.36 203.47,21.47 198.23,16.22 198.23,14.23 197.26,13.26 195.96,13.26 194.79,12.1 193.92,12.1 193.08,11.26 191.73,11.26 190.91,10.44 187.62,10.44 185.48,12.58 173.92,12.58 173.44,12.1 164.04,12.1 163.37,11.43 160.8,11.43 160.09,10.72 157.88,10.72 v2(155.77,8.61)
  BOTTOM w0.102: v2(155.77,8.61) 153.53,6.37 146.4,6.37 144.99,7.79 144.99,9.46 143.35,11.11 141.11,11.11 140.75,11.46 138.27,11.46 135.8,13.92 135.8,15.05 137.75,17 137.75,17.94 137.24,18.45 137.24,22.03 137.42,22.21 137.82,22.21 138.31,22.69 138.31,23.75 136.81,25.25 136.81,25.35 136.29,25.88 135.96,25.88 134.98,26.85 134.98,28.12 134.78,28.33 133.83,28.33 PR8230.1
I_DCHG_ADC1_R: length 9.3
  TOP w0.102: U4701.E3 203.73,50.36 204.04,50.05 204.47,50.05 204.58,49.94 204.58,48.58 204.92,48.24 204.92,47.44 205.03,47.32 205.22,47.32 205.73,46.82 205.73,45.74 R4708.1 206.18,44.81 v2(205.85,44.48) 205.68,44.31 204.83,44.31 204.63,44.51 C4727.2
I_SET: length 48.8
  TOP w0.102: PQ8501.3 153.06,9.25 v2(153.3,9.49)
  IN1 w0.114: v2(122,28.45) 122,28.76 123.09,29.84 126.89,29.84 127.81,28.92 128.52,28.92 128.84,28.6 129.53,28.6 130.58,27.55 130.58,22.26 131.93,20.92 133.54,20.92 136.23,18.22 136.23,17.24 138.48,14.99 140.35,14.99 141.23,14.1 142.8,14.1 142.94,13.96 151.43,13.96 153.3,12.1 v2(153.3,9.49)
  BOTTOM w0.102: PR8211.2 123.35,28.47 122.83,28.99 122.28,28.99 122,28.71 v2(122,28.45)
IM_5S_CLK: length 183.8
  TOP w0.102: v2(56.96,49.97) 58.14,48.79 101.88,48.79 104.79,45.88 144.99,45.88 145.62,46.51 179.87,46.51 181.17,47.8 184.92,47.8 185.56,48.44 188.02,48.44 188.37,48.09 191.5,48.09 192.14,47.45 197.16,47.45 197.34,47.28 R4718.2 197.81,47.52 198.43,47.52 198.53,47.42 198.89,47.06 199.53,47.06 200.28,47.8 201.35,47.8 202.3,48.76 U4701.C1
  IN2 w0.127: v2(56.96,49.97) 56.96,49.52 53.58,46.14 50.99,46.14 48.93,44.08 48.93,42.27 50.38,40.82 50.38,38.68 53.06,35.99 61.74,35.99 62.78,34.95 v2(62.78,34.42)
  BOTTOM w0.102: v2(62.78,34.42) 62.78,34.16 61.58,32.96 R6211.1
IM_5S_DAT: length 182.8
  TOP w0.102: v2(57.72,50.14) 58.59,49.27 102.08,49.27 104.99,46.36 144.61,46.36 145.37,47.12 179.62,47.12 180.79,48.29 184.44,48.29 185.1,48.95 188.19,48.95 188.45,48.7 191.75,48.7 192.52,47.94 197.21,47.94 197.31,48.03 R4717.2 197.89,47.71 198.5,47.71 198.97,47.25 199.46,47.25 200.2,47.99 201.25,47.99 201.98,48.72 201.98,49.38 U4701.B2
  IN2 w0.127: v2(57.72,50.14) 57.72,49.38 53.84,45.51 51.25,45.51 50.31,44.57 50.31,42.69 51.41,41.59 51.41,38.54 53.33,36.63 62,36.63 63.41,35.22 v2(63.41,34.49)
  BOTTOM w0.102: v2(63.41,34.49) 63.41,33.2 R6212.1
IMVP_PSYS: length 194.1
  TOP w0.102: v2(65.29,72.41) 64.57,73.13 56.17,73.13 51.95,77.35 51.95,84 52.61,84.66 52.61,87.77 51.57,88.81 51.57,101.73 50.45,102.85 49.26,102.85 49.03,102.62 PR8846.1 49.03,102.09 48.88,101.94 48.38,101.94 PR8850.2 PC8813.2
  TOP w0.203: PC8813.2 46.45,101.52 46.19,101.78 45.55,101.78 45.2,101.43 PU8800.42
  IN2 w0.114: v2(135.16,25.94) 135.16,27.74 134,28.9 132.4,28.9 130.71,30.6 130.71,30.86 129.62,31.95 128.14,31.95 126.48,33.61 122.31,33.61 118.26,37.65 114.32,37.65 113.8,37.14 108.32,37.14 107.76,37.71 84.44,37.71 83.57,36.84 67.63,36.84 64.51,33.72 62.15,33.72 61.39,34.48 60.84,34.48 60.18,35.13 52.02,35.13 51.54,35.62 50.02,35.62 45.93,39.71 45.93,43.09 49.62,46.79 49.62,48.87 49.28,49.21 49.28,53.65 50.06,54.42 53.04,54.42 53.93,55.31 53.93,55.71 53.32,56.32 53.32,59.53 55.04,61.25 55.04,61.77 58.28,65 58.28,65.43 65.26,72.41 v2(65.29,72.41)
  BOTTOM w0.102: v2(135.16,25.94) 134.93,26.17 PC8223.1 134.48,26.5 134.4,26.58 PR8235.2
IMVP_PSYS_EC: length 286.9
  TOP w0.102: PR8846.2 50.72,102.29 51.37,101.65 51.37,94.5 v2(49.77,92.9) ; v2(205.16,44.71) 205.22,44.77 R4707.1
  IN1 w0.114: v2(205.16,44.71) 204.96,44.51 204.96,35.93 203.99,34.96 202.72,33.69 202.72,21.78 195.87,14.92 195.87,14.23 194.64,13.01 193.77,13.01 192.77,12.01 191.42,12.01 190.59,11.18 188.72,11.18 186.45,13.46 164.19,13.46 162.9,12.18 160.41,12.18 159.7,11.47 157.09,11.47 154.69,9.07 152.25,9.07 151.85,9.47 147.04,9.47 143.7,12.82 138.52,12.82 137.82,13.52 137.82,15.01 135.78,17.05 135.78,18.03 133.46,20.35 130.81,20.35 130.66,20.49 130.66,21.54 130.13,22.07 130.13,27.36 129.34,28.15 128.65,28.15 128.33,28.47 127.62,28.47 126.7,29.39 125.01,29.39 123.41,27.79 120.72,27.79 117.19,31.33 113.4,31.33 112.94,31.79 103.23,31.79 102.82,31.38 101.96,31.38 101.94,31.4 88.27,31.4 87.65,30.77 82.4,30.77 82,31.17 69.66,31.17 69.03,30.54 61.85,30.54 60.87,29.57 57.44,29.57 57.36,29.65 54.44,29.65 53.89,30.2 52.71,30.2 51.95,29.45 49.94,29.45 47.69,31.7 47.69,34.11 45.23,36.56 44.05,36.56 43.44,37.18 43.44,38.34 43.27,38.51 43.27,43.87 42.26,44.87 42.26,46.82 42.98,47.54 42.98,49.44 42.4,50.02 42.4,55.3 42.73,55.63 42.73,59.4 43.63,60.29 43.63,66.64 44.15,67.16 44.15,69.03 43.17,70.01 43.17,76.39 44.31,77.53 44.31,79.94 43.31,80.94 43.31,81.57 43.85,82.12 43.85,85.84 49.34,91.33 49.34,92.75 49.49,92.9 v2(49.77,92.9)
IN_CLK: length 131.9
  TOP w0.097: C3515.2 209.44,86.96 209.2,86.72 208.78,86.72 208.58,86.91 v2(208.58,87.1)
  IN2 w0.114: v2(208.58,87.1) 208.58,86.94 208.67,86.85 209.41,86.85 209.67,87.11 209.67,88.33 211.5,90.16 211.5,92.38 211.18,92.7 211.18,94.31 208.9,96.59 208.9,96.78 208.81,96.87 208.73,96.95 206.9,98 203.64,98 201.79,99.85 200.85,99.85 200.08,100.62 200.08,101.12 199.59,101.62 198.88,101.62 194.56,105.33 191.2,108.69 187.18,108.69 184.6,111.28 176.81,111.28 176.06,110.53 171.91,110.53 171.16,111.28 168.44,111.28 166.53,113.19 143.26,113.19 143.11,113.04 140.38,113.04 138.8,111.46 133.65,111.46 133.38,111.73 129.55,111.73 128.97,112.3 127.98,112.3 127.33,111.66 123.2,111.66 121.73,110.19 119.64,110.19 117.68,108.23 116.17,108.23 113.19,105.26 113.19,103.94 112.73,103.48 112.73,102.62 112.16,102.05 110.82,102.05 109.96,101.2 108.85,101.2 108.16,100.51 108.16,99.54 v1(107.72,99.1)
  BOTTOM w0.102: U400.AE6 107.96,98.86 v1(107.72,99.1)
IN_CLK#: length 131.9
  TOP w0.097: C3516.2 209.45,86.38 209.31,86.52 208.77,86.52 v2(208.58,86.33)
  IN2 w0.114: v2(208.58,86.33) 208.87,86.62 209.5,86.62 209.9,87.02 209.9,88.24 211.72,90.06 211.72,92.48 211.41,92.79 211.41,94.4 209.13,96.69 209.13,96.88 208.97,97.03 208.87,97.14 208.84,97.15 207.93,97.67 206.96,98.23 203.73,98.23 201.88,100.08 200.95,100.08 200.31,100.72 200.31,101.22 199.68,101.85 198.97,101.85 196.19,104.23 194.72,105.49 191.29,108.92 187.28,108.92 184.69,111.5 176.71,111.5 175.97,110.76 172,110.76 171.25,111.51 168.53,111.51 166.62,113.42 143.16,113.42 143.01,113.27 140.28,113.27 138.71,111.69 133.74,111.69 133.48,111.96 129.64,111.96 129.07,112.53 127.88,112.53 127.24,111.89 123.1,111.89 121.64,110.42 119.54,110.42 117.59,108.46 116.07,108.46 112.96,105.35 112.96,104.04 112.5,103.58 112.5,102.72 112.07,102.28 110.72,102.28 109.87,101.43 108.75,101.43 107.93,100.61 107.93,99.96 v1(107.71,99.73)
  BOTTOM w0.102: U400.AE5 107.94,99.51 v1(107.71,99.73)
IN_D0: length 130.3
  TOP w0.097: v2(208.07,89.1) 208.42,88.75 209.3,88.75 209.44,88.89 C3513.2
  IN2 w0.114: v2(208.07,89.1) 207.76,88.79 207.52,88.79 206.66,89.66 206.66,90.07 206.85,90.26 207,90.26 207.64,89.62 209.43,89.62 210.31,90.5 210.31,91.37 210.76,91.82 210.76,94.12 208.08,96.8 206.9,97.44 203.28,97.44 199.19,100.31 198.3,101.2 193.71,104.57 190.84,107.45 187.53,107.45 184.12,110.86 177.95,110.86 176.27,110.05 171.57,110.05 170.84,110.77 168.08,110.77 166.08,112.77 143.43,112.77 143.28,112.62 140.55,112.62 138.98,111.05 136.33,110.58 133.94,110.58 133.21,111.31 129.37,111.31 128.8,111.88 128.26,111.88 127.47,111.09 126.02,111.09 125.74,110.81 123.07,110.81 121.77,109.51 120.53,109.51 119.89,108.88 118.95,108.88 117.89,107.82 116.34,107.82 113.88,105.35 113.88,103.56 113.39,103.08 113.39,102.52 112.3,101.43 111.06,101.43 109.92,100.28 109.44,100.28 108.86,99.71 v1(108.62,99.71)
  BOTTOM w0.102: v1(108.62,99.71) 108.82,99.51 U400.AF5
IN_D0#: length 130.3
  TOP w0.097: v2(208.07,88.33) 208.29,88.55 209.26,88.55 209.44,88.37 C3514.2
  IN2 w0.114: v1(108.63,99.07) 109.05,99.49 109.05,99.57 109.53,100.06 110.02,100.06 111.16,101.2 112.39,101.2 113.62,102.43 113.62,102.98 114.11,103.47 114.11,105.26 116.43,107.59 117.98,107.59 119.05,108.65 119.99,108.65 120.62,109.28 121.87,109.28 123.16,110.58 125.83,110.58 126.12,110.86 127.56,110.86 128.35,111.65 128.7,111.65 129.28,111.08 133.11,111.08 133.84,110.35 136.35,110.35 139.09,110.83 140.65,112.39 143.37,112.39 143.52,112.54 165.99,112.54 167.98,110.55 170.75,110.55 171.47,109.82 176.32,109.82 178,110.63 184.03,110.63 187.43,107.22 190.74,107.22 193.56,104.4 198.15,101.02 199.04,100.13 203.21,97.21 206.84,97.21 207.95,96.62 210.54,94.03 210.54,91.92 210.09,91.47 210.09,90.6 209.33,89.85 207.74,89.85 207.09,90.49 206.75,90.49 206.43,90.16 206.43,89.56 207.43,88.56 207.83,88.56 v2(208.07,88.33)
  BOTTOM w0.102: v1(108.63,99.07) 108.84,98.86 U400.AF6
IN_D1: length 120.1
  TOP w0.097: C3511.2 209.44,90.97 209.29,90.82 208.53,90.82 208.45,90.9 v2(208.45,91.13)
  IN2 w0.114: v2(208.45,91.13) 208.45,90.9 208.58,90.77 209.14,90.77 209.3,90.93 209.3,91.69 209.89,92.28 209.89,93.76 208.64,95 206.98,96.25 201.86,96.25 199.98,98.13 196.63,99.61 190.27,105.96 188.35,106.49 186.89,106.49 185.4,107.98 183.88,108.83 182.6,108.83 180.12,109.82 178.33,109.82 176.93,109.09 170.76,109.09 170.1,109.75 167.46,109.75 165.31,111.89 144.03,111.89 143.88,111.74 142.81,111.74 141.04,111.19 140.5,110.65 140.39,110.55 140.23,110.38 136.48,109.7 133.57,109.7 133.22,110.05 132.84,110.43 129.05,110.43 127.8,109.18 126.01,109.18 125.26,109.93 123.43,109.93 122.13,108.63 120.89,108.63 120.25,108 119.31,108 118.25,106.94 117.48,106.94 115.16,104.62 115.16,102.86 112.2,99.9 111.31,99.9 v1(110.47,99.06)
  BOTTOM w0.102: U400.AJ6 110.68,98.86 v1(110.47,99.06)
IN_D1#: length 120.1
  TOP w0.097: v2(208.45,90.36) 208.72,90.63 209.04,90.63 C3512.2
  IN2 w0.114: v2(208.45,90.36) 208.63,90.54 209.24,90.54 209.53,90.84 209.53,91.6 210.12,92.18 210.12,93.85 208.79,95.17 207.05,96.48 201.95,96.48 200.45,97.98 200.44,98 200.11,98.32 196.76,99.8 190.39,106.17 189.37,106.45 188.66,106.65 188.38,106.72 186.99,106.72 185.96,107.75 185.85,107.87 185.54,108.17 183.94,109.06 182.64,109.06 180.16,110.05 178.28,110.05 176.87,109.31 170.86,109.31 170.2,109.97 167.56,109.97 165.41,112.12 143.94,112.12 143.79,111.97 142.77,111.97 140.92,111.4 140.12,110.59 136.46,109.93 133.67,109.93 133.45,110.15 133.45,110.15 132.94,110.66 128.96,110.66 127.71,109.41 126.11,109.41 125.36,110.16 123.33,110.16 122.04,108.86 120.79,108.86 120.16,108.23 119.22,108.23 118.16,107.17 117.38,107.17 114.93,104.71 114.93,102.96 112.11,100.13 111.22,100.13 110.84,99.76 v1(110.5,99.76)
  BOTTOM w0.102: v1(110.5,99.76) 110.75,99.51 U400.AJ5
IN_D2: length 116.8
  TOP w0.097: v2(208.74,93.1) 208.74,92.89 208.97,92.66 209.3,92.66 209.54,92.9 C3509.2
  IN2 w0.114: v1(111.36,98.67) 111.55,98.86 112.1,98.86 112.34,99.1 113.43,99.1 116.12,101.79 116.12,104.44 117.8,106.11 118.36,106.11 118.85,105.62 119.78,105.62 120.89,106.74 121.15,106.74 123.7,109.28 125,109.28 125.81,108.47 128.01,108.47 129.32,109.78 132.57,109.78 133.31,109.05 137.24,109.05 141.54,109.69 141.82,109.69 143.22,111.1 144.15,111.1 144.3,111.25 164.59,111.25 166.83,109 169.6,109 170.28,108.32 177.36,108.32 178.7,108.68 179.7,108.68 180.78,107.6 183.81,107.6 184.2,107.21 184.2,107.01 186.12,105.08 189.3,105.08 196.64,97.74 200.83,95.93 201.56,95.2 203.34,95.2 204.5,94.04 208.6,94.04 209.22,93.42 209.22,92.88 209.13,92.79 208.87,92.79 208.74,92.92 v2(208.74,93.1)
  BOTTOM w0.079: 111.61,98.86 111.55,98.86 v1(111.36,98.67)
  BOTTOM w0.102: U400.AL6 111.61,98.86
IN_D2#: length 116.8
  TOP w0.097: C3510.2 209.34,92.46 208.87,92.46 v2(208.74,92.33)
  IN2 w0.114: v1(111.36,99.34) 111.61,99.09 112.01,99.09 112.25,99.33 113.34,99.33 115.9,101.89 115.9,104.53 117.71,106.34 118.45,106.34 118.94,105.85 119.68,105.85 120.79,106.96 121.06,106.96 123.6,109.51 125.09,109.51 125.9,108.7 127.91,108.7 129.23,110.01 132.67,110.01 132.8,109.88 133.4,109.28 137.22,109.28 141.53,109.92 141.72,109.92 143.13,111.32 144.06,111.32 144.21,111.47 164.68,111.47 166.93,109.23 169.7,109.23 170.38,108.55 177.33,108.55 178.67,108.91 179.8,108.91 180.88,107.83 183.9,107.83 184.43,107.3 184.43,107.1 186.22,105.31 189.39,105.31 196.77,97.94 200.96,96.12 201.65,95.43 203.43,95.43 204.6,94.26 208.69,94.26 209.44,93.51 209.44,92.79 209.22,92.56 208.97,92.56 v2(208.74,92.33)
  BOTTOM w0.079: 111.53,99.51 v1(111.36,99.34)
  BOTTOM w0.102: U400.AL5 111.53,99.51
INPUT3VSEL: length 17.3
  TOP w0.079: v1(135.77,86.52) 136.14,86.88 137.03,86.88 137.21,86.7 138.79,86.7
  TOP w0.102: 138.79,86.7 142.33,86.7 v2(142.42,86.61) 142.89,86.14 R651.1
  BOTTOM w0.079: U400.BT27 127.57,86 128.08,86 128.18,86.1 133.12,86.1 133.36,85.86 133.36,85.58 133.46,85.48 134.81,85.48 135.77,86.44 v1(135.77,86.52)
INT_BT_OFF#: length 14.2
  TOP w0.102: Q4102.3 164.86,84.99 165.05,85.17 165.05,85.78 165.56,86.29 Q4102.6 166.58,86.29 166.62,86.33 167.09,86.33 167.45,85.96 v2(167.87,85.96) 168.8,86.89 169.28,86.89 169.69,87.3 171,87.3 171.1,87.4 171.1,87.79 171.34,88.03 v2(171.34,88.71) 171.35,88.72 171.35,89.04 R4104.2
  BOTTOM w0.102: v2(171.34,88.71) 171.65,88.71 172.27,89.34 173.61,89.34 173.95,89.67 CN4100.54
INT_EDP_AUXN: length 102.2
  TOP w0.097: C3418.2 33.68,126.69 33.49,126.5 33.49,126.36 v2(33.82,126.03)
  IN2 w0.114: v2(105.01,116.04) 105.26,116.3 105.26,116.73 99.65,122.34 90.93,122.34 86.4,126.87 81.23,126.87 78.75,129.34 74.19,129.34 73.64,129.9 52.74,129.9 52.31,129.47 42.56,129.47 41.56,130.47 41.19,130.47 41.1,130.56 38.86,130.56 38.73,130.43 35.39,130.43 34.96,130 34.96,129.06 33.55,127.65 33.55,126.3 v2(33.82,126.03)
  BOTTOM w0.079: 110.51,107.38 110.51,107.36 110.52,107.34 110.52,107.09 110.66,106.95 110.66,104.94 111.14,104.46 111.14,103.99 111.03,103.88 111.03,102.99 110.44,102.39 110.44,102.31 110.41,102.29 110.41,101.82 110.07,101.48 110.07,100.86 U400.AH4
  BOTTOM w0.097: v2(105.01,116.04) 105.25,115.8 105.25,115.26 105.47,115.04 106.25,115.04 110.51,110.78 110.51,107.38
INT_EDP_AUXP: length 102.2
  TOP w0.097: v2(33.05,126.03) 33.29,126.27 33.29,126.58 33.29,126.59 33.19,126.69 C3419.2
  IN2 w0.114: v2(105.77,116.04) 105.48,116.33 105.48,116.82 99.74,122.56 91.02,122.56 86.49,127.1 81.32,127.1 78.85,129.57 74.29,129.57 73.73,130.13 52.64,130.13 52.21,129.7 42.65,129.7 41.66,130.7 41.29,130.7 41.19,130.79 38.76,130.79 38.63,130.66 35.29,130.66 34.73,130.1 34.73,129.16 33.32,127.75 33.32,126.3 v2(33.05,126.03)
  BOTTOM w0.079: 110.7,107.38 110.7,107.36 110.69,107.34 110.69,107.16 110.83,107.02 110.83,105.01 111.31,104.53 111.31,103.92 111.2,103.81 111.2,102.92 110.6,102.32 110.6,101.74 110.35,101.48 U400.AH3
  BOTTOM w0.097: 110.7,107.38 110.7,110.86 106.33,115.24 105.55,115.24 105.44,115.35 105.44,115.72 v2(105.77,116.04)
