# Allegro board dax8jmb16e0-e-www.DeviceDB.xyz_.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
KSO12: length 256.8
  TOP w0.102: v2(135.14,13.62) 135.9,13.62 137.35,12.16 143.32,12.16 146.03,9.45 151.16,9.45 151.32,9.3 151.32,8.61 v2(151.19,8.48) ; R6832.1 41.31,49.19 v2(40.64,49.19) ; U4701.C11 202.3,55.56 v3(202.63,55.23)
  IN1 w0.114: v2(86.16,28.17) 85.67,28.66 81.48,28.66 80.85,29.29 79.14,29.29 78.2,28.35 69.5,28.35 66.63,25.48 65.74,25.48 63.98,27.23 55.96,27.23 55.58,27.61 54.9,27.61 54.52,27.24 51.12,27.24 48.91,25.03 47.18,25.03 46.63,25.58 46.63,26.19 47.07,26.64 47.07,27.36 45.58,28.86 45.58,31.32 43.64,33.26 43.64,33.79 42.58,34.85 41.82,34.85 39.7,36.97 39.7,43.97 40.09,44.35 40.09,46.39 40.75,47.05 40.75,49.08 v2(40.64,49.19)
  IN2 w0.076: v3(202.63,55.23) 202.63,54.75 202.3,54.42 202.3,50.21 202.85,49.65 202.85,47.86 202.61,47.62 202.36,47.62 202.09,47.35 202.09,46.92 202.29,46.72 202.78,46.72 203.06,46.44
  IN2 w0.114: v2(151.19,8.48) 152.64,9.94 155.2,9.94 155.59,9.55 159.72,9.55 160.89,10.72 162.86,10.72 164.12,11.98 187.98,11.98 189.34,13.34 197.17,13.34 198.36,14.53 198.36,16.18 202.15,19.97 202.15,32.58 203.94,34.38 203.94,40.1 204.18,40.33 204.18,45.31 203.06,46.44
  BOTTOM w0.102: v2(86.16,28.17) 86.91,28.17 87.84,27.24 98.44,27.24 99.85,28.65 100.8,28.65 101.48,27.97 101.48,26.42 102.19,25.71 107.12,25.71 108.11,24.72 109.56,24.72 110.45,23.83 115.48,23.83 118.63,20.68 123.24,20.68 123.5,20.43 123.5,15.71 128.19,11.02 131.15,11.02 132.36,9.81 134.16,9.81 135.66,11.31 136.74,11.31 137.09,11.66 137.09,12.06 135.53,13.62 v2(135.14,13.62) ; CN5000.28 40.67,49.22 v2(40.64,49.19)
KSO13: length 168.7
  TOP w0.102: v2(53.2,51.34) 53.78,51.34 53.98,51.54 57.87,51.54 59.05,50.36 102.73,50.36 104.79,48.3 116.87,48.3 117.72,47.45 143.87,47.45 144.63,48.21 175.82,48.21 180.7,53.1 188.8,53.1 190.67,54.97 190.67,55.1 191.01,55.43 191.33,55.43 191.8,55.9 191.8,56.49 192.29,56.98 v2(193.84,56.98) ; U4701.D11 v3(203.28,55.23)
  IN2 w0.076: 198.06,57.26 198.29,57.03 199.89,57.03 201.17,55.75 203.04,55.75 203.28,55.51 v3(203.28,55.23)
  IN2 w0.114: v2(193.84,56.98) 196.08,56.98 196.65,57.54 197.77,57.54 198.06,57.26
  BOTTOM w0.102: v2(53.2,51.34) 51.8,51.34 51.33,50.87 51.33,50.56 50.69,49.92 45.3,49.92 45.21,50 44.21,50 43.92,49.72 CN5000.29
L_SPK+: length 169.5
  TOP w0.762: v4(160.54,127.44) L3600.2
  IN1 w0.762: 198.07,112.05 196.73,112.05 196.35,111.67 193.06,111.67 192.19,112.54 187.04,112.54 186.39,111.89 181.72,111.89 180.98,111.15 177.99,111.15 177.31,110.47 171.18,110.47 170.57,111.08 167.55,111.08 163.68,114.95 163.68,117.74 163.37,118.05 163.37,119.97 162.68,120.66 162.68,123.37 161.65,124.4 161.65,126.8 161.02,127.44 v4(160.54,127.44) ; 218.9,20.79 218.9,24.42 219.92,25.44 220.57,25.44 221.97,26.83 221.97,27.7 222.89,28.62 222.89,35.58 223.72,36.42 223.72,47.41 224.34,48.03 224.34,50.25 223.72,50.87 223.72,54.8 223.93,55.02 223.93,57.48 222.38,59.03 221.14,59.03 213.65,66.52 213.65,67.43 ; 202.62,112.05 203.78,112.05 204.6,112.87 206.61,112.87 207.04,112.44 207.62,112.44 208.19,111.88 208.19,107.8 207.68,107.29 207.68,106.35 208.12,105.91 208.68,105.91 210.68,103.92 210.68,102.28 211.29,101.67 211.29,98.46 208.98,96.16 208.98,94.68 206.66,92.36 206.66,87.95 207.04,87.57 207.04,86.8 207.73,86.11 207.73,83.63 209.42,81.94 209.42,81.18 211.79,78.82 211.79,76.19 212.55,75.43
  IN1 w1.524: 213.65,67.43 213.65,74.33 212.55,75.43 ; 198.07,112.05 202.62,112.05
  vias: v2(218.92,18.85) v2(218.95,19.49) v2(219.96,18.3)
L_SPK+_R: length 2.8
  TOP w0.762: v4(163.92,127.26) 163.34,127.26 163.17,127.44 L3600.1
  BOTTOM w0.762: CN3600.4 v4(163.92,127.26)
L_SPK-: length 167.8
  TOP w0.762: v4(160.61,126.41) 161.14,126.41 L3601.2
  IN1 w0.762: 217.85,20.44 217.85,24.8 219.5,26.45 220.15,26.45 220.95,27.25 220.95,28.12 221.87,29.04 221.87,36.14 222.7,36.97 222.7,47.83 223.33,48.45 223.33,49.83 222.7,50.45 222.7,55.21 222.92,55.43 222.92,57.06 221.96,58.02 220.72,58.02 211.87,66.87 211.87,67.56 ; 211.87,72.79 211.87,74.07 210.66,75.28 210.66,78.29 208.41,80.54 208.41,81.51 206.71,83.21 206.71,85.6 206.03,86.29 206.03,87.15 205.65,87.53 205.65,92.78 207.96,95.1 207.96,96.62 210.27,98.93 210.27,101.25 209.66,101.86 209.66,103.5 208.26,104.89 207.54,104.89 206.66,105.78 206.66,111.37 206.18,111.85 205.02,111.85 203.44,110.27 ; v4(160.61,126.41) 160.61,124 161.66,122.95 161.66,120.24 162.35,119.55 162.35,117.63 162.66,117.32 162.66,114.53 167.13,110.06 170.15,110.06 170.76,109.46 177.73,109.46 178.41,110.14 181.4,110.14 182.13,110.86 186.8,110.86 187.46,111.52 191.77,111.52 192.64,110.65 196.58,110.65 196.96,110.27 197.95,110.27
  IN1 w1.524: 211.87,72.79 211.87,67.56 ; 197.95,110.27 203.44,110.27
  vias: v2(218.02,19.33) v2(218.02,18.67) v2(218.58,18.3)
L_SPK-_R: length 2.8
  TOP w0.762: v4(163.99,126.01) 163.85,125.87 C3636.2 162.88,125.87 L3601.1
  BOTTOM w0.762: CN3600.3 v4(163.99,126.01)
LAD0: length 69
  TOP w0.102: R436.1 162.92,71.79 163.41,71.3 163.41,71 163.68,70.72 164.49,69.91 v2(165.16,69.91)
  TOP w0.112: U4701.H1 205.56,49.05 206.19,48.42 v2(206.19,47.85)
  BOTTOM w0.102: CN7701.2 165.03,71.94 165.03,71.94 165.03,70.04 v2(165.16,69.91) 165.03,69.79 165.03,68.36 167.62,65.76 167.62,64.62 171.38,60.87 172.25,60.87 173.96,59.16 173.96,58 177.13,54.84 178.99,54.84 179.99,55.83 182.61,55.83 184.14,54.31 188.46,54.31 189.24,55.08 190.21,55.08 190.37,55.24 190.37,56.25 191.23,57.12 193.12,57.12 193.98,56.25 195.1,56.25 195.66,55.7 195.66,51.27 198.67,48.26 198.67,47.3 199.7,46.27 201.52,46.27 201.89,46.64 203.08,46.64 203.38,46.35 205.04,46.35 206.19,47.49 v2(206.19,47.85)
LAD0_L: length 41.7
  TOP w0.102: v2(163.38,73.8) 163.38,73.32 R436.2
  IN2 w0.079: v1(131.48,84.33) 131.48,84.23 131.84,83.87 131.84,83.21 131.94,83.11 131.94,82.61 132.06,82.48 132.44,82.48 133.33,81.59 133.99,81.59 135.24,80.35 135.47,80.35 136.46,79.35 136.46,78.57
  IN2 w0.127: 136.46,78.57 139.18,75.85 142.09,75.85 145,72.94 148.93,72.94 149.54,73.55 150.52,73.55 151.65,72.43 160.9,72.43 161.19,72.14 162.85,72.14 163.38,72.67 v2(163.38,73.8)
  BOTTOM w0.079: v1(131.48,84.33) 131.29,84.52 U400.CA29
LAD1: length 71.8
  TOP w0.102: v2(162.06,71.61) 161.94,71.73 R437.1
  TOP w0.114: v2(209.22,46.49) 209.13,46.49 207.81,47.81 206.99,47.81 206.66,48.14 206.66,48.48 206.21,48.93 U4701.J1
  BOTTOM w0.102: v2(209.22,46.49) 208.93,46.77 208.6,46.77 207.24,45.42 207.24,44.63 v2(206.68,44.07) 206.22,43.62 202.75,43.62 201.86,44.51 201.26,44.51 200.82,44.95 199.15,44.95 197.35,46.75 197.35,47.55 196.86,48.04 196.12,48.04 195.36,48.79 195.36,49.64 194.97,50.03 190.4,50.03 188.45,51.98 185.62,51.98 184.83,52.76 178.29,52.76 177.54,53.52 174.21,53.52 169.79,57.93 169.79,58.45 162.94,65.3 162.94,68.81 161.66,70.1 161.66,70.44 162.06,70.84 v2(162.06,71.61) 162.21,71.61 162.54,71.94 CN7701.7
LAD1_L: length 40.8
  TOP w0.102: R437.2 161.16,71.25 v2(161.15,71.23)
  IN2 w0.079: v1(130.59,84.33) 130.95,83.98 130.95,83.04 130.95,83.04 130.95,82.65 131.24,82.35 131.25,82.35 131.45,82.14 131.45,81.82 132.42,80.85 134.05,80.85 135.15,79.75 135.15,79.15 136.32,77.98
  IN2 w0.127: 136.32,77.98 136.32,77.87 138.94,75.25 141.83,75.25 144.75,72.34 149.18,72.34 149.79,72.95 150.28,72.95 151.4,71.83 156.42,71.83 156.55,71.7 156.55,71.35 156.68,71.23 156.93,71.23 157.06,71.35 157.06,71.7 157.19,71.83 159.1,71.83 160.18,70.74 160.66,70.74 v2(161.15,71.23)
  BOTTOM w0.079: v1(130.59,84.33) 130.4,84.52 U400.BY29
LAD2: length 69.4
  TOP w0.079: v2(207.22,48.37) 207.22,48.66 206.86,49.02 U4701.K1
  TOP w0.102: R439.1 165.46,70.59 v2(165.46,70.47)
  BOTTOM w0.102: CN7701.1 165.54,71.73 165.46,71.66 v2(165.46,70.47) 165.64,70.29 165.64,69.62 165.3,69.27 165.3,68.47 165.75,68.03 166.43,68.03 166.99,68.59 167.62,68.59 167.83,68.38 167.83,67.63 168.83,66.63 168.83,64.6 169.47,63.96 169.47,63.4 171.61,61.25 172.25,61.25 177.01,56.49 177.01,55.71 177.59,55.13 178.4,55.13 179.74,56.47 183.03,56.47 184.92,54.58 185.49,54.58 185.51,54.6 187.91,54.6 190.07,56.75 190.49,56.75 191.12,57.38 194,57.38 194.87,56.52 195.26,56.52 195.93,55.84 195.93,52.65 196.96,51.63 196.96,50.34 198.93,48.37 198.93,47.41 199.81,46.54 201.29,46.54 202.29,47.54 204.81,47.54 205.07,47.27 205.59,47.27 205.78,47.46 205.78,48.2 205.95,48.37 v2(207.22,48.37)
LAD2_L: length 45.9
  TOP w0.102: v2(164.09,71.13) 163.43,71.79 163.43,72.33 R439.2
  IN2 w0.079: v1(129.65,85.53) 130.03,85.15 130.03,84.49 130.17,84.34 130.17,82.72 130.67,82.23 130.67,81.92 130.97,81.62 131.4,81.62 132.34,80.68 133.98,80.68 134.84,79.82 134.84,79 135.85,77.98
  IN2 w0.127: v2(164.09,71.13) 163.7,70.74 161.6,70.74 161.22,70.36 159.24,70.36 158.74,70.87 156.31,70.87 155.68,71.5 150.98,71.5 150.47,72.01 144.61,72.01 141.7,74.92 138.8,74.92 135.85,77.87 135.85,77.98
  BOTTOM w0.079: U400.BY27 129.94,85.82 v1(129.65,85.53)
LAD3: length 68.6
  TOP w0.102: v2(162.1,70.31) 162.15,70.36 R441.1
  TOP w0.112: U4701.L1 207.51,48.93 208.93,47.5 209.13,47.5 v2(209.15,47.53)
  BOTTOM w0.102: CN7701.6 163.03,72 162.85,71.81 162.85,71.56 162.54,71.25 162.54,70.75 v2(162.1,70.31) 162.1,70.05 163.23,68.92 163.23,65.39 170.06,58.56 170.06,58.04 174.32,53.78 177.89,53.78 178.63,53.04 184.93,53.04 185.73,52.24 188.56,52.24 190.49,50.32 195.06,50.32 197.61,47.76 197.61,46.86 199.26,45.22 200.93,45.22 201.18,44.96 203.06,44.96 204.04,43.99 205.73,43.99 206.66,44.92 206.66,45.41 208.77,47.53 v2(209.15,47.53)
LAD3_L: length 44.3
  TOP w0.102: v2(162.73,70.14) 162.73,70.8 R441.2
  IN2 w0.079: 135.38,77.98 134.43,78.94 134.43,79.98 133.96,80.45 132.32,80.45 131.33,81.44 130.9,81.44 130.28,82.06 130.28,82.35 130.01,82.63 130.01,84.21 129.78,84.43 129.2,84.43 129.12,84.51 129.12,85.13 v1(128.74,85.51)
  IN2 w0.127: 135.38,77.98 135.38,77.87 138.66,74.59 141.55,74.59 144.46,71.68 150.33,71.68 150.84,71.17 155.55,71.17 156.18,70.54 158.6,70.54 159.27,69.87 162.47,69.87 v2(162.73,70.14)
  BOTTOM w0.079: U400.BV27 129.05,85.82 v1(128.74,85.51)
LAN_AMBLED: length 17.6
  TOP w0.102: C4014.2 228.22,97.46 v2(228.8,96.87) 228.8,96.14 v2(228.53,95.86) 228.71,95.69 228.71,92.51 228.34,92.14 R4008.2
  BOTTOM w0.102: v2(228.8,96.87) 228.92,96.76 228.92,92.35 228.28,91.71 228.28,89.13 230.77,86.64 CN4000.11
LAN_AMBLED#: length 63
  TOP w0.102: v2(207.04,74.99) 206.75,74.71 205.78,74.71 204.81,73.74 203.46,73.74 202.8,73.08 202.8,65.71 202.34,65.24 201.94,65.24 200.39,63.7 200.39,62.91 200.21,62.72 197.9,62.72 v2(197.7,62.92) ; v2(193.15,62.92) 193.76,63.53 TP4002.1 194.28,63.72 194.28,64.45 194.33,64.49 U4000.27
  IN1 w0.114: v2(229.57,80.55) 228.58,81.54 225.66,81.54 v2(224.19,80.07)
  IN2 w0.114: v2(197.7,62.92) 197.28,63.33 193.56,63.33 v2(193.15,62.92)
  BOTTOM w0.102: v2(224.19,80.07) 221.09,76.97 211.13,76.97 210.79,76.62 210.79,76.48 209.12,74.81 207.22,74.81 v2(207.04,74.99) ; CN4000.12 232.27,84.41 230.44,82.58 228.14,82.58 C4037.1 229.36,80.55 v2(229.57,80.55)
LAN_DIS#: length 11
  TOP w0.079: v1(129.9,82.11) 129.9,81.52 128.79,80.4
  TOP w0.102: 128.79,80.4 128.79,78.28 130.82,76.25 130.82,74.45 TP426.1
  BOTTOM w0.079: U400.BU34 129.29,81.52 129.38,81.61 129.5,81.74 129.57,81.8 129.6,81.8 v1(129.9,82.11)
LAN_MCTG0: length 4.4
  BOTTOM w0.102: v2(224.25,75.6) R4017.1 222.97,75.17 222.97,74.48 222.72,74.22 221.96,74.22 221.9,74.17 U4001.15
LAN_MCTG1: length 3.3
  BOTTOM w0.102: U4001.18 222.94,71.17 v2(222.99,71.12) 222.99,70.29 R4016.1
LAN_MCTG2: length 3.4
  BOTTOM w0.102: v2(223.35,67.34) 223.35,68.14 R4015.1 222.84,68.26 222.76,68.17 U4001.21
LAN_MCTG3: length 2.4
  BOTTOM w0.102: U4001.24 222.4,65.17 222.49,65.08 R4014.1
LAN_PWR_ON: length 116.4
  TOP w0.076: U4701.L7 207.81,53.27 208.22,53.27 208.32,53.37 212.11,53.37 212.4,53.07 212.92,53.07
  TOP w0.102: v2(166.22,20.77) 166.28,20.71 172.62,20.71 173.3,20.02 v2(173.9,20.02) ; v2(165.91,27.95) 166,28.04 PR9507.2 ; v2(217.6,48.25) 218.14,48.8 218.14,53.29 217.86,53.57 217.08,53.57 216.58,53.07 212.92,53.07
  IN1 w0.114: v2(218.12,44) 217.69,43.57 217.69,37.64 219.57,35.76 219.57,30.62 218.89,29.94 218.89,29.74 217.94,28.79 217.94,28.45 213.88,24.39 211.29,24.39 209.55,22.66 208.64,22.66 208.14,22.15 208.14,21.27 206.03,19.16 204.53,19.16 201.79,16.42 201.79,14.28 197.3,9.79 192.52,9.79 v2(192.01,10.3)
  BOTTOM w0.102: v2(217.6,48.25) 217.6,47.4 217.06,46.86 215.63,46.86 215.25,46.48 215.25,45.06 216.31,44 v2(218.12,44) ; v2(173.9,20.02) 173.9,19.62 174.84,18.68 177.29,18.68 177.91,18.06 182.59,18.06 189.29,11.36 191.33,11.36 192.01,10.68 v2(192.01,10.3) ; v2(165.91,27.95) 165.91,26.28 166.43,25.76 166.43,20.99 v2(166.22,20.77)
LAN_WLED: length 12.2
  TOP w0.102: v2(227.01,94.24) v2(227.68,94.24) 227.68,93.89 227.44,93.66 226.42,93.66 226.31,93.54 C4013.2 R4007.2
  IN2 w0.114: v2(227.01,94.24) 227.01,96.12 228.48,97.59 228.85,97.59 230.77,99.52 230.77,99.52 CN4000.9
LAN_WLED#: length 106.4
  TOP w0.102: U4000.26 193.93,64.37 193.01,63.45 192.45,63.45 192.39,63.39 191.83,63.39 191.83,63.39 TP4001.1 190.66,63.85 188.04,63.85 187.38,63.19 187.38,60.22 188.45,59.15 191.88,59.15 192.92,60.19 193.13,60.19 194.51,61.57 196.03,61.57 196.65,60.95 196.85,60.95 197.22,60.57 Q4000.4 197.89,60.57 197.98,60.66 197.98,60.81 197.44,61.34 196.81,61.34 196.5,61.66 196.5,62 196.96,62.46 200.24,62.46 200.6,62.82 200.6,63.61 201.96,64.98 202.36,64.98 203.01,65.62 203.01,72.9 203.64,73.53 205,73.53 205.97,74.5 207.15,74.5 207.6,74.96 v2(207.6,75.25)
  IN1 w0.114: v2(229.88,84.94) 230.34,84.94 231.02,84.26 231.02,82.66 230.13,81.77 225.27,81.77 v2(224.2,80.69)
  BOTTOM w0.102: v2(224.2,80.69) 220.67,77.17 210.95,77.17 210.58,76.79 210.58,76.56 209.07,75.05 207.81,75.05 v2(207.6,75.25) ; CN4000.10 230.82,102.23 230.82,105.08 C4036.1 230.01,103.21 227.95,101.15 227.95,96.09 228.71,95.33 228.71,92.44 228.07,91.8 228.07,89.05 229.78,87.34 229.78,85.04 v2(229.88,84.94)
LANLINK_STATUS: length 104.7
  TOP w0.102: Q4000.1 198.47,59.27 198.13,58.94 196.58,58.94 196.21,59.31 196.21,61.11 195.95,61.37 194.59,61.37 193.21,59.99 193.01,59.99 191.96,58.94 188.33,58.94 187.05,60.22 187.05,63.17 187.49,63.6 v2(187.49,63.9) ; v1(134.54,89.6) 134.97,89.17 135.21,89.17 135.49,88.89 137.43,88.89 137.65,88.67 140.02,88.67 140.39,88.29 142.27,88.29 143.01,89.03 146.08,89.03 147.22,87.89 150.38,87.89 150.62,88.13 151.81,88.13 152.39,87.55 154.24,87.55 R423.1 154.44,88.02 154.6,88.18 156.1,88.18 158.08,90.16 158.88,90.16 159.26,89.79 159.49,89.79 159.83,89.45 162.04,89.45 v2(162.49,89)
  IN1 w0.114: v2(187.49,63.9) 187.49,64.39 185.67,66.21 185.67,70.41 186.26,71 186.26,86.88 186,87.14 v2(186,89.55)
  IN2 w0.114: v2(186,89.55) 185.5,90.05 182.81,90.05 180.19,92.67 178.66,92.67 177.01,91.01 174.44,91.01 173.76,90.33 169.62,90.33 169.37,90.09 164.31,90.09 163.22,89 v2(162.49,89)
  BOTTOM w0.079: U400.CG20 134.54,89.74 v1(134.54,89.6)
LANRSET: length 1.7
  TOP w0.102: R4000.2 196.32,64.11 195.93,64.51 U4000.31
LED#: length 14.6
  TOP w0.102: CN7600.19 8.4,105.34 v2(8.62,105.56) 9.14,106.08 10.23,106.08 C7602.1 11.34,105.62 11.82,105.14 12.2,105.14 12.79,104.55 13.73,104.55 14.03,104.25 14.03,103.81 14.36,103.47 14.96,103.47 15.83,104.35 15.83,105.38 R7619.2 15.26,105.71 15.05,105.49 15.05,105.03 14.79,104.78 14.54,104.78 14.37,104.94 Q7600.6
LED_3S_SATA#: length 357.3
  TOP w0.102: D4300.2 205.9,10.32 204.08,12.14 v2(204.08,12.25)
  IN2 w0.114: v2(59.44,33.76) 59.75,33.46 61.11,33.46 61.77,32.8 65.74,32.8 66.73,33.79 67.37,33.79 69.51,35.93 84.62,35.93 85.48,36.79 107.32,36.79 107.89,36.23 115.07,36.23 116.14,35.15 119.47,35.15 121.93,32.7 126.11,32.7 127.76,31.04 129.24,31.04 129.8,30.48 129.8,30.22 132.02,27.99 133.43,27.99 134.05,27.37 134.05,25.04 135.11,23.98 135.23,23.98 136.87,22.35 138.36,22.35 139.03,21.68 140.57,21.68 143.69,18.57 148.81,18.57 149.36,18.02 156.6,18.02 156.93,18.35 168.41,18.35 168.94,18.88 176.86,18.88 177.06,18.68 181.55,18.68 182.26,19.39 182.49,19.39 v2(182.75,19.65) 182.23,20.17 182.23,20.8 184,22.58 185.08,22.58 185.73,23.23 185.73,23.64 186.65,24.56 186.65,25 184.38,27.28 184.38,35.6 184.67,35.9 187.42,35.9 187.63,35.69 187.63,35.2 188.31,34.52 189.32,34.52 189.41,34.42 193.4,34.42 193.53,34.56 194.18,35.2 194.18,38.22 195.08,39.12 195.08,40.01 195.5,40.44 195.5,42.14 193.75,43.89 193.75,44.66 192.18,46.22 192.18,50.8 191.97,51.02 191.97,54.73 190.47,56.22 189.07,56.22 188.98,56.13 185.03,56.13 182.84,58.32 182.84,62.41 181.09,64.16 181.09,68.53 179.79,69.82 179.79,70.33 179.2,70.92 177.84,70.92 177.33,70.41 175.37,70.41 174.61,71.18 174.61,71.63 174.18,72.07 173.34,72.07 171.56,73.84 168.05,73.84 166.85,75.05 165.9,75.05 165.18,75.77 158.97,75.77 158.57,75.37 154.65,75.37 154.55,75.47 153.44,75.47 v2(152.99,75.92)
  BOTTOM w0.079: 144.81,96.38 144.75,96.44 143.11,96.44 142.24,97.31 142.24,97.7 141.64,98.3 141.3,98.3 141.15,98.44 140.46,98.44 140.32,98.58 138.77,98.58 138.69,98.66 138.59,98.7 138.58,98.71 138.31,98.71 138.22,98.67 U400.CN7
  BOTTOM w0.102: 144.81,96.38 R568.2 145.11,95.87 145.4,95.58 149.55,95.58 149.69,95.44 151.66,95.44 151.71,95.49 152.05,95.49 153.27,94.27 154.15,94.27 154.68,93.74 155.83,93.74 156.45,93.12 156.45,92.53 156.95,92.02 156.95,90.99 156.07,90.1 156.07,87.81 154.66,86.41 154.66,85.43 151.96,82.73 151.96,76.93 152.97,75.92 v2(152.99,75.92) ; v2(204.08,12.25) 203.75,12.58 202.4,12.58 201.34,11.52 197.96,11.52 197.38,12.1 194.2,12.1 192.4,13.9 187.9,13.9 184.26,17.54 184.26,19.17 183.98,19.45 182.95,19.45 v2(182.75,19.65) ; CN7601.21 34.74,24.97 33.69,23.92 C7628.1 30.21,23.3 30.64,22.87 45.45,22.87 47.66,25.08 50.02,25.08 50.4,25.46 55.3,25.46 56.65,26.8 56.65,30.41 57.16,30.92 57.16,32.54 57.64,33.03 59.37,33.03 59.44,33.1 v2(59.44,33.76)
LED_PWRSTBY#: length 215.5
  TOP w0.102: R4738.2 182.52,59.47 182.39,59.6 U4700.6 181.02,59.6 180.57,59.16 R4734.1 180.57,58.7 180.37,58.51 179.06,58.51 169.78,49.23 144.2,49.23 143.45,48.47 118.14,48.47 117.29,49.32 105.21,49.32 103.15,51.38 59.73,51.38 58.11,53 57.44,53 57.2,52.76 53.6,52.76 53.08,52.24 v2(53,52.24) ; v2(34.27,76.41) 32.98,76.41 30.01,79.38 30.01,81.95 18.12,93.84 18.12,102.08 16.62,103.58 16.62,106.02 16.15,106.49 R7619.1 15.34,106.33 13.78,106.33 13.72,106.28 Q7600.5
  BOTTOM w0.102: v2(34.27,76.41) 39.18,71.51 39.18,66.01 39.4,65.78 39.4,60.76 40.54,59.63 42.39,59.63 45.5,56.52 47.16,56.52 47.84,57.21 49.39,57.21 50.79,55.8 50.79,54.28 52.83,52.24 v2(53,52.24)
LFRAME#: length 109.5
  TOP w0.112: v2(209.14,48.21) 209.14,48.22 208.49,48.22 207.83,48.87 207.83,49.21 207.51,49.53 U4701.L2
  IN2 w0.079: 135.51,80.61 135.44,80.61 134.96,81.09 134.96,81.51 135.16,81.71 135.16,82.15 134.83,82.48 134.58,82.48 134.4,82.66 133.64,82.66 133.46,82.48 132.95,82.48 132.82,82.61 132.82,82.94 132,83.77 132,83.94 131.84,84.11 131.84,84.48 131.67,84.65 131.67,84.75 v1(131.48,84.94)
  IN2 w0.127: 135.51,80.61 136.65,79.47 136.65,78.85 139.32,76.18 142.23,76.18 145.14,73.27 148.79,73.27 149.97,74.44 149.97,74.91 150.1,75.04 150.33,75.04 150.45,74.91 150.45,74.09 151.73,72.81 162.22,72.81 162.76,73.35 v2(162.76,73.68)
  BOTTOM w0.079: U400.CA28 131.25,85.17 v1(131.48,84.94)
  BOTTOM w0.102: v2(162.76,73.68) 163.05,73.39 163.43,73.39 163.54,73.28 CN7701.5 163.54,71.89 163.69,71.73 163.69,70.96 164.24,70.4 164.24,68.04 165.77,66.51 165.77,65.09 172.28,58.58 172.28,58.58 176.81,54.05 177.41,54.05 181.85,54.05 182.38,53.52 184.82,53.52 185.84,52.51 188.15,52.51 188.17,52.53 188.53,52.89 190,52.89 191.34,51.55 191.34,50.77 191.49,50.61 195.14,50.61 195.85,49.9 197.35,48.41 197.88,47.87 197.88,46.97 199.37,45.48 201.04,45.48 201.29,45.23 203.48,45.23 v2(204.02,44.69) 204.45,44.26 205.63,44.26 206.39,45.03 206.39,45.52 209.08,48.21 v2(209.14,48.21)
LID_OFF_CN: length 15.2
  TOP w0.102: R3424.1 C3424.2 ; C3424.2 17.35,115.88 Q3401.2 ; C3424.2 18.15,117.02 20.18,117.02 22.08,118.93 22.08,123.5 22.33,123.75 22.84,123.75 22.97,123.63 Q3400.3
LID_SW#_3: length 355.7
  TOP w0.102: v2(48.52,58.83) 48.29,58.6 R7510.1 47.87,59.32 Q7501.1 ; v2(24.45,131.34) 24.45,131.01 24.55,130.9 24.55,130.59 EC3400.2 25.09,130.05 25.6,130.05 25.89,129.76 25.89,127.38 26.01,127.25 26.01,127.14 26.77,126.38 26.77,125.62 26.53,125.39 26.27,125.39 25.93,125.05 R3400.2 25.36,125.05 25.23,125.18 v2(24.89,125.18) 23.89,125.18 v2(23.22,124.52) ; R4742.1 207.14,46.98 206.88,47.24 205.69,47.24 205.3,47.63 v2(205.3,47.7) ; v3(205.88,51.33) 205.56,51.01 U4701.H4 ; R7616.1 11.67,106.36 v2(11.77,106.25)
  IN1 w0.114: v2(43.98,58.83) 43.98,55.1 43.54,54.67 43.54,50.48 44.04,49.98 44.04,47.26 43.62,46.84 43.62,44.89 44.18,44.33 44.18,38.96 48.6,34.54 48.6,32.08 50.32,30.36 51.5,30.36 52.25,31.12 54.58,31.12 55.13,30.57 58.36,30.57 v2(58.68,30.89) 59.09,30.48 60.49,30.48 61.56,31.55 66.49,31.55 67.02,32.08 82.38,32.08 82.78,31.69 87.27,31.69 87.89,32.31 101.29,32.31 101.93,32.94 103.1,32.94 103.34,32.7 113.32,32.7 113.78,32.24 118.94,32.24 120.65,30.53 127.18,30.53 128.09,29.61 128.8,29.61 129.12,29.29 129.81,29.29 131.27,27.83 131.27,22.55 132.22,21.6 133.82,21.6 136.92,18.5 136.92,17.52 138.77,15.68 142.51,15.68 143.54,14.65 153.37,14.65 154.93,13.09 162.5,13.09 163.81,14.4 186.8,14.4 188.71,12.49 189.8,12.49 v2(190.23,12.07) ; v2(23.22,124.52) 23.22,123.63 25.06,121.79 25.06,119.55 20.76,115.25 19.42,115.25 18.56,114.39 18.56,110.89 14.1,106.43 12.15,106.43 11.97,106.25 v2(11.77,106.25) 11.67,106.15 11.67,105.62 12,105.29 14.23,105.29 15.14,104.37 15.14,103.74 15.7,103.18 15.7,102.02 36.69,81.03 36.69,75.57 v2(37.07,75.19)
  IN2 w0.114: v2(190.23,12.07) 190.75,11.54 192.96,11.54 193.39,11.97 198.99,11.97 200.76,13.73 201.19,13.73 202.46,15.01 202.46,18.18 203.54,19.26 203.54,32.03 205.32,33.82 205.32,39.52 206.75,40.95 206.75,45.92 206.14,46.53 206.14,46.86 v2(205.3,47.7)
  BOTTOM w0.076: v3(205.88,51.33) 206.05,51.16 206.05,51.1 206.2,50.95 206.2,49.83 204.91,48.55 204.91,48.44
  BOTTOM w0.102: CN3400.38 24.65,131.76 24.45,131.55 v2(24.45,131.34) ; v2(37.07,75.19) 37.07,74.25 39.38,71.94 39.38,66.1 39.61,65.87 39.61,60.85 40.62,59.83 42.98,59.83 v2(43.98,58.83) 43.98,58.83 v2(48.52,58.83) ; D6200.1 57.87,30.61 58.02,30.46 58.25,30.46 v2(58.68,30.89) ; 204.91,48.44 204.91,48.09 v2(205.3,47.7)
LID_SW#_3_Q: length 9.2
  TOP w0.102: R7504.2 48.6,58.25 48.32,57.97 47.73,57.97 R7510.2 47.09,59.32 Q7501.6 46.2,59.73 46.03,59.56 46.03,59.19 v2(46.22,59) 46.22,58.69 46.1,58.57 44.46,58.57 44.41,58.63 44.41,59.19 44.23,59.37 Q7502.2
LID_SW#_R: length 5.6
  TOP w0.102: R7616.2 11.19,107.68 11.18,107.68 C7603.2 10.28,108.08 9.66,108.08 9.1,107.52 v2(9.1,107.32) 9.1,107.11 8.37,106.38 7.78,106.38 7.74,106.34 CN7600.17
LIMIT_SIGNAL: length 195.8
  TOP w0.102: v2(199.65,97.8) 199.65,98 200.15,98.5 200.37,98.5 201.32,99.45 203.34,99.45 204.03,100.14 204.03,101.36 204.48,101.81 206.61,101.81 208.1,103.31 210.18,103.31 214.31,107.43 214.31,109.02 v2(214.49,109.21) ; PR8503.2 159.51,8.95 v2(161.6,8.95) ; v2(224.49,110.39) 224.49,110.2 EC9700.1
  IN1 w0.114: v2(161.6,8.95) 166.34,8.95 166.82,8.46 173.08,8.46 175.61,10.99 184.47,10.99 188.17,7.3 195.71,7.3 196.83,8.41 197.8,8.41 199.5,10.11 199.5,10.32 203.82,14.64 203.82,17.12 204.92,18.22 206.65,18.22 208.8,20.37 209.99,20.37 210.59,20.97 213.95,20.97 216.06,23.08 216.06,24.65 219.31,27.9 219.31,28.22 220.17,29.08 220.4,29.08 220.92,29.6 220.92,36.77 220.11,37.59 220.11,38.9 220.62,39.41 220.62,56.66 215.25,62.03 211.64,62.03 211.31,62.36 211.31,63.16 211.04,63.43 209.85,63.43 209.23,64.05 209.23,67.42 208.64,68 208.64,71.05 206.99,72.7 205.85,72.7 205.21,73.34 205.21,76.51 205.47,76.76 205.47,78.85 204.85,79.47 204.85,79.85 203.74,80.95 203.74,84.24 202.34,85.64 202.34,89.16 201.79,89.72 201.79,90.1 203.18,91.5 203.18,94.16 199.65,97.69 v2(199.65,97.8) ; v2(224.49,110.39) 224.49,110.11 223.7,109.32 214.61,109.32 v2(214.49,109.21)
  BOTTOM w0.102: PCN8000.6 222.9,108.89 223.34,109.34 223.64,109.34 224.49,110.19 v2(224.49,110.39)
LPC_ESPI_CLK: length 121
  TOP w0.102: R4702.1 215.4,49.53 215.4,48.6 214.54,47.74 210.2,47.74 v2(209.77,48.16) 209.33,48.6 208.61,48.6 U4701.M1 ; R7712.1 161.22,65.49 161.07,65.64 v2(160.61,65.64) 160.31,65.34 155.38,65.34 v2(155.25,65.21) 155.1,65.05 147.21,65.05 146.54,64.39 134.28,64.39 129.97,68.7 129.97,69.99 129.84,70.12 129.84,71.75 129.79,71.79 C402.1 129.42,71.82 R442.2
  BOTTOM w0.102: CN7701.8 162.03,72.17 161.58,71.71 161.58,70.75 160.61,69.79 v2(160.61,65.64) 162.35,63.91 163.55,63.91 169.23,58.22 169.23,57.7 173.97,52.96 175.38,52.96 176.34,52 178.16,52 178.58,52.42 184.78,52.42 185.5,51.7 188.34,51.7 190.3,49.73 194.87,49.73 195.08,49.52 195.08,48.62 195.94,47.76 196.74,47.76 197.07,47.43 197.07,46.64 199.03,44.67 200.7,44.67 201.19,44.18 201.78,44.18 202.65,43.31 207.88,43.31 210.19,45.63 210.19,47.74 v2(209.77,48.16)
LPC_ESPI_RESET#: length 117.3
  TOP w0.102: R446.1 161.18,70.55 v2(160.48,71.25) ; U4701.K3 207.18,50.04 207.66,50.04 207.83,49.87 207.83,49.54 207.98,49.38 208.26,49.38 208.86,48.78 209.73,48.78 v2(209.75,48.8)
  IN2 w0.079: v1(130.59,85.53) 131.12,84.99 131.12,83.49 131.18,83.43 131.18,82.72 131.68,82.23 131.68,81.84 131.91,81.62 132.98,81.62 133.21,81.4 133.88,81.4 135.85,79.43 136.06,79.43 136.27,79.22 136.27,78.34
  IN2 w0.114: v2(160.48,71.25) 159.6,72.13 151.52,72.13 150.4,73.25 149.67,73.25 149.05,72.64 144.87,72.64 141.96,75.55 139.06,75.55 136.27,78.34
  BOTTOM w0.102: v1(130.59,85.53) 130.88,85.82 U400.CA27 ; CN7701.9 161.53,72.19 160.86,71.52 160.74,71.52 v2(160.48,71.25) 160.28,71.05 160.28,69.49 159.91,69.13 159.91,65.45 161.74,63.62 163.43,63.62 168.94,58.1 168.94,57.58 173.86,52.67 175.05,52.67 176.56,51.16 188.47,51.16 190.19,49.44 193.85,49.44 195.83,47.47 196.62,47.47 196.78,47.32 196.78,46.52 198.91,44.39 200.42,44.39 201.77,43.03 207.99,43.03 210.93,45.97 210.93,47.62 v2(209.75,48.8)
M_A_A0: length 58.5
  IN1 w0.165: v2(84.81,38.93) 84.98,38.76 85.21,38.76 85.33,38.88 85.33,39.45 85.51,39.63 85.8,39.63 85.96,39.46 85.96,38.56 86.11,38.41 86.34,38.41 86.52,38.59 86.52,39.76 86.01,40.26 86.01,40.42 85.82,40.61 85.82,41.07 85.98,41.23 85.98,41.46 85.81,41.64 85.48,41.64 85.33,41.79 84.27,41.79 84.1,41.95 84.1,42.45 84.56,42.92 84.56,43.44 84.84,43.72 84.84,46.25 92.48,53.89 92.48,54.18 103.58,65.27 103.58,69.92 105.37,71.71 105.37,75.67 105.77,76.08 105.98,76.08 v1(106.18,75.88)
  BOTTOM w0.079: U400.AC37 107.03,79.42 106.94,79.33 106.94,77.71 106.61,77.37 106.61,76.23 106.26,75.88 v1(106.18,75.88)
  BOTTOM w0.127: v2(84.81,38.93) 84.85,38.89 JDIM2800.144
M_A_A1: length 59.8
  IN1 w0.165: v1(106.16,74.71) 105.88,74.71 105.72,74.55 105.72,71.46 104,69.73 104,65.1 97.93,59.03 97.93,58.56 98.31,58.17 98.31,57.9 98.12,57.71 97.85,57.71 97.36,58.19 97.09,58.19 96.9,58 96.9,57.72 97.38,57.24 97.38,56.96 97.19,56.77 96.91,56.77 96.43,57.26 96.15,57.26 95.96,57.06 95.96,56.79 96.45,56.3 96.45,56.03 96.25,55.84 95.98,55.84 95.49,56.32 95.22,56.32 95.03,56.13 95.03,55.85 95.51,55.37 95.51,55.1 95.32,54.9 95.04,54.9 94.56,55.39 94.29,55.39 94.09,55.19 94.09,54.92 94.58,54.44 94.58,54.16 94.38,53.97 94.11,53.97 93.63,54.45 93.35,54.45 93.16,54.26 93.16,53.97 85.26,46.08 85.26,43.35 v2(85.02,43.11)
  BOTTOM w0.079: v1(106.16,74.71) 106.6,75.15 106.6,75.92 106.78,76.1 106.78,77.28 107.11,77.61 107.11,79.25 107.29,79.43 107.29,79.69 107.22,79.81 107.22,80.04 U400.AC36
  BOTTOM w0.127: v2(85.02,43.11) 84.99,43.06 84.96,43.06 84.31,42.92 82.84,42.92 82.62,43.06 82.31,43.58 82.1,44.05 JDIM2800.133
M_A_A2: length 59
  IN1 w0.165: v1(106.15,76.46) 105.75,76.46 105.04,75.75 105.04,72.09 103.16,70.21 103.16,65.48 84.43,46.75 84.43,43.77 84.18,43.53 84.18,43.06 83.42,42.3 83.42,41.61 83.7,41.33 84.18,41.33 84.73,40.78 84.93,40.78 85.24,40.48 85.24,40.25 84.92,39.94 84.69,39.94 v2(83.96,40.67)
  BOTTOM w0.079: U400.AC34 106.78,81.27 106.78,80.11 106.8,80.03 106.8,79.77 106.78,79.7 106.78,77.83 106.45,77.5 106.45,76.75 v1(106.15,76.46)
  BOTTOM w0.127: JDIM2800.132 81.85,37.98 81.94,38.07 81.94,39.17 83.45,40.67 v2(83.96,40.67)
M_A_A3: length 61.1
  IN1 w0.165: v1(106.15,73.54) 106.15,71.41 104.42,69.67 104.42,64.92 102.26,62.77 102.26,62.3 102.65,61.91 102.65,61.63 102.46,61.44 102.19,61.44 101.74,61.89 101.46,61.89 101.27,61.7 101.27,61.42 101.76,60.93 101.76,60.66 101.57,60.47 101.29,60.47 100.77,60.99 100.49,60.99 100.3,60.8 100.3,60.53 100.62,60.2 100.62,59.93 100.43,59.73 100.15,59.73 99.83,60.06 99.56,60.06 99.36,59.86 99.36,59.59 99.85,59.1 99.85,58.83 99.66,58.64 99.38,58.64 99.04,58.98 98.76,58.98 98.57,58.79 98.57,58.52 98.89,58.2 98.89,57.69 94.31,53.1 92.88,53.1 85.76,45.98 85.76,44.7 85.68,44.62 85.68,43.83 85.83,43.67 85.83,42.37 85.59,42.13 85.14,42.13 v2(84.77,42.5)
  BOTTOM w0.079: U400.AC35 107.39,80.52 107.39,79.86 107.46,79.73 107.46,79.36 107.28,79.18 107.28,77.54 106.95,77.21 106.95,76.03 106.84,75.93 106.84,75.8
  BOTTOM w0.127: v2(84.77,42.5) 82.79,42.64 82.62,42.73 82.43,42.89 81.6,44.23 JDIM2800.131 ; 106.84,75.8 106.84,74.22 v1(106.15,73.54)
M_A_A4: length 58.6
  IN1 w0.165: v1(103.32,75.32) 103.03,75.32 102.34,74.63 102.34,72.7 101.33,71.68 100.82,71.68 98.8,69.66 98.8,67.66 93.79,62.65 93.79,62.44 94.53,61.7 94.53,61.43 94.33,61.23 94.06,61.23 93.49,61.8 93.22,61.8 93.03,61.6 93.03,61.33 93.59,60.76 93.59,60.47 79.97,46.84 79.97,45.06 81.01,44.02 81.01,43.4 80.86,43.25 80.86,42.88 80.37,42.4 80.37,38.82 v2(80.86,38.33)
  BOTTOM w0.079: v1(103.32,75.32) 103.62,75.62 103.62,75.64 105.45,77.47 105.45,78.15 105.99,78.69 105.99,79.69 105.96,79.76 105.96,80.06 105.99,80.14 105.99,80.35 105.96,80.4 105.96,80.65 U400.AA35
  BOTTOM w0.127: v2(80.86,38.33) 80.86,38.31 80.85,38.31 JDIM2800.128
M_A_A5: length 60.8
  IN1 w0.165: v1(103.08,73.49) 103.13,73.44 103.13,72.47 101.66,71 101.2,71 99.94,69.74 99.94,66.95 99.7,66.71 99.42,66.71 99.19,66.47 99.19,66.23 99.75,65.67 99.75,65.44 99.5,65.19 99.22,65.19 98.58,65.82 98.31,65.82 98.12,65.63 98.12,65.35 98.76,64.72 98.76,64.44 98.56,64.25 98.29,64.25 97.59,64.94 97.32,64.94 97.13,64.75 97.13,64.47 97.75,63.85 97.75,63.43 80.91,46.59 80.91,45.33 81.75,44.49 81.75,40.47 v2(80.93,39.65)
  BOTTOM w0.079: 105.67,77.02 105.67,77.17 105.98,77.48 106.18,77.48 106.61,77.9 106.61,79.73 106.64,79.81 106.64,80 106.61,80.09 106.61,80.32 U400.AB35
  BOTTOM w0.127: v2(80.93,39.65) 80.36,39.08 80.36,37.04 JDIM2800.126 ; v1(103.08,73.49) 103.36,73.49 104.61,74.73 104.61,75.75 105.67,76.81 105.67,77.02
M_A_A6: length 60.3
  IN1 w0.165: v1(103.35,76.49) 102.91,76.49 102.01,75.6 102.01,72.88 101.2,72.07 100.62,72.07 98.38,69.83 98.38,67.89 92.01,61.51 92.01,61.18 92.72,60.46 92.72,60.19 92.53,60 92.26,60 91.51,60.74 91.23,60.74 91.03,60.54 91.03,60.26 91.78,59.52 91.78,59.24 91.58,59.05 91.31,59.05 90.54,59.82 90.31,59.82 90.08,59.58 90.08,59.35 90.84,58.58 90.84,58.31 90.65,58.12 90.38,58.12 89.61,58.88 89.37,58.88 89.14,58.65 89.14,58.42 89.91,57.65 89.91,57.37 89.72,57.18 89.44,57.18 88.67,57.95 88.44,57.95 88.21,57.71 88.21,57.48 88.97,56.71 88.97,56.44 86.68,54.14 79.55,47.01 79.55,44.86 80.19,44.22 80.19,43.99 v2(80.51,43.67)
  BOTTOM w0.079: v1(103.35,76.49) 104.1,76.49 105.28,77.67 105.28,78.22 105.82,78.76 105.82,79.34 105.73,79.42 U400.AA37
  BOTTOM w0.127: JDIM2800.127 80.6,44.27 80.51,44.18 v2(80.51,43.67)
M_A_A7: length 60.3
  IN1 w0.165: v1(101.44,73.07) 101.01,73.07 97.77,69.83 97.77,67.87 87.39,57.49 87.39,57.2 88.04,56.56 88.04,56.28 87.84,56.09 87.57,56.09 86.97,56.69 86.69,56.69 86.5,56.5 86.5,56.22 87.09,55.64 87.09,55.36 86.9,55.17 86.62,55.17 86.04,55.75 85.77,55.75 85.58,55.55 85.58,55.28 86.22,54.63 86.22,54.28 83.15,51.2 79.13,47.19 79.13,40.19 v2(79.61,39.71)
  BOTTOM w0.079: U400.AA36 105.56,80.05 105.56,79.86 105.48,79.66 105.48,79.43 105.65,79.26 105.65,78.82 105.11,78.29 105.11,77.74 104.34,76.97 103.28,76.97 102.84,76.52 102.84,75.09
  BOTTOM w0.127: v1(101.44,73.07) 102.84,74.46 102.84,75.09 ; v2(79.61,39.71) 79.13,39.22 79.13,38.25 79.35,38.02 JDIM2800.122
M_A_A8: length 58.8
  IN1 w0.165: v2(81.23,42.59) 81.23,42.92 81.34,43.03 81.34,44.3 80.39,45.26 80.39,46.67 95.17,61.45 95.17,61.95 94.65,62.47 94.65,62.74 94.84,62.94 95.12,62.94 95.75,62.3 96.02,62.3 96.22,62.5 96.22,62.77 95.61,63.38 95.61,63.65 95.8,63.85 96.08,63.85 96.68,63.24 96.96,63.24 97.15,63.43 97.15,63.7 96.63,64.23 96.63,64.84 99.22,67.43 99.22,69.53 101.07,71.38 101.46,71.38 102.65,72.57 102.65,73.72 103.06,74.12 v1(103.34,74.12)
  BOTTOM w0.079: 105.34,77.09 105.62,77.37 105.62,78.08 106.15,78.62 106.15,79.73 106.13,79.79 106.13,80.03 106.15,80.11 106.15,80.39 106.13,80.44 106.13,80.94 U400.AB34
  BOTTOM w0.127: v1(103.34,74.12) 103.39,74.12 104.25,74.99 104.25,75.9 105.34,76.99 105.34,77.09 ; v2(81.23,42.59) 80.02,42.59 79.82,42.79 79.82,43.31 79.99,43.49 79.99,43.73 80.1,43.84 JDIM2800.125
M_A_A9: length 58.6
  IN1 w0.165: v1(101.43,75.49) 101.42,75.49 98.81,72.88 96.5,72.88 96.33,72.7 96.33,68.31 80.22,52.21 80.22,51.9 80.84,51.29 80.84,51.01 80.64,50.82 80.37,50.82 79.85,51.34 79.56,51.34 79.38,51.15 79.38,50.88 80.11,50.15 80.11,49.95 79.96,49.8 77.1,46.93 77.1,44.68 77.33,44.46 77.33,42.49 77.95,41.86 v2(77.95,41.86)
  BOTTOM w0.079: U400.W36 104.7,80.04 104.7,79.84 104.77,79.68 104.77,79.43 104.6,79.25 104.6,77.95 104.16,77.51 103.07,77.51 102.07,76.51 102.07,76.12 v1(101.43,75.49)
  BOTTOM w0.127: JDIM2800.121 79.1,43.02 v2(77.95,41.86)
M_A_A10: length 58.6
  IN1 w0.079: v1(105.04,83.06) 104.63,82.64 104.63,82.37 104.95,82.05 105.34,82.05 108.01,79.38 108.01,76.62 107.82,76.43 107.82,76.15
  IN1 w0.165: v2(87.02,38.36) 87.61,38.95 87.61,41 86.94,41.67 86.94,45.38 93.4,51.85 94.83,51.85 105.67,62.69 105.67,69.58 107.37,71.28 107.37,74.33 107.82,74.77 107.82,76.15
  BOTTOM w0.079: v1(105.04,83.06) 105.21,83.22 U400.Y31
  BOTTOM w0.127: v2(87.02,38.36) 87.35,38.03 JDIM2800.146
M_A_A11: length 57.3
  IN1 w0.165: v1(101.43,74.9) 101.43,74.9 96.93,70.4 96.93,68.27 81.39,52.73 81.39,50.63 77.68,46.93 77.68,42.68 77.94,42.42 78.19,42.42 78.46,42.16 78.46,40.19 78.39,40.12 v2(78.39,39.2)
  BOTTOM w0.079: 102.32,76.1 102.32,76.51 103.16,77.35 104.25,77.35 104.76,77.86 104.76,79.18 104.94,79.36 104.94,79.71 104.87,79.88 104.87,80.28 104.77,80.37 104.77,81.27 U400.W34
  BOTTOM w0.127: 102.32,76.1 102.32,75.78 v1(101.43,74.9) ; JDIM2800.120 78.85,38.74 v2(78.39,39.2)
M_A_A12: length 59.1
  IN1 w0.165: v2(78.21,43.62) 78.21,46.87 82.66,51.31 82.66,51.59 81.98,52.27 81.98,52.54 82.17,52.73 82.44,52.73 83.06,52.11 83.33,52.11 83.52,52.3 83.52,52.58 82.87,53.23 82.87,53.48 83.06,53.67 83.36,53.67 83.99,53.04 84.26,53.04 84.46,53.24 84.46,53.51 83.82,54.15 83.82,54.45 84.01,54.64 84.26,54.64 84.92,53.98 85.2,53.98 85.39,54.17 85.39,54.45 84.66,55.17 84.66,55.41 97.35,68.1 97.35,70.02 101.03,73.7 v1(101.44,73.7)
  BOTTOM w0.079: 102.61,76.18 102.61,76.55 103.24,77.18 104.32,77.18 104.93,77.79 104.93,78.34 105.48,78.89 105.48,79.19 105.31,79.36 105.31,79.74 105.39,79.93 105.39,80.55 105.47,80.63 105.47,81.09 105.73,81.35 U400.AA34
  BOTTOM w0.127: 102.61,76.18 102.61,75.54 102.08,75.01 102.08,74.34 v1(101.44,73.7) ; JDIM2800.119 78.6,44.01 v2(78.21,43.62)
M_A_A13: length 59
  IN1 w0.079: v1(107.81,82.35) 107.81,82.17 108.82,81.16 108.82,80.5 109.74,79.58 109.74,78.69
  IN1 w0.165: 109.74,78.69 109.74,71.99 109.48,71.73 109.48,70.69 108.19,69.4 108.19,58.86 101.38,52.05 98.62,52.05 95.9,49.33 94.54,49.33 89.9,44.69 89.9,42.02 89.67,41.79 89.67,40.8 89.17,40.3 89.17,39.03 89.33,38.87 89.63,38.87 89.82,39.06 v2(89.82,39.22)
  BOTTOM w0.079: U400.AC32 107.59,82.57 v1(107.81,82.35)
  BOTTOM w0.127: JDIM2800.158 90.35,38.03 90.1,38.28 90.1,38.94 v2(89.82,39.22)
M_A_ACT#: length 60.3
  IN1 w0.165: v1(102.85,78.14) 100.08,78.14 99.69,78.53 98.22,78.53 94.52,74.83 94.52,68.94 74.27,48.68 74.27,44.45 74.74,43.98 74.74,43.01 75.17,42.58 75.17,41.74 76.79,40.11 76.79,38.95 v2(77.35,38.38)
  BOTTOM w0.079: U400.V35 103.47,80.15 103.47,79.43 103.36,79.32 103.36,78.64 v1(102.85,78.14)
  BOTTOM w0.127: v2(77.35,38.38) JDIM2800.114
M_A_ALERT#: length 57.1
  IN1 w0.165: v2(77.85,40.47) 77.33,41 77.33,41.69 76.92,42.09 76.92,44.1 76.34,44.68 76.34,46.77 78.88,49.31 78.88,51.51 79.7,52.34 95.91,68.54 95.91,73.12 96.19,73.4 98.1,73.4 101.01,76.31 101.24,76.31 v1(101.43,76.12)
  BOTTOM w0.079: U400.W37 104.43,79.49 104.43,78.03 104.08,77.68 103,77.68 101.96,76.65 v1(101.43,76.12)
  BOTTOM w0.127: v2(77.85,40.47) JDIM2800.116
M_A_BG#0: length 59.7
  IN1 w0.165: v2(76.48,41.7) 76.3,41.7 75.67,42.32 75.67,42.96 75.04,43.59 75.04,48.86 95.07,68.89 95.07,74.39 98.79,78.11 99.32,78.11 99.8,77.63 103.07,77.63 103.45,78.01 103.45,78.45 103.62,78.62 v1(103.87,78.62)
  BOTTOM w0.079: v1(103.87,78.62) 104.09,78.85 104.09,79.7 104.12,79.79 104.12,80.01 104.09,80.11 104.09,80.36 104.12,80.48 104.12,80.94 U400.V34
  BOTTOM w0.127: JDIM2800.115 77.6,44.25 77.35,44 77.35,43.39 77.11,43.15 77.11,42.33 v2(76.48,41.7)
M_A_BG#1: length 58.3
  IN1 w0.165: v1(103.89,78.04) 103.89,77.78 103.34,77.22 101,77.22 99.27,75.49 98.61,75.49 98.35,75.76 97.55,75.76 95.49,73.69 95.49,68.72 77.51,50.74 77.51,50.5 78.14,49.86 78.14,49.59 77.95,49.4 77.68,49.4 77.27,49.81 77.03,49.81 76.8,49.57 76.8,49.34 77.21,48.93 77.21,48.66 77.02,48.46 76.74,48.46 76.33,48.87 76.1,48.87 75.88,48.65 75.88,44.34 76.18,44.03 76.18,43.27 v2(76.46,43)
  BOTTOM w0.079: v1(103.89,78.04) 104.26,78.41 104.26,79.67 104.29,79.76 104.29,80.03 104.26,80.13 104.26,80.34 104.29,80.46 104.29,80.65 U400.W35
  BOTTOM w0.127: JDIM2800.113 77.1,44.26 77,44.15 77,43.53 v2(76.46,43)
M_A_BS#0: length 56.7
  IN1 w0.165: v1(104.16,82.32) 104.87,81.84 105.11,81.75 105.35,81.65 105.47,81.54 105.65,81.31 105.92,80.9 106.92,79.25 106.92,74.3 106.97,73.87 106.97,71.32 105.25,69.61 105.25,63.53 105.24,63.51 104.91,62.87 104.69,62.52 103.93,61.54 94.66,52.27 93.23,52.27 86.58,45.61 86.58,40.47 86.63,40.29 v2(87.04,39.67)
  BOTTOM w0.079: U400.W32 v1(104.16,82.32)
  BOTTOM w0.127: JDIM2800.150 88.35,38 88.24,38.2 88.05,38.47 87.72,38.88 87.25,39.42 v2(87.04,39.67)
M_A_BS#1: length 58.9
  IN1 w0.079: v1(105.98,83.08) 105.98,82.01 108.62,79.37 108.62,76.23
  IN1 w0.165: 108.62,76.23 108.62,74.5 108.03,73.92 108.03,71.04 106.51,69.52 106.51,62.34 105.7,61.53 105.7,61.29 106.51,60.48 106.51,60.2 106.31,60 106.05,60 105.23,60.83 105,60.83 104.76,60.59 104.76,60.36 105.55,59.57 105.55,59.31 105.35,59.12 105.07,59.12 104.29,59.89 104.06,59.89 95.18,51.01 93.75,51.01 88.22,45.48 88.22,43.34 v2(87.82,42.93)
  BOTTOM w0.079: U400.AB31 106.12,83.22 v1(105.98,83.08)
  BOTTOM w0.127: v2(87.82,42.93) 87.1,43.64 JDIM2800.145
M_A_CAS#: length 58.6
  IN1 w0.079: 109.23,78.75 109.23,79.47 108.09,80.62 108.09,81.26 107.79,81.55 107.51,81.55 v1(106.87,82.2)
  IN1 w0.165: 109.23,78.75 109.23,72.47 108.67,71.91 108.67,70.78 107.35,69.46 107.35,59.65 103.35,55.66 101.04,55.66 95.55,50.17 94.16,50.17 89.16,45.17 89.16,42.98 88.6,42.42 88.6,41.73 88.77,41.57 88.94,41.57 89.14,41.37 89.14,41.1 88.94,40.91 88.81,40.91 88.73,40.82 v2(88.73,40.26)
  BOTTOM w0.079: v1(106.87,82.2) 106.65,82.42 106.58,82.42 U400.AB32
  BOTTOM w0.127: JDIM2800.156 89.85,38.54 89.23,39.17 89.23,39.77 v2(88.73,40.26)
M_A_CB0: length 2.6
  TOP w0.102: R2804.2 72.76,37.4 v2(71.85,38.31)
  BOTTOM w0.102: JDIM2800.92 71.85,37.99 71.85,37.99
  BOTTOM w0.114: 71.85,37.99 v2(71.85,38.31)
M_A_CB1: length 3
  TOP w0.102: R2805.2 71.56,44.15 v2(71.56,43.61)
  BOTTOM w0.114: JDIM2800.91 71.6,44.13 71.56,44.08 v2(71.56,43.61)
M_A_CB2: length 6.4
  TOP w0.102: v2(72.86,42.28) 72.91,42.33 72.91,42.35 73.52,42.96 73.52,43.77 74,44.25 R2806.2
  BOTTOM w0.114: JDIM2800.101 74.1,44.31 73.59,43.79 73.59,43 72.86,42.28 v2(72.86,42.28)
M_A_CB3: length 4.3
  TOP w0.102: v2(74.22,43.2) 75.01,44 R2807.2
  BOTTOM w0.114: v2(74.22,43.2) 75.1,44.09 JDIM2800.105
M_A_CB4: length 2.5
  TOP w0.102: v2(70.85,38.31) 71.69,37.48 R2808.2
  BOTTOM w0.114: v2(70.85,38.31) JDIM2800.88
M_A_CB5: length 5
  TOP w0.102: v2(70.32,42.89) 70.82,43.39 70.82,43.86 R2809.2
  BOTTOM w0.114: JDIM2800.87 70.6,44.06 70.79,43.88 70.79,43.35 v2(70.32,42.89)
M_A_CB6: length 2.2
  TOP w0.102: R2810.2 73.77,38.16 73.85,38.24 v2(73.85,38.31)
  BOTTOM w0.114: v2(73.85,38.31) JDIM2800.100
M_A_CB7: length 2.3
  TOP w0.102: R2811.2 74.84,38.32 v2(74.85,38.34)
  BOTTOM w0.114: v2(74.85,38.34) JDIM2800.104
M_A_CKE0: length 61
  IN1 w0.165: v1(102.8,79.33) 102.19,79.33 101.76,79.76 95.77,79.76 94.06,78.06 94.06,77.12 92.69,75.75 92.69,74.35 93.23,73.81 93.23,68.83 72.6,48.2 72.6,44.69 73.32,43.97 73.32,42.77 v2(74.18,41.92)
  BOTTOM w0.079: U400.U36 102.96,79.97 102.96,79.49 v1(102.8,79.33)
  BOTTOM w0.127: v2(74.18,41.92) 74.91,42.65 74.95,42.65 76.1,43.8 JDIM2800.109
M_A_CKE1: length 60.8
  IN1 w0.165: v2(76.28,38.36) 75.65,38.99 75.65,40.39 74.65,41.38 74.65,42.09 74.06,42.68 74.02,42.68 73.76,42.94 73.76,44.42 73.8,44.46 73.8,48.81 93.89,68.89 93.89,73.74 93.1,74.53 93.1,75.42 97.12,79.44 101.58,79.44 102.27,78.74 v1(102.85,78.74)
  BOTTOM w0.079: U400.U37 103.21,79.41 103.19,79.38 103.19,79.08 v1(102.85,78.74)
  BOTTOM w0.127: JDIM2800.110 76.35,38 76.28,38.07 v2(76.28,38.36)
M_A_CLKN0: length 60.4
  IN1 w0.114: v1(103.23,82.45) 103.18,82.5 103.01,82.5 102.95,82.45 102.95,81.95 102.73,81.72 102.51,81.72 102.18,81.39 102.18,81.07 102.47,80.78 104.3,80.78 106.06,79.01 106.06,78.66 105.82,78.41 105.32,78.41 105.21,78.3 105.21,78.05 105.7,77.56 105.7,77.19 105.45,76.94 104.83,76.94 104.72,76.83 104.72,72.36 102.38,70.01 102.38,69.85 102.69,69.54 102.69,69.19 102.44,68.94 101.82,68.94 101.68,68.8 101.68,68.43 101.81,68.3 102.26,68.3 102.51,68.05 102.51,67.47 102.26,67.22 101.8,67.22 101.69,67.11 101.69,66.71 101.8,66.6 102.26,66.6 102.51,66.35 102.51,65.75 102.26,65.51 101.93,65.51 101.81,65.39 101.81,65.05 83.78,47.02 83.78,46.4 83.53,46.15 83.08,46.15 82.96,46.04 82.96,45.64 83.08,45.53 83.53,45.53 83.78,45.28 83.78,44.73 83.48,44.43 83.48,43.38 83.52,43.34 v2(83.74,43.34)
  BOTTOM w0.079: v1(103.23,82.45) 103.23,82.63 103.37,82.76 103.56,82.76 103.69,82.63 U400.V32
  BOTTOM w0.097: JDIM2800.139 83.6,44.28 83.44,44.12 83.44,43.4 83.5,43.34 v2(83.74,43.34)
M_A_CLKN1: length 59.6
  IN1 w0.114: v1(102.32,82.45) 102.16,82.61 101.99,82.61 101.43,82.05 101.43,80.98 102.29,80.12 103.79,80.12 104.55,79.35 104.55,77.58 104.12,77.15 104.12,72.6 100.82,69.3 100.82,65.27 82.38,46.83 82.38,46.82 81.97,46.42 81.97,45.5 82.15,45.33 82.15,45.09 82.38,44.85 82.38,42.86 82.66,42.58 82.66,40.74 83.64,39.76 83.64,38.98 83.72,38.9 v2(83.99,38.9)
  BOTTOM w0.079: v1(102.32,82.45) 102.44,82.57 U400.T32
  BOTTOM w0.097: v2(83.99,38.9) 83.73,38.9 83.65,38.82 83.65,38.18 83.85,37.98 JDIM2800.140
M_A_CLKP0: length 60.4
  IN1 w0.114: v1(103.24,83.09) 102.73,82.58 102.73,82.04 102.63,81.95 102.41,81.95 101.95,81.48 101.95,80.97 102.37,80.55 104.21,80.55 105.84,78.92 105.84,78.76 105.72,78.64 105.23,78.64 104.98,78.39 104.98,77.96 105.47,77.47 105.47,77.28 105.35,77.17 104.74,77.17 104.49,76.92 104.49,72.45 102.15,70.11 102.15,69.76 102.46,69.45 102.46,69.28 102.34,69.17 101.73,69.17 101.46,68.9 101.46,68.33 101.72,68.07 102.17,68.07 102.28,67.96 102.28,67.56 102.17,67.45 101.71,67.45 101.46,67.2 101.46,66.62 101.71,66.37 102.17,66.37 102.28,66.25 102.28,65.85 102.17,65.73 101.83,65.73 101.58,65.49 101.58,65.15 83.55,47.12 83.55,46.49 83.43,46.38 82.98,46.38 82.74,46.13 82.74,45.55 82.98,45.3 83.43,45.3 83.55,45.18 83.55,44.83 83.25,44.53 83.25,43.61 v2(82.97,43.34)
  BOTTOM w0.079: U400.V31 103.36,83.22 v1(103.24,83.09)
  BOTTOM w0.097: JDIM2800.137 83.1,44.29 83.24,44.15 83.24,43.6 v2(82.97,43.34)
M_A_CLKP1: length 59.6
  IN1 w0.114: v2(83.22,38.9) 83.41,39.09 83.41,39.66 82.43,40.65 82.43,42.48 82.15,42.76 82.15,44.76 81.92,44.99 81.92,45.23 81.75,45.41 81.75,46.51 82.15,46.92 82.15,46.92 100.59,65.36 100.59,69.39 103.89,72.69 103.89,77.25 104.33,77.68 104.33,79.25 103.69,79.89 102.2,79.89 101.2,80.89 101.2,82.15 101.9,82.84 102.07,82.84 v1(102.32,83.1)
  BOTTOM w0.079: U400.T31 102.44,83.22 v1(102.32,83.1)
  BOTTOM w0.097: JDIM2800.138 83.35,37.98 83.45,38.08 83.45,38.67 v2(83.22,38.9)
M_A_CS#0: length 63.1
  IN1 w0.079: v1(107.8,83.06) 107.37,82.63 107.37,82.21 108.39,81.19 108.39,80.55 109.48,79.46 109.48,78.77
  IN1 w0.165: v2(89.09,42.17) 89.09,42.22 89.47,42.6 89.47,44.88 94.34,49.75 95.73,49.75 99.28,53.31 99.51,53.31 100.33,52.49 100.35,52.47 100.61,52.47 100.83,52.69 100.83,52.93 99.98,53.77 99.98,54.01 100.22,54.24 100.45,54.24 101.44,53.25 101.67,53.25 101.88,53.46 101.88,53.72 101.71,53.88 100.92,54.68 100.92,54.94 101.21,55.24 101.66,55.24 102.43,54.46 102.9,54.46 107.77,59.33 107.77,69.43 109.08,70.73 109.08,71.84 109.48,72.24 109.48,78.77
  BOTTOM w0.079: v1(107.8,83.06) 108.03,82.84 108.03,82.78 U400.AE32
  BOTTOM w0.127: v2(89.09,42.17) 89.09,42.22 88.2,43.11 88.2,44.09 88.1,44.18 JDIM2800.149
M_A_CS#1: length 64
  IN1 w0.079: 109.72,80.41 109.36,80.78 109.36,81.31 108.7,81.96 v1(108.7,82.35)
  IN1 w0.165: v2(90.73,42.46) 90.73,44.33 94.89,48.49 96.24,48.49 97.04,49.28 97.27,49.28 97.95,48.6 98.19,48.6 98.41,48.82 98.41,49.08 97.74,49.75 97.74,49.98 97.97,50.22 98.2,50.22 99.35,49.07 99.59,49.07 99.82,49.3 99.82,49.54 98.67,50.68 98.67,50.92 98.97,51.21 99.3,51.21 100.37,50.14 100.66,50.14 100.89,50.37 100.89,50.66 100.7,50.85 100.7,51.05 100.87,51.21 101.73,51.21 105.45,54.93 105.89,54.93 106.27,54.55 106.98,54.55 107.48,55.06 107.48,56.97 109.25,58.74 109.25,69.56 111.13,71.44 111.13,77.43 110.65,77.91 110.65,79.48 109.72,80.41
  BOTTOM w0.079: v1(108.7,82.35) 108.92,82.57 U400.AF32
  BOTTOM w0.127: v2(90.73,42.46) 90.74,42.46 90.31,42.89 90.31,44.05 90.1,44.25 JDIM2800.157
M_A_DQ0: length 78.7
  IN1 w0.127: v1(90.87,86.52) 90.58,86.82 86.29,86.82 80.07,80.6 80.07,69.06 59.54,48.54 59.54,48.33 60.03,47.84 60.03,47.63 59.88,47.48 59.67,47.48 59.32,47.83 59.11,47.83 58.96,47.68 58.96,47.47 59.37,47.07 59.37,46.88 58.92,46.43 53.04,46.43 50.68,44.07 50.68,42.61 51.16,42.13 51.16,40.87 v2(50.81,40.51)
  BOTTOM w0.079: v1(90.87,86.52) 91.25,86.15 92.87,86.15 93.3,86.58 94.05,86.58 U400.A26
  BOTTOM w0.102: JDIM2800.4 49.85,39.56 v2(50.81,40.51)
M_A_DQ1: length 79.7
  IN1 w0.127: v1(92.64,85.35) 92.64,85.81 93.25,86.42 93.25,87.1 92.74,87.61 91.62,87.61 91.28,87.96 85.55,87.96 78.14,80.55 78.14,76.39 78.27,76.27 78.4,76.27 78.55,76.12 78.55,75.65 78.14,75.24 78.14,72.14 78.47,71.81 78.47,71.25 78.14,70.92 78.14,70.49 78.47,70.16 78.47,69.32 56.72,47.57 52.57,47.57 49.36,44.36 v2(49.36,43.34)
  BOTTOM w0.079: U400.D26 96.08,85.71 95.93,85.56 95.51,85.56 95.48,85.58 95.04,85.58 94.88,85.61 94.66,85.61 94.59,85.58 94.35,85.58 94.27,85.61 93.89,85.61 93.41,85.13 93.4,85.12 92.87,85.12 v1(92.64,85.35)
  BOTTOM w0.102: JDIM2800.3 49.6,43.58 v2(49.36,43.34)
M_A_DQ2: length 79.9
  IN1 w0.127: v2(52.85,38.41) 52.41,38.85 52.41,42.33 52.87,42.78 52.87,43.95 53.86,44.94 59.53,44.94 65.95,51.36 66.04,51.45 66.04,51.76 65.56,52.24 65.56,52.45 65.71,52.6 65.92,52.6 66.44,52.08 66.67,52.08 66.83,52.24 66.83,52.47 66.32,52.97 66.32,53.19 66.47,53.33 66.68,53.33 67.21,52.8 67.39,52.8 67.57,52.98 67.57,53.16 67.05,53.68 67.05,53.94 81.72,68.61 81.72,79.91 85.89,84.08 87.08,84.08 88.3,85.3 89.31,85.3 89.8,84.82 90.91,84.82 v1(91.7,84.03)
  BOTTOM w0.079: U400.D28 95.86,85.19 95.59,84.92 94.93,84.92 94.86,84.85 94.52,84.85 93.79,84.56 93.68,84.45 92.99,84.45 92.92,84.39 92.06,84.39 v1(91.7,84.03)
  BOTTOM w0.102: v2(52.85,38.41) JDIM2800.16
M_A_DQ3: length 79.8
  IN1 w0.127: v2(53.85,39.2) 54.04,39.2 55.48,40.65 58.45,40.65 59.67,41.86 59.67,43.47 78.11,61.9 78.11,62.26 77.65,62.72 77.65,62.93 77.8,63.07 78.01,63.07 78.54,62.55 78.76,62.55 78.91,62.7 78.91,62.92 78.39,63.45 78.39,63.66 78.54,63.81 78.75,63.81 79.27,63.28 79.48,63.28 79.63,63.43 79.63,63.64 79.11,64.17 79.11,64.38 79.25,64.53 79.46,64.53 79.99,64 80.2,64 80.35,64.15 80.35,64.36 79.82,64.89 79.82,65.1 79.97,65.24 80.18,65.24 80.71,64.72 80.92,64.72 81.07,64.86 81.07,65.08 80.54,65.6 80.54,65.81 80.69,65.96 80.9,65.96 81.43,65.43 81.64,65.43 81.79,65.58 81.79,65.79 81.25,66.34 81.25,66.52 82.86,68.13 82.86,78.06 88.42,83.62 88.42,83.74 v1(88.71,84.03)
  BOTTOM w0.079: 90.36,84.89 92.62,84.89 92.68,84.95 93.47,84.95 93.96,85.44 94.24,85.44 94.32,85.41 94.62,85.41 94.69,85.44 94.87,85.44 95.02,85.41 95.21,85.41 U400.C28
  BOTTOM w0.102: v2(53.85,39.2) JDIM2800.20 ; 90.36,84.89 89.57,84.89 v1(88.71,84.03)
M_A_DQ4: length 77.6
  IN1 w0.127: v1(91.45,86.6) 90.85,87.2 85.91,87.2 79.69,80.97 79.69,69.22 57.28,46.81 52.89,46.81 50.3,44.23 50.3,42.45 50.78,41.97 50.78,41.1 50.3,40.61 50.3,39.77 v2(50.85,39.22)
  BOTTOM w0.079: v1(91.45,86.6) 91.73,86.32 92.8,86.32 93.23,86.74 94.25,86.74 94.4,86.67 94.6,86.67 U400.B26
  BOTTOM w0.102: v2(50.85,39.22) JDIM2800.8
M_A_DQ5: length 78.9
  IN1 w0.127: v1(92.66,86.68) 92.11,87.23 91.45,87.23 91.1,87.58 85.75,87.58 78.9,80.73 78.9,80.55 79.23,80.22 79.23,79.89 79.1,79.76 79,79.76 78.85,79.61 78.85,79.4 79,79.25 79.05,79.25 79.18,79.12 79.18,78.87 79.05,78.74 79,78.74 78.85,78.59 78.85,78.38 79,78.24 79.05,78.24 79.18,78.11 79.18,77.85 79.05,77.73 79,77.73 78.85,77.58 78.85,77.37 79,77.22 79.1,77.22 79.18,77.14 79.18,75.06 78.95,74.83 78.95,74.27 79.18,74.05 79.18,73.36 78.95,73.13 78.95,72.6 79.18,72.37 79.18,69.49 56.88,47.19 52.73,47.19 49.92,44.38 49.92,42.3 50.12,42.09 v2(50.12,41.76)
  BOTTOM w0.079: v1(92.66,86.68) 92.89,86.91 94.29,86.91 94.44,86.84 94.91,86.84 95.05,86.7 95.22,86.7 U400.C26
  BOTTOM w0.102: JDIM2800.7 50.6,43.03 50.12,42.55 v2(50.12,41.76)
M_A_DQ6: length 78.5
  IN1 w0.127: v2(53.31,43.63) 54.23,44.56 59.69,44.56 68.33,53.21 68.33,53.62 67.92,54.04 67.92,54.27 68.08,54.43 68.31,54.43 68.79,53.96 69,53.96 69.15,54.11 69.15,54.32 68.71,54.75 68.71,54.97 68.86,55.11 69.07,55.11 69.55,54.63 69.76,54.63 69.91,54.78 69.91,54.99 69.43,55.47 69.43,55.68 69.58,55.83 69.79,55.83 70.27,55.35 70.48,55.35 70.63,55.5 70.63,55.71 70.16,56.18 70.16,56.39 70.31,56.54 70.52,56.54 70.99,56.07 71.2,56.07 71.35,56.22 71.35,56.43 70.88,56.9 70.88,57.11 71.03,57.26 71.24,57.26 71.71,56.79 71.92,56.79 72.07,56.94 72.07,57.15 71.57,57.64 71.57,57.85 71.72,58 71.93,58 72.43,57.51 72.64,57.51 72.78,57.66 72.78,57.87 72.24,58.41 72.24,58.59 82.1,68.45 82.1,79.71 86.09,83.7 87.24,83.7 88.46,84.92 89.04,84.92 89.52,84.43 90.1,84.43 v1(90.51,84.03)
  BOTTOM w0.079: U400.B28 94.62,85.02 94.48,85.02 93.71,84.71 93.7,84.71 93.61,84.62 92.88,84.62 92.82,84.56 91.04,84.56 v1(90.51,84.03)
  BOTTOM w0.102: v2(53.31,43.63) 53.31,44.04 53.1,44.24 JDIM2800.17
