# Allegro board dax8jmb16e0-e-www.DeviceDB.xyz_.brd (continued)
## Nets (continued)
N37096728: PQ8013.2(B1) PQ8013.5(B2) PR8026.1
N37096732: PQ8007.4(G) PQ8013.6(C1) PR8024.2
N37096738: PQ8009.1(S) PQ8013.4(E2)
N37096862: PQ8008.1(S) PQ8012.4(E2)
N37277040: C4708.2 U4701.A6(CAP)
N37519775: TP6105.1 U6100.20(SDA_3/VSEL_2/GPIO_P3.6)
N37543651: R3509.2 U3501.16(REXT)
N37586765: C3504.1 U3501.17(CEXT)
N37868269: R606.1 U400.E1(SKTOCC#)
N38095593: CN4300.75(GND_75) R4307.2
N38167474: F3402.1 R3418.1 R3419.1
N38256574: D7600.2(ANODE) R7611.2
N38256936: C7608.1 C7617.1 U7600.14(VCC12)
N38259073: R7615.2 U7600.26(CWP)
N38478578: R514.2 U400.CP32(CNV_WT_RCOMP_0) U400.CR32(CNV_WT_RCOMP_1)
N38488617: Q7500A.1(S) R7502.2 U7500.6(R\S\T\1\)
N38488687: Q7500B.1(S) R7503.2 U7500.7(R\S\T\2\)
N38488730: R7500.1 U7500.3(R\S\T\3\)
N38512591: C2828.2 R2818.2
N38515705: C2857.2 R2842.1
N38531847: Q5004.6(D) R5014.1
N38538012: CN7700.41(HOOK1) R7717.1
N38538131: CN7700.39(PWRGOOD/HOOK0) R7720.2
N38538150: CN7700.46(RESET#/HOOK6) R7723.2
N38881137: PR8838.1 PR8863.2
N38904312: PC8509.2 PQ8505.2(BASE) PR8511.1 PR8513.2
N38904357: PQ8505.3(COLLECTOR) PQ8506.2(BASE) PR8514.2
N38936226: PQ8200.4(G) PQ8202.6(C1) PR8207.1
N38936233: PD8201.2 PQ8201.2(G) PR8204.1
N38936236: PC8203.2 PC8204.1 PR8201.1 PR8205.1
N38936237: PC8204.2 PC8205.1 PR8202.1 PR8206.1
N38936238: PQ8201.1(S) PQ8202.4(E2)
N38936239: PQ8202.3(C2) PR8203.2
N38936251: PQ8202.2(B1) PQ8202.5(B2) PR8208.1
N38936280: PD8202.1(CATHODE) PD8204.1(CATHODE) PR8210.1
N38936318: PC8212.1 PR8212.1
N38936322: PD8207.3(ANODE) PR8213.1
N38936359: PC8216.1 PR8216.1
N38936366: PC8217.1 PC8218.1 PR8217.1 PR8225.2
N38936367: PC8218.2 PC8219.1 PR8218.1 PR8227.2
N38936486: PR8236.1 PU8201.3(ALERT#)
N38936522: PR8243.2 PR8244.1
N39054084: PD8207.2(CATHODE) PR8245.1
N39054087: PD8207.1(NC) PR8246.1
N39054316: PD8206.2(ANODE) PR8247.2 PR8248.2
N39109711: PC8611.1 PC8612.1 PC8613.1 PC8614.1 PC8615.1 PC8616.1 PL8600.2 PR8606.2 PR8622.2
N39166693: PC9533.1 PU9502.12(CT1)
N39166694: PC9534.1 PU9502.10(CT2)
N39176871: R472.1 U400.CJ31(GPP_H9/I2C4_SCL)
N39250128: R3606.1 U3600.2(GPIO0/DMIC-DATA12)
N39250180: R3607.1 U3600.3(GPIO1/DMIC-CLK)
N39252871: C3616.1 U3600.22(VREF)
N39252874: C3615.2 R3612.2 U3600.21(LDO1-CAP)
N39253153: C3617.2 U3600.27(CPVEE)
N39253381: C3618.2 U3600.28(CBN)
N39253577: C3618.1 U3600.30(CBP)
N39254281: C3620.1 C3621.2 R3627.2 U3600.20(AVDD1)
N39254866: R3613.2 R3614.1 U3600.12(HP/LINE1-JD(JD1))
N39255557: C3623.2 U3600.6(LDO3-CAP)
N39257337: C3628.1 U3600.32(LDO2-CAP)
N39257569: C3629.1 L3604.2 U3600.33(AVDD2)
N39257899: C3630.2 C3631.1 C3632.2 C3633.1 L3605.1 U3600.34(PVDD1) U3600.39(PVDD2)
N39295059: PC8631.1 PC8632.1 PC8633.1 PC8634.1 PC8635.1 PC8636.2 PL8601.2 PR8617.1 PR8623.2 PR8624.2
N39295158: PC8630.1 PR8615.1
N39300434: Q3600.1(EMITTER) R3622.1
N39300462: Q3600.2(BASE) R3623.1
N39344253: R3624.2 U3600.16(VD33STB)
N39344256: C3610.2 U3600.15(MIC2-CAP)
N39350388: PR9211.2 PR9215.1 PU9202.4(OUT Y)
N39350435: PR9214.2 PR9216.1 PR9217.1 PU9202.2(INA)
N39350871: PR9618.1 PU9601.1(A)
N39404743: PR8902.1 PR8908.1
N39404748: PC8912.1 PR8908.2 PR8911.2 PR8912.1
N39429458: PR8127.1 PU8102.1(NC)
N39429526: PQ8100.3(D) PR8125.2 PR8127.2
N39429563: PC8105.1 PR8121.1 PR8123.1 PU8102.2(INA)
N39429571: PQ8100.5(G) PQ8100.6(D) PR8126.2
N39429642: PD8101.1 PR8130.2
N39429644: PD8101.2 PQ8100.2(G) PR8129.1
N39437629: PR8836.2 PR8862.1
N39495583: PC8925.1 PR8923.2 PR8926.2 PR8927.1
N39495593: PC8925.2 PC8926.2 PR8919.1 PR8925.2 PR8928.2 PR8929.2
N39496223: PR8918.1 PR8923.1
N39496240: PR8924.2 PR8925.1
N39496246: PR8924.1 PR8927.2 PR8928.1
N39505770: PC8924.1 PR8917.2
N39507993: PC8911.1 PR8904.2
N39508098: PC8912.2 PC8913.2 PR8905.1 PR8910.2 PR8913.2 PR8914.2
N39508207: PR8909.2 PR8910.1
N39508213: PR8909.1 PR8912.2 PR8913.1
N39511106: PC9015.1 PR9004.2
N39511208: PC9016.1 PR9008.2 PR9011.2 PR9012.1
N39511215: PC9016.2 PC9017.2 PR9006.1 PR9010.2 PR9013.2 PR9014.2
N39511310: PR9005.1 PR9008.1
N39511324: PR9009.2 PR9010.1
N39511330: PR9009.1 PR9012.2 PR9013.1
N39518726: PC9032.1 PR9019.2
N39518792: PC9033.1 PR9023.2 PR9026.2 PR9027.1
N39518799: PC9033.2 PC9034.2 PR9021.1 PR9025.2 PR9028.2 PR9029.2
N39518892: PR9020.1 PR9023.1
N39518906: PR9024.2 PR9025.1
N39518912: PR9024.1 PR9027.2 PR9028.1
N39639429: CN7603.7 R7636.1
N39639481: CN7603.6 R7637.1
N40345900: TP4707.1 U4701.F10(GPIOC7/D\T\R\_BOUT)
N40797009: R7628.2 U7601.4(EN)
N40803839: C7616.1 Q7600.2(G) Q7600.3(D) R7617.2 R7618.1
N42265562: CN4000.13(GND) CN4000.14(GND1) R4013.2
N42433669: CN4000.15(GND2) CN4000.16(GND3) R4012.2
N43333369: Q3400.2(G) R3400.1 R3402.1
N53993617: Q5002.2(G) Q5003.3(D) R5011.1
N54863788: TP404.1 U400.CG35(SPI0_CS1#)
N55084151: CN4300.68(SUSCLK) TP4300.1
N267342533: TP5300.1 U5300.11(INT2)
N396393270: CN7603.1 TP7606.1
N396393460: CN7603.2 TP7607.1
N396393590: CN7603.4 TP7608.1
N396393720: CN7603.5 TP7609.1
N447193501: PR8840.1 PR8864.2
N3850189818: TP428.1 U400.CR35(RSVD28)
N4193523427: JDIM2800.162(S2#/C0) TP2801.1
N4193523428: JDIM2800.165(S3#/C1) TP2802.1
N4193827027: JDIM2801.162(S2#/C0) TP2800.1
N4193827028: JDIM2801.165(S3#/C1) TP2803.1

Pads without a net: CN3400 3; CN3500 13 14; CN4100 8 12 20 44 46 48 66 68 70; CN4200 24 29 31 35 37 38 40 42 44 46 48 60 62 63 64 65 68; CN4201 4 8 12; CN4300 6 8 20 22 24 26 28 30 32 34 36 40 42 44 46 48 54 56 58 67; CN4400 11 12; CN5000 33 40 41 42; CN5001 4 5; CN5201 8; CN6200 9 10; CN7600 8; CN7601 2; CN7603 11 12; CN7702 5 8; D5003 3 4 5; H7931 1; H7932 1; H7933 1; NOREF#2 1; NOREF#3 1; NOREF#5 1; NOREF#7 1; NOREF#8 1; NOREF#9 1; PCN8500 4; PQ8900 2; PQ8901 2; PU8600 10 15 16; PU8800 2 37; U400 A34 A35 AA24 AA26 AB25 AC6 AC7 AC24 AC25 AC26 AD24 AD26 AG6 AG7 AH26 AJ1 AJ2 AJ3 AJ4 AJ27 AL1 AL2 AL3 AL4 AM3 AM4 AN1 AN2 AN3 AN4 AR3 AT3 AU3 AY9 B35 BA1 BA2 BB9 BB24 BC1 BC2 BC24 BC28 BJ34 BJ36 BK34 BK35 BK36 BL34 BL36 BL37 BP8 BP9 BP34 BP35 BR18 BT3 BT4 BT6 BT7 BT8 BT9 BU1 BU2 BU3 BU4 BU5 BU6 BU8 BU9 BV24 BV25 BV28 BV30 BV34 BW3 BW4 BW8 BW9 BY31 BY32 C34 CA34 CA35 CA36 CA37 CB8 CB9 CC30 CE27 CE29 CE30 CE32 CF12 CF20 CF22 CF27 CF29 CG1 CG2 CG22 CH20 CH25 CH27 CH28 CH30 CJ25 CJ27 CJ29 CJ30 CK15 CK22 CK23 CK25 CM10 CM16 CM18 CM19 CM20 CM22 CM26 CM27 CN8 CN16 CN18 CN19 CN23 CN24 CN26 CN36 CP3 CP4 CP16 CP18 CP26 CP36 CR3 CR4 CR12 CR16 CR18 CR20 D34 D37 F34 F37 G1 G2 G3 G4 H3 H4 K12 K14 K15 K17 K18 K20 L25 M24 M26 P24 P26 R24 R25 R26 T25 U3 U4 U34 U35 V24 V25 V28 V29 W3 W25 Y3 Y24 Y25; U3501 12 20; U3600 17 18; U4100 3; U4701 A12 D2 D3 E9 F3 G10 H6 J9 J10 K5 L6 L11 M11; U5100 3 4 5 10 11 12 13 14 15 16 25 26 27 28 29 30 31; U5701 3; U5800 23 38; U5801 3; U6100 3 4 5 21 38 39; U6302 B1 B2 C1; U7500 8; U7600 8 13; U7601 3

## Via types
v1: diameter 0.457, hole 0.254, TOP to BOTTOM, 846 vias
v2: diameter 0.508, hole 0.254, TOP to BOTTOM, 4873 vias
v3: diameter 0.406, hole 0.203, TOP to BOTTOM, 57 vias
v4: diameter 0.61, hole 0.356, TOP to BOTTOM, 226 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1V0A_PG: length 133.8
  IN1 w0.114: v2(127.16,120.05) 126.8,119.69 123.86,119.69 123.78,119.77 121.47,119.77 120.74,119.04 107.57,119.04 106.55,120.06 83.83,120.06 80.79,123.1 77.6,123.1 76.94,123.75 74.4,123.75 73.27,124.89 71.08,124.89 70.45,125.51 63.48,125.51 63.4,125.42 58.28,125.42 57.69,124.84 52.52,124.84 52.1,124.41 49.11,124.41 45.46,120.76 41.91,120.76 39.47,118.32 33.28,118.32 29.86,114.91 27.35,114.91 19.69,107.25 19.65,107.25 v2(18.4,106)
  BOTTOM w0.102: v2(127.16,120.05) 127.59,120.48 127.59,121.92 127.83,122.16 128.28,122.16 PR9203.2 ; v2(18.4,106) 17.15,107.24 10.92,107.24 9.74,108.42 PR8110.2
1V8A_PG: length 3.5
  BOTTOM w0.112: v2(162.03,22.3) 162.68,22.3 163.33,21.65 PR8108.2
  BOTTOM w0.114: v2(162.03,22.3) 162.03,23.38 161.87,23.54 PU9300.13
2V5_PG: length 138.8
  TOP w0.102: v2(157.24,57.31) 158.36,58.43 158.91,58.43 159.41,58.93 PR8716.1
  IN1 w0.114: v2(157.24,57.31) 157.24,57.2 157.36,57.08 158.07,56.37 162.11,56.37 164.11,54.37 164.11,53.69 164.74,53.06 169.27,53.06 169.74,52.58 174.06,52.58 174.54,53.06 178.82,53.06 180.37,51.51 180.85,51.51 181.04,51.32 183.01,51.32 185.59,48.74 186.43,48.74 187.51,47.67 187.7,47.67 188.82,46.55 191.03,46.55 195.05,42.53 195.05,40.57 194.62,40.14 194.62,39.45 193.95,38.78 193.95,36.55 194.83,35.67 194.83,30.94 195.66,30.12 195.66,26.18 193.99,24.51 193.99,22.59 192.52,21.11 191.88,21.11 191.75,20.98 190.89,20.98 189.88,19.97 188.53,19.97 187.07,21.44 185.38,21.44 185.19,21.63 183.8,21.63 183.62,21.45 182,21.45 181.39,20.84 181.39,19.87 180.9,19.38 176.57,19.38 175.9,20.05 175.9,20.62 175.46,21.06 175.46,23.09 174.93,23.62 174.93,23.62 174.58,23.97 173.48,23.97 172.73,23.22 172.22,23.22 172.08,23.37 169.64,23.37 v2(169.1,23.91)
  BOTTOM w0.102: v2(169.1,23.91) 168.61,23.42 168.61,19.77 162.25,13.41 161.91,13.41 161.65,13.66 161.65,14.79 159.88,16.57 157.92,16.57 150.9,9.55 148.06,9.55 147.44,10.17 146.92,10.17 146.52,10.56 R3301.2 R3302.2 148.25,11.58 R3303.2
3V_5V_PG: length 216.9
  TOP w0.102: PR8123.2 40.74,78.28 39.86,77.4 38.72,77.4 v2(38.34,77.78) ; v2(177.93,19.8) 178.49,19.24 182.95,19.24 183.34,19.63 184.03,19.63 184.51,19.14 188.98,19.14 PR8627.1
  IN2 w0.114: v2(52.87,55.49) 52.37,55.99 50.52,55.99 48.6,54.06 48.6,48.85 48.87,48.58 48.87,47 45.24,43.37 45.24,39.43 49.73,34.93 51.26,34.93 51.74,34.45 59.67,34.45 60.41,33.71 61.18,33.71 61.86,33.03 65.65,33.03 66.66,34.04 67.24,34.04 69.36,36.16 84.16,36.16 85.02,37.02 107.47,37.02 108.04,36.45 115.16,36.45 116.24,35.38 119.56,35.38 122.02,32.92 126.2,32.92 127.86,31.27 129.34,31.27 130.02,30.58 130.02,30.31 132.12,28.22 133.53,28.22 134.28,27.47 134.28,25.14 135.2,24.21 135.33,24.21 136.05,23.49 137.67,23.49 139.25,21.91 140.66,21.91 143.78,18.79 148.91,18.79 149.45,18.25 156.51,18.25 156.84,18.58 167.01,18.58 168.05,19.62 170.28,19.62 170.56,19.34 177.05,19.34 177.25,19.14 177.51,19.14 177.93,19.55 v2(177.93,19.8)
  BOTTOM w0.102: PR8603.1 178.22,19.1 177.93,19.4 v2(177.93,19.8) ; v2(38.34,77.78) 38.72,77.4 39.86,77.4 40.39,77.93 42.35,77.93 49.54,70.75 49.54,63.01 50.1,62.45 50.1,60.95 50.54,60.51 50.54,59.45 51.89,58.1 51.89,56.69 52.87,55.7 v2(52.87,55.49)
+1.0V_STG: length 31.9
  IN1 w0.508: v2(121.06,106.1) 118.83,108.34 115.6,108.34 114.64,109.3 110.07,109.3 108.9,110.47 107.68,110.47 107.43,110.22 102.93,110.22 102.22,109.5 100.64,109.5 99.93,110.22 99.07,110.22 98.78,109.92 97.18,109.92 v2(96.81,110.29)
  BOTTOM w0.254: v2(96.81,110.29) 96.83,110.32 R403.2
  BOTTOM w0.508: 121.01,103.03 120.61,103.43 120.61,104.6 121.18,105.17 C639.2 121.06,105.5 v2(121.06,106.1) R622.1
+1.2V_VCCPLL_OC:
  vias: v2(126,68.73)
+1.2V_VCCPLL_OC_ON: length 16.6
  TOP w0.254: PQ9605.2 125.46,59.47 125.28,59.29 125.28,58.73 124.69,58.14 v2(124.07,58.14) 124.04,58.14 123.38,58.81 PR9611.2 123.21,58.28 122.84,57.92 112.71,57.92 112.08,58.54 PU9602.4
+1.2VSUS: length 252.7
  TOP w0.178: v2(208.43,106.66) 208.43,106.47 208.21,106.25 207.91,106.25 207.76,106.4 U5800.28 ; v2(203.55,107.54) 203.8,107.54 203.84,107.58 U5800.20 ; v2(208.57,112.81) 208.57,113.35 208.47,113.44 207.91,113.44 207.76,113.29 U5800.1
  TOP w0.381: R544.2 131.49,68.39 134.64,65.24 145.94,65.24 146.64,65.94 149.74,65.94 150.65,66.86 v2(151.77,66.86)
  TOP w0.508: v2(183.12,70.8) 182.38,70.8 181.64,70.06 181.64,65.13 177.34,60.83 177.34,59.83 176.69,59.17 176.69,57.86 169.48,50.65 164.57,50.65 164.34,50.88 v2(164.34,51.31)
  IN1 w0.381: v2(151.77,66.86) 156.4,62.23 156.4,56.85 158.51,54.74 159.85,54.74 161.54,53.06 163.9,53.06 164.34,52.62 v2(164.34,51.31)
  IN2 w0.508: v2(203.55,107.54) 203.2,107.54 202.59,106.93 202.59,105.31 205.18,102.72 206.09,102.72 207.28,101.53 210.27,101.53 210.7,101.1 210.7,99.09 213.76,96.04 v2(213.76,95.19)
  BOTTOM w0.102: 117.63,79.06 117.7,79.13 117.7,79.76 117.71,79.76 U400.AY36 ; v1(107.65,79) 107.64,79.01 U400.AD36 ; U400.Y36 v1(105.12,79.04) ; v1(112.95,78.49) 112.95,78.74 112.67,79.02 U400.AM36 ; 110.29,79.03 110.29,79.16 110.16,79.29 U400.AH36
  BOTTOM w0.191: 110.29,79.03 110.29,77.67 v1(110.57,77.38)
  BOTTOM w0.203: v1(122.97,79.02) 122.79,79.21 122.79,79.95 U400.BH36
  BOTTOM w0.254: v2(139.32,39.02) JDIM2801.54 ; v2(72.85,38.31) JDIM2800.96 ; JDIM2801.159 167.57,43.56 167.23,43.23 v2(166.8,43.23) ; v2(153.57,42.12) JDIM2801.111 ; v2(134.2,43.69) 134.07,43.83 JDIM2801.33 ; JDIM2801.178 172.32,38.69 v2(171.35,39.65) ; JDIM2801.129 158.07,44.3 157.79,44.02 157.79,41.71 158.56,40.95 158.56,40.71 v2(158.61,40.66) ; v1(101.38,82.92) 101.57,82.92 101.87,82.62 U400.R32 ; v2(149.82,39.02) JDIM2801.96 ; v2(112.02,42.37) 111.92,42.37 111.51,42.78 111.51,43.06 111.01,43.57 111.01,44.18 111.1,44.27 JDIM2800.241 ; v2(158.32,38.41) JDIM2801.130 ; JDIM2801.112 153.82,38.44 154.09,38.71 v2(155.88,38.71) 155.32,38.15 JDIM2801.118 ; v2(128.82,39.02) JDIM2801.12 ; v2(155.1,43.95) 155.1,44.19 155.07,44.23 JDIM2801.117 ; v1(113.33,82.95) 113.71,82.57 U400.AN32 ; JDIM2801.148 164.82,38.59 v2(164.37,39.04) ; JDIM2800.136 82.85,38.21 v2(82.96,38.31) ; v2(166.32,38.31) JDIM2801.154 ; JDIM2801.123 156.57,43.82 156.56,43.82 v2(156.56,43.49) ; v2(159.82,38.35) JDIM2801.136 ; 117.63,79.06 117.63,78.79 v1(117.72,78.7) ; v2(168.25,43.08) 168.44,43.08 168.74,43.38 168.74,44.12 168.57,44.3 JDIM2801.163 ; v2(164.04,43.3) 164.27,43.3 164.57,43.6 JDIM2801.147 ; v1(116.96,82.89) 117.28,82.57 U400.AW32 ; JDIM2801.220 182.82,39.91 182.56,40.16 v2(182.53,40.16) ; JDIM2801.153 166.07,44.23 166,44.17 166,43.41 165.67,43.09 v2(165.31,43.09) ; v2(159.89,43.8) 159.57,44.12 JDIM2801.135 159.57,46.35 160.28,47.07 161.07,46.29 JDIM2801.141 161.07,43.84 v2(160.89,43.67) ; JDIM2801.75 144.57,44.3 144.74,44.13 144.74,42.86 144.2,42.31 v2(143.77,42.31) ; v1(109.61,83.1) 110.07,82.64 U400.AH32 109.95,82.45 v1(109.62,82.45) ; v2(176.61,42.63) 177.57,43.58 JDIM2801.199 ; v2(156.51,38.76) 156.51,38.4 156.82,38.09 JDIM2801.124 ; v2(84.35,38.35) JDIM2800.142 ; JDIM2801.160 167.82,38.66 167.53,38.94 v2(167.34,38.94) ; JDIM2801.241 v2(188.07,43.87) ; v2(161.32,38.35) JDIM2801.142 ; v2(78.35,38.34) JDIM2800.118 ; v1(120.5,82.89) 120.83,82.57 U400.BE32 ; v2(62.35,39.2) JDIM2800.54
  BOTTOM w0.381: v2(164.34,51.31) 164.34,51.7 164.12,51.92 163.44,51.92 162.95,51.44 162.95,50.44 160.28,47.77 160.28,47.07
  BOTTOM w0.508: v2(213.76,95.19) 213.13,95.81 209.03,95.81 208.31,95.1 206.26,95.1 205.9,95.46 204.22,95.46 202.17,93.4 189.44,93.4 189.17,93.13 189.17,88.88 188.15,87.86 188.15,86.22 187.89,85.95 187.89,85.06 187.5,84.68 187.5,83.19 186.41,82.1 186.41,78.84 185.29,77.73 185.29,76.35 182.11,73.17 182.11,71.81 v2(183.12,70.8)
  vias: v2(51.84,39.2) v2(53.35,49.28) v2(53.35,48.16) v2(53.68,48.75) v2(53.98,49.31) v2(53.98,48.16) v2(54.31,48.72) v2(54.62,48.11) v2(54.69,49.26) v2(55,48.62) v2(55.41,49.1) v2(57.38,43.68) v2(66.83,42.42) v2(68.1,61.69) v2(68.21,61.03) v2(68.57,62.11) v2(68.69,61.45) v2(68.94,60.84) v2(69.12,62.64) v2(69.17,61.91) v2(69.38,61.3) v2(69.54,63.13) v2(69.69,62.38) v2(69.82,61.75) v2(70.11,62.86) v2(70.32,62.26) v2(70.57,63.3) v2(70.77,62.7) v2(71.1,63.79) v2(71.21,63.16) v2(76.46,42.36) v2(77.33,39.22) v2(78.16,42.96) v2(79.61,43.95) v2(79.59,39.02) v2(79.61,38.38) v2(81.53,38.58) v2(82.84,43.95) v2(83.95,43.92) v2(85.38,38.13) v2(87.03,39.04) v2(87.76,43.74) v2(88.72,43.24) v2(88.71,38.99) v2(90.61,39.02) v2(91.09,41.81) v2(91.97,43.5) v2(95.13,47.12) v2(95.11,39.3) v2(95.82,47.15) v2(95.82,46.51) v2(96.46,47.15) v2(96.45,46.51) v2(97.1,47.15) v2(97.09,46.51) v2(97.72,46.51) v2(99.7,41.56) v2(101.3,40.82) v2(106.03,38.33) v2(120.91,39.76) v2(144.51,32.95) v2(144.89,32.34) v2(145.14,32.95) v2(145.53,32.34) v2(145.78,32.95) v2(146.16,32.34) v2(146.54,32.95) v2(146.92,32.34) v2(147.3,32.95) v2(147.56,32.34) v2(147.94,32.95) v2(148.04,20.72) v2(148.19,32.34) v2(148.67,20.72) v2(149.31,20.86) v2(149.49,21.49) v2(165.63,39.03) v2(170.19,40.25)
+1.2VSUS_S: length 1
  BOTTOM w0.102: PR8725.2 v2(144.29,34.94)
+1.05V_DEEP_SUS: length 166
  TOP w0.254: v2(39.53,122.48) 39.53,122.34 39.3,122.11 R7716.1 ; CN7700.44 CN7700.43 30.26,120.15 v2(30.26,120.15)
  TOP w0.381: C460.2 128.62,94.15 v1(129.14,94.66) 129.64,94.16 C452.2 ; v1(127.29,92.2) 127.5,92.41 C456.2 ; C461.2 127.32,94.15 v1(127.87,94.7) ; C453.2 129.2,91.18 C446.2 129.27,92.43 129.63,92.43 v1(129.83,92.23) 130.02,92.43 C464.2 ; v1(131.76,93.91) 131.76,94.12 131.23,94.65 C455.2
  IN1 w0.254: v2(39.53,122.48) 38.29,121.24 31.35,121.24 v2(30.26,120.15)
  IN1 w0.381: v2(122.28,119.31) 121.65,119.31 121.01,118.67 107.3,118.67 106.64,119.33 92.01,119.33 91.6,118.93 v2(91.6,118.6) 90.5,119.7 83.68,119.7 80.64,122.74 77.27,122.74 76.63,123.37 74.22,123.37 73.1,124.5 70.96,124.5 70.3,125.15 63.63,125.15 63.55,125.06 58.45,125.06 57.86,124.47 52.67,124.47 52.25,124.05 49.35,124.05 v2(47.95,122.64)
  IN2 w0.381: v2(39.53,122.48) 39.69,122.64 v2(47.95,122.64)
  IN2 w0.508: v2(160.51,101.73) 160.51,100.55 159.71,99.75 156.83,99.75 156.57,99.49 154.9,99.49 154.53,99.13 154.53,99.03 153.77,98.27 151.82,98.27 151.62,98.47 151.11,98.47 150.92,98.28 149.33,98.28 v2(149.29,98.24)
  BOTTOM w0.127: 127.1,94.51 U400.BR14 127.11,94.07 ; 126.24,94.01 U400.BP14 ; U400.BP14 126.24,94.59 ; U400.BP14 125.94,94.3 ; U400.BT12 127.83,95.14 ; U400.BT12 127.54,95.49 ; U400.BT12 127.54,94.85 ; 126.89,89.81 U400.BR20 127.18,90.1 ; U400.BP20 126.24,89.81 ; U400.BP20 126.24,90.4 ; U400.BP20 125.94,90.1 ; 126.89,93.1 U400.BR15 127.2,93.46 ; 125.94,89.26 U400.BP22 126.24,89.56 ; U400.BT18 127.54,91.49 ; U400.BT18 127.87,91.78 ; U400.BT18 127.24,91.78 ; U400.BT19 127.87,90.94 ; U400.BT19 127.54,91.23 ; U400.BT19 127.24,90.94 ; U400.BT22 127.54,89.56 ; U400.BT22 127.24,89.26 ; U400.BT22 127.83,89.26 ; 126.89,95.5 U400.BR12 127.14,95.14
  BOTTOM w0.254: 142.76,106.33 143.16,105.93 143.16,105.09 R587.1 ; v2(91.6,118.6) 91.6,118.32 98.83,111.09 102.11,111.09 103.15,110.05 103.78,110.05 104.45,109.38 104.45,107.55 105.29,106.72 R604.2
  BOTTOM w0.381: R607.2 149.28,97.49 149.28,98.23 v2(149.29,98.24)
  BOTTOM w0.508: 158.23,106.81 158.56,106.81 160.59,104.78 160.59,101.81 v2(160.51,101.73) ; R608.1 128.5,112.95 127.68,112.95 v2(127.09,112.35)
  vias: v1(130.46,93.92) v2(125.43,93.78) v2(125.51,94.87) v2(125.46,91.75) v2(125.56,93.09) v2(137.17,106.35) v2(137.83,106.35) v2(138.46,106.35) v2(139.1,106.35) v2(139.73,106.35) v2(147.94,128.38) v2(148.57,128.38) v2(149.21,128.38) v2(149.84,128.38) v2(150.48,128.38) v2(151.13,128.38) v2(151.79,128.38) v2(152.43,128.38) v2(153.07,128.38) v2(153.72,128.38)
+1.05V_DEEP_SUS_S:
  vias: v2(145.3,127.34)
+1.05V_LAN_R: length 21.7
  TOP w0.203: v2(198.31,66.35) 198.14,66.51 U4000.3 ; U4000.22 192.29,66.51 192.21,66.6 C4012.1 ; C4010.1 195.69,63.82 195.69,64.32 195.59,64.42 195.59,64.42 195.53,64.47 U4000.30 ; C4007.1 197.95,69.55 197.47,69.07 197.47,68.71 197.27,68.51 U4000.8
  TOP w0.381: v2(195.18,64.06) 195.18,63.56 C4010.1 ; C4007.1 198.22,69.06 v2(197.93,68.76)
  TOP w0.508: C4009.1 C4012.1
  IN1 w0.508: v2(188.47,66.93) 190.22,66.93 193.19,63.96 195.08,63.96 v2(195.18,64.06)
  BOTTOM w0.381: 198.51,64.04 197.93,64.04 197.26,63.38 195.79,63.38 195.18,63.99 v2(195.18,64.06)
  vias: v2(197.76,67.88)
+1.05V_LAN_REGOUT:
  vias: v2(191.27,64.74) v2(191.48,65.32) v2(191.69,64.25) v2(192.12,63.79)
+1.8V: length 430.1
  TOP w0.203: v2(222.56,14.99) 222.56,14.98 222.56,14.15 222.34,13.93 U3600.29
  TOP w0.381: R529.1 149.18,92.21 v2(149.22,92.17) ; R520.2 149.28,91.22 v2(149.43,91.06) 149.79,91.06 149.82,91.09 R519.2 ; v2(150.76,84.87) 150.76,84.89 150.38,85.27 149.59,85.27 149.24,85.62 v2(148.24,85.62)
  TOP w0.508: v2(195.07,14.68) 195.07,13.46 193.88,12.27 191.5,12.27 189.72,10.49 189.72,8.71 v2(190.33,8.11)
  TOP w0.762: 195.87,37.21 195.05,36.39 193.01,36.39 192.8,36.61 181.19,36.61 180.11,35.53 180.11,35.32 179.72,34.93 178.88,34.93 177.94,35.87 170.69,35.87 169.9,36.66 168.36,36.66 168.31,36.71 164.2,36.71 163.67,36.17 161.4,36.17 159.55,34.32 PR9512.2
  IN1 w0.254: v2(22.06,111.33) 22.06,113.12 24.74,115.8 25.74,115.8 29,119.06 39.25,119.06 40.03,119.85 40.03,121.57 40.96,122.5 42.97,122.5 v2(43.57,121.9) ; 162.67,91.12 162.67,93.06 163.93,94.32 165.37,94.32 165.83,93.86 167.22,93.86 v2(167.81,94.46) ; v2(154.75,124.41) 153.5,125.66 146.44,125.66 144.69,123.91 135.47,123.91 134.15,125.23 128.1,125.23 126.5,123.63 120.37,123.63 119.12,124.87 116.98,124.87 115.4,123.3 114.23,123.3 112.53,121.6 108.06,121.6 107.4,122.26 84.57,122.26 81.84,124.99 79.34,124.99 77.57,126.76 76.44,126.76 75.95,127.26 v2(75.14,127.26)
  IN1 w0.508: v2(193.98,18.07) 194.32,18.07 195.84,19.59 195.84,19.89 197.47,21.52 197.47,22.28 198.8,23.61 198.8,29.99 199.09,30.28 199.09,37.04 198.6,37.53 ; v2(222.56,14.99) 221.65,14.08 217.73,14.08 216.58,15.23 216.58,18.3 215.73,19.16 210.65,19.16 209.87,19.94 209.03,19.94 208.66,19.57 208.66,18.45 205.18,14.97 204.74,14.97 200.8,11.02 200.8,9.19 200.92,9.07 200.92,8.32 200.13,7.53 198.81,7.53 198.36,7.98 v2(197.34,7.98)
  IN1 w0.762: 177.83,69.27 177.83,70.03 178.34,70.54 179.18,70.54 179.56,70.16 180.2,70.16 180.71,70.67 180.71,73.41 181.41,74.12 181.41,78.37 179.86,79.93 179.86,82.79 179.55,83.1 176.58,83.1 175.19,84.49 175.19,85.37 ; 198.4,38.62 198.39,38.63 198.39,45.12 196.78,46.73 196.78,47.34 196.43,47.7 195.99,47.7 195.21,48.48 194.23,48.48 192.85,49.87 190.21,49.87 189.35,50.73 189.35,50.73 187.95,52.13 187.17,52.13 186.57,52.74 181.14,58.17 181.14,59.76 178.06,62.84 178.06,63.63
  IN2 w0.508: v2(222.61,20.07) 221.67,20.07 220.99,19.39 220.99,17.4 219.54,15.96 219.54,14.53 220.02,14.05 221.62,14.05 v2(222.56,14.99)
  BOTTOM w0.203: v2(150.76,84.87) 150.76,84.31 149.51,83.06 149.51,76.61 150.35,75.77 150.35,75.24 150.12,75.01 149.67,75.01 148.8,75.88 148.8,81.72 147.82,82.7 R508.2 ; v2(143.92,89.83) 143.92,89.82 R532.2
  BOTTOM w0.254: v2(154.75,124.41) 154.75,120.99 155.28,120.45 155.28,118.4 155.66,118.02 155.66,117.25 155.43,117.02 155.43,115.85 162.03,109.25 162.03,108.37 163.54,106.87 164.47,106.87 166.78,104.55 166.78,102.34 168.83,100.3 168.83,98.55 167.86,97.59 167.86,95.67 167.81,95.62 v2(167.81,94.46) ; v2(75.14,127.26) 74.42,127.26 73.57,128.12 73.57,128.38 72.31,129.63 57.67,129.63 56.43,128.39 56.43,126.6 54.55,124.72 49.26,124.72 46.44,121.9 v2(43.57,121.9) ; v2(22.06,111.33) 21.67,111.72 18.62,111.72 18.4,111.94 15.94,111.94 15.18,112.71 PR8104.2
  BOTTOM w0.381: R517.1 149.61,91.24 v2(149.43,91.06) 149.23,90.86 R512.1 ; v2(141.49,90.9) 141.53,90.86 R515.1 ; v2(148.24,85.62) 148.03,85.41 R504.2 R506.2 146.94,85.11 R510.2
  BOTTOM w0.508: v2(193.98,18.07) 193.98,16.47 194.66,15.79 194.66,15.1 v2(195.07,14.68) ; v2(190.33,8.11) 190.84,7.6 195.95,7.6 196.34,7.98 v2(197.34,7.98)
  vias: v2(152.71,90.25) v2(197.94,38) v2(197.92,37.15)
+1.8V_DEEP_SUS: length 187.3
  TOP w0.102: v2(146.64,89.65) 147.22,89.07 R497.1
  TOP w0.203: R500.2 153.35,89.92 153.45,89.82 v2(153.45,89.39)
  TOP w0.381: C459.2 132.37,94.46 132.37,93.91 v1(132.34,93.88) ; R4143.2 167.54,89.54 166.45,88.45 v2(166.45,87.2) ; C432.2 132.66,92.5 v1(132.39,92.23) 132.12,92.5 C440.2 ; v1(133.36,91.67) 132.86,91.17 C457.2 ; v2(170.34,89.3) 170.34,90.01 171.01,90.68 R4144.1 ; v2(212.56,48.71) R4721.1
  TOP w0.508: R4719.1 196.98,40.1 196.73,39.85 196.53,39.85 195.81,39.14 195.27,39.14 194.68,39.72 v2(193.96,39.72)
  IN1 w0.381: 158.43,86.48 158.84,86.89 160.85,86.89 161.27,87.31 161.27,87.98 161.63,88.34 162.71,88.34 162.89,88.52 ; v2(166.45,87.2) 166.45,88.5 166.95,89 167.78,89 168.05,88.73 169.97,88.73 170.34,89.09 v2(170.34,89.3)
  IN1 w0.508: v2(193.96,39.72) 193.51,39.72 192.78,39 192.78,38.26 192.22,37.7 190.66,37.7 ; v2(195.11,10.24) 195.11,10.71 196.49,12.1 197.71,12.1 199.39,13.77 199.39,15.81 204.21,20.63 205.34,20.63 206.23,21.52 206.23,22.79 204.59,24.44 204.59,32.44 208.99,36.85 208.99,40.5 210.93,42.43 v2(210.93,44.67) ; v2(151.09,33.2) 151.06,33.18 151.06,27.89 153.04,25.91 153.04,25.23 154.67,23.6 156.19,23.6 156.7,23.09 156.7,20.78 157.8,19.69 v2(162.39,19.69) ; v2(172.59,20.05) 172.33,19.79 172.33,16.98 v2(172.54,16.77)
  IN1 w1.27: 179.94,49.56 160.2,49.56 158.15,51.62 154.59,51.62 153.75,52.46 153.75,55.5 151.92,57.34
  IN2 w0.508: v2(162.39,19.69) 162.56,19.86 166.95,19.86 167.37,20.28 172.37,20.28 v2(172.59,20.05) ; v2(142.1,72.01) 142.1,72.01 141.65,72.46 v2(141.65,72.46) 141.65,72.48 140.99,73.14 138.12,73.14 v2(137.71,73.55)
  BOTTOM w0.178: v2(139.53,88.17) 139.33,88.37 138.44,88.37 U400.CP23
  BOTTOM w0.203: v2(139.3,92) 139.16,92.15 U400.CP17
  BOTTOM w0.254: v2(136.41,73.64) 136.41,73.82 136.66,74.07 R494.2 ; v2(137.71,73.55) 137.71,73.55 137.71,74.15 R574.2
  BOTTOM w0.381: v2(210.93,44.67) 211.98,45.73 211.98,48.13 v2(212.56,48.71)
  BOTTOM w0.508: v2(195.11,10.24) 193.07,8.21 191.12,8.21 190.57,8.76 187.47,8.76 183.83,12.4 177.5,12.4 177.25,12.66 177.25,14.05 176.26,15.04 175.44,15.04 174.76,15.72 174.76,15.74 174.44,16.05 174.44,17.02 174.09,17.38 172.91,17.38 172.54,17.01 v2(172.54,16.77) ; v2(162.39,19.69) 162.34,19.63 PR8105.1
  vias: v2(150.35,33.25) v2(150.88,33.81) v2(157.84,85.94) v2(158.3,85.5)
+1.8VPCU: length 3.7
  IN1 w0.508: v2(155.84,29.42) 154.85,30.41 153.68,30.41 v2(152.9,29.62)
  vias: v2(152.31,29.18)
+2.5VSUS: length 77.9
  TOP w0.508: C2824.1 116.87,43.58 C2825.1 115.42,43.58 v2(115.38,43.62)
  IN1 w0.508: v2(124.04,43.34) 123.55,42.86 123.33,42.86 121.98,41.51 118.96,41.51 116.89,43.58 115.42,43.58 v2(115.38,43.62) ; v2(164.26,41.17) v2(161.75,41.17)
  BOTTOM w0.203: 192.07,43.5 192.44,43.87 192.44,44.15 192.57,44.28 JDIM2801.259 ; 192.07,43.5 v2(192.03,43.46) ; 192.07,43.5 JDIM2801.257
  BOTTOM w0.254: JDIM2800.257 115.1,43.87 115.36,43.62 v2(115.38,43.62) 115.38,43.75 115.6,43.98 JDIM2800.259
  BOTTOM w0.508: v2(161.75,41.17) 160.54,39.96 153.96,39.96 153.48,40.44 127.87,40.44 125.46,42.86 124.52,42.86 v2(124.04,43.34)
  BOTTOM w1.016: v2(164.26,41.17) 163.14,42.29 163.14,47.15 163.66,47.66 166.51,47.66 167.19,48.34 167.19,51.22 165.15,53.26
  vias: v2(163.76,61.75) v2(164.45,61.73) v2(165.17,54.21) v2(165.81,54.2) v2(191.58,42.9)
+2.5VSUS_S:
  vias: v2(167.98,61.84)
+3.3V_8270C: length 1.5
  BOTTOM w0.203: PC8638.1 192.27,19.52 PU8601.10
+3V: length 842.7
  TOP w0.102: Q4101.2 171.64,85.48
  TOP w0.178: C3508.1 214.47,94.71 213.88,94.11 ; 213.88,94.11 213.88,93.61 213.37,93.1 U3501.30 ; 213.88,94.11 213.75,94.24 R3512.1 ; 211.62,87.3 211.62,87.49 211.76,87.62 U3501.11
  TOP w0.203: R594.2 140.98,69.19 v2(140.26,68.47) ; R5408.1 165.38,98.63 164.95,99.06 R5407.1 165.23,99.57 v2(165.49,99.57) ; 215.21,9.71 215.41,9.71 215.64,9.94 215.64,11.12 216.05,11.53 U3600.8
  TOP w0.254: R3613.1 216.24,7.57 214.94,6.27 212.68,6.27 212.12,5.72 209.61,5.72 209.02,6.31 207.91,6.31 207.81,6.41 205.45,6.41 204.13,7.73 ; R416.2 R463.2 135.19,68.76 134.99,68.56 v2(134.76,68.56) ; v2(179.1,35.75) 178.37,36.48 171.56,36.48 171.15,36.89 R2825.1 ; 35.19,126.24 35.19,126.8 34.44,127.55 34.44,128.99 34.24,129.2 R3412.1 ; v2(210.52,9.34) 210.56,9.38 211.74,9.38 212.88,8.24 C3624.2 R3610.2 214.62,8.91 214.62,9.13 215.21,9.71 ; v2(62.52,24.9) 62.52,26.17 62.7,26.35 Q5402.2 ; v2(155.6,98.35) 155.63,98.31 156.05,98.31 R560.1 156.09,98.99 155.11,99.98 R558.1 ; v2(47.9,65.21) 47.9,65.78 R5402.1 ; v2(110.58,49.93) 117.36,49.93 118.29,49.01 143.3,49.01 144,49.71 154.82,49.71 156.5,51.39 v2(160.31,51.39) ; v2(167.62,98.42) 167.62,99.18 C5404.1 168.06,99.62 168.06,100.27 167.91,100.43 U5400.1 ; v2(166.78,95.71) 166.76,95.74 R450.1 166.18,95.72 R447.1 165.94,95.2 165.64,94.9 Q401.5 ; R4722.1 R4720.1 216.44,47.07 216.44,46.11 215.22,44.89 212.21,44.89 211.47,44.15 210.32,44.15 210.16,44.31 R4756.1 209.13,44.31 208.5,43.68 206.69,43.68 206.11,43.1 202.35,43.1 199.31,40.06 v2(199.18,40.06) 198.17,39.05 196.85,39.05 194.8,37 193.26,37 192.92,37.34 192.92,37.89 193.19,38.16 193.19,39.98 192.65,40.52 192.65,41.7 192.16,42.19 190.99,42.19 R2824.1 ; v2(212.54,94.72) 212.4,94.58 R3513.1 ; R597.2 154.92,79.05 v2(155.02,78.95) ; R595.2 154.27,80.14 154.76,80.14 v2(154.82,80.08) 154.91,80.16 R593.2 ; v2(129.07,65.79) 129.07,66.44 128.61,66.9 127.5,66.9 127.15,67.25 U401.5 ; v2(195.9,46.94) 195.97,47.01 196.85,47.01 R4718.1 ; R4717.1 196.46,48.29 v2(196.3,48.44) ; R7719.2 30.79,107.35 v2(30.79,107.24) ; R489.2 153.85,96.98 154.06,96.78 154.64,96.78 154.87,96.55 R488.2 155.05,96.42 155.43,96.04 v2(155.46,96.04)
  TOP w0.305: v2(65.93,26.04) 65.63,26.35 Q5402.5
  TOP w0.381: R4305.2 204.24,18.85 204.24,15.46 204.3,15.39 204.3,15.31 C5205.1 ; 211.95,85.93 211.95,86.72 211.62,87.05 211.62,87.3 ; R3507.2 212.61,83.04 212.76,82.89 213.49,82.89 214.01,82.37 R3504.2 ; v2(139.43,103.82) 139.43,103.95 139.89,104.4 140.11,104.4 140.39,104.4 141.54,105.54 141.54,106.91 141.54,108.64 143.84,110.94 143.84,112.9 144.23,113.28 147.74,113.28 157.13,103.89 162.19,103.89 v2(162.72,104.42) ; R3415.1 23.54,120.25 v2(23.73,120.06) ; R5108.1 170.04,65.26 170.29,65 171.36,65 v2(171.42,65.07) ; v2(143.39,94.34) 143.81,94.34 v2(144.5,95.03) ; R5405.2 171.04,100.36 v2(171.4,100.01) ; R415.2 133.23,68.55 134.28,67.5 v2(134.79,67.5) ; Q401.2 163.13,94.9 162.49,95.53 v2(162.49,95.69)
  TOP w0.508: R7637.2 v2(29.62,23.12) ; 93.89,36.91 94.62,37.65 110.75,37.65 112.25,39.15 112.25,39.93 ; v2(170.52,84.51) 171.48,85.48 171.64,85.48 ; R5013.1 R5012.1 45.49,57.61 v2(45.73,57.85) ; v2(175.88,89.11) 175.88,89.85 176.03,90 177.05,90 177.44,90.39 v2(179.62,90.39) ; v2(56.18,61.03) 54.16,63.05 52.53,63.05 51.98,63.61 49.5,63.61 v2(47.9,65.21) ; v2(179.73,71.68) 181.27,71.68 181.49,71.46 183.78,71.46 184.6,70.63 184.6,68.77 R4001.1 ; v2(41.38,92.08) PR8816.1 ; C2844.1 191,44.97 C2842.1 191.01,44.48 v2(191.57,43.93) 191.57,43.89 190.33,42.65 190.33,42.4 ; v2(178.6,69.74) 177.8,69.74 175.97,67.91 175.97,66.69 174.43,65.15 173.93,64.65 173.93,63.59 173.44,63.1 172.39,63.1 172.19,63.3 v2(171.43,63.3) 170.52,63.3 170.44,63.22 169.8,63.22 169.37,62.79 167.86,62.79 167.47,63.18 160.85,63.18 157.42,59.75 155.29,59.75 155.04,59.5 v2(155.04,59.14)
  IN1 w0.254: v2(112.02,41.69) 112.33,41.69 112.66,42.02 112.66,44.18 110.58,46.25 v2(110.58,49.93)
  IN1 w0.381: v2(171.43,63.3) 171.43,65.05 v2(171.42,65.07)
  IN1 w0.508: v2(155.04,59.14) 155.04,61.61 151.21,65.44 v2(151.21,65.61) 150.66,66.17 150.49,66.17 v2(149.79,66.87) 150.78,67.86 150.78,68.42 149.36,69.85 147.96,69.85 147.63,70.19 147.63,72.21 150.25,74.83 150.25,75.21 v2(149.89,75.57) 150.25,75.93 150.25,76.54 150.78,77.06 v2(153.25,77.06) ; v2(165.49,99.57) 166.05,100.14 169.43,100.14 169.95,100.67 171.2,100.67 ; v2(62.47,126.43) 57.91,126.43 57.2,125.72 52.16,125.72 51.73,125.3 48.47,125.3 47.03,123.86 46.75,123.86 46.11,123.22 40.34,123.22 39.93,123.63 v2(36.52,123.63) ; v2(189.49,41.5) 188.81,41.5 188.22,40.91 186.61,40.91 186.19,40.49 186.19,38.71 185.81,38.33 185.02,38.33 183.01,36.31 181.86,36.31 181.47,35.93 v2(181.47,35.49) ; v2(23.73,120.06) 23.73,119.25 20.36,115.88 19.01,115.88 17.81,114.68 v2(17.81,114.05) ; v2(170.52,84.51) 169.58,83.57 168.56,83.57 167.75,82.76 167.75,80.66 167.1,80.01 167.1,79.46 166.38,78.75 162.11,78.75 161.81,78.44 157.59,78.44 157.01,79.02 v2(156.62,79.02) 156.55,78.95 v2(155.02,78.95)
  IN1 w0.762: v2(190.34,92.64) 190.34,93.98 188.07,96.25 186.67,96.25 182.86,100.06 176.95,100.06
  IN2 w0.254: v2(199.18,40.06) 198.02,41.22 198.02,43.32 197.55,43.79 197.55,46 196.61,46.94 v2(195.9,46.94) 195.9,46.94 195.87,46.97 195.87,48.01 v2(196.3,48.44)
  IN2 w0.508: v2(191.57,43.93) 191.57,44.21 190.2,45.58 190.2,47.57 187.55,50.22 184.89,50.22 178.8,56.31 178.8,58.93 174.91,62.82 171.92,62.82 v2(171.43,63.3) ; v2(47.9,65.21) 47.9,60.57 45.73,58.4 v2(45.73,57.85) ; v2(27.43,100.56) 21.4,106.6 21.4,107.17 18.53,110.04 18.53,113.34 v2(17.81,114.05) ; v2(212.54,94.72) 212.84,94.42 216.8,94.42 v2(217.13,94.75) ; v2(48.14,39.55) 47.1,39.55 46.65,40 46.65,42.89 50.38,46.61 50.38,53.5 50.65,53.77 53.31,53.77 54.58,55.04 54.58,56.01 54.23,56.37 54.23,59.07 v2(56.18,61.03) 56.95,61.8 56.95,62.75 59.04,64.84 59.04,65.26 64.57,70.79 65.13,70.79 66.45,72.12 v2(66.45,72.9)
  BOTTOM w0.203: v2(143.39,94.34) 143.14,94.34 143.07,94.42 R479.2 ; 147.05,88.75 147.02,88.73 R533.1 ; 147.05,88.75 142.86,88.75 R485.2 ; 147.05,88.75 148.69,88.75 149.77,87.67 149.77,86.89 150.38,86.28 150.38,85.34 150.15,85.11 150.15,84.67 149.21,83.72 149.21,76.26 v2(149.89,75.57)
  BOTTOM w0.254: R568.1 145.57,96.09 v2(146.11,96.09) R541.2 ; JDIM2801.255 v2(191.57,43.93) ; JDIM2800.255 114.6,43.29 114.89,43 114.89,42.14 114.44,41.69 v2(112.02,41.69) ; v2(179.1,35.75) 181.21,35.75 v2(181.47,35.49) ; R486.1 143.26,95.65 144.04,95.65 144.5,95.19 v2(144.5,95.03) ; v2(136.95,68.55) 137.7,69.3 137.7,71.59 R493.2 R492.2
  BOTTOM w0.381: v2(212.03,85.31) 211.26,86.09 R3506.2 ; v2(60.53,31.12) 60.33,30.92 R9647.1 R6213.1 ; R526.2 R528.2 139.1,105.69 139.41,105.39 139.41,103.84 v2(139.43,103.82) ; R7713.2 156.23,78.58 156.62,78.97 v2(156.62,79.02) ; v2(162.72,104.42) 162.29,103.99 162.29,101.12 v2(161.38,100.21) ; v2(46.82,23.37) 45.91,22.46 30.29,22.46 v2(29.62,23.12) ; R555.2 150.92,94.16 v2(150.97,94.12) ; R554.1 148.29,94.31 148.08,94.52 v2(147.67,94.52) 147.38,94.52 R487.2 ; C7604.1 45.84,28.06 45.3,27.51 v2(45.3,27.18)
  BOTTOM w0.508: PR8102.2 14.67,115.03 13.89,115.81 PR8100.2 PR8119.2 12.92,116.02 13.52,116.62 15,116.62 17.56,114.05 v2(17.81,114.05) ; v2(154.82,80.08) 154.82,79.66 154.8,79.63 154.8,79.18 v2(155.02,78.95) 155.02,78.52 154.54,78.03 R7714.2 154.17,77.79 153.44,77.06 v2(153.25,77.06) ; v2(171.4,100.01) 173.14,100.01 179.87,93.28 179.87,91.5 179.62,91.26 v2(179.62,90.39) ; v2(178.6,69.74) 179.27,70.41 179.27,71.27 179.68,71.68 v2(179.73,71.68) ; 140.93,67.88 141.64,67.17 144.7,67.17 145.01,66.87 v2(149.79,66.87) ; v2(129.07,65.79) 128.96,65.69 128.96,65.01 133.74,60.23 136.33,60.23 137.33,59.24 154.94,59.24 v2(155.04,59.14) ; v2(134.79,67.5) 135.12,67.5 137.16,65.46 144.02,65.46 144.3,65.18 150.78,65.18 v2(151.21,65.61) ; v2(66.66,34.47) 66.65,34.47 65.33,35.8 49.08,35.8 48.51,36.37 48.51,39.18 v2(48.14,39.55) ; v2(170.52,84.51) 170.52,85.2 172.12,86.8 172.12,87.61 172.18,87.67 172.18,88.35 172.53,88.71 174.64,88.71 175.04,89.1 175.87,89.1 v2(175.88,89.11)
  BOTTOM w0.762: 211.51,95.03 210.7,94.21 207.37,94.21 206.52,93.36 203.61,93.36 201.87,91.62 191.35,91.62 v2(190.34,92.64)
  BOTTOM w2.54: 148.17,48.57 124.21,48.57 122.52,50.26 122.52,56.06 120.25,58.32 110.98,58.32 105.72,63.58 87.36,63.58 78.27,72.68 78.27,81.18
  vias: v2(34.37,122.81) v2(34.48,123.75) v2(34.93,123.17) v2(34.94,122.52) v2(35.09,121.8) v2(35.21,123.73) v2(35.87,123.65) v2(44.71,33.61) v2(45.19,92.29) v2(45.32,33.43) v2(45.3,26.54) v2(45.59,91.79) v2(45.98,92.29) v2(46.4,91.81) v2(46.82,92.29) v2(48.32,79.35) v2(48.95,79.35) v2(49.59,79.35) v2(50.22,79.35) v2(50.86,79.35) v2(56.12,24.31) v2(59.88,25.16) v2(60.38,25.55) v2(76.34,82.17) v2(76.79,82.62) v2(77.24,83.07) v2(77.72,83.54) v2(78.17,84) v2(156.6,96.31) v2(160.15,52) v2(160.38,99.04) v2(160.59,6.5) v2(160.94,51.34) v2(161.04,99.04) v2(161.23,6.5) v2(161.58,51.31) v2(161.86,6.5) v2(162.23,51.36) v2(162.5,6.5) v2(163.13,6.5) v2(163.77,6.5) v2(164.4,6.5) v2(165.04,6.5) v2(169.78,22.41) v2(169.81,21.77) v2(170.42,22.41) v2(170.44,21.77) v2(171.05,22.41) v2(171.08,21.77) v2(171.69,22.38) v2(171.72,21.72) v2(180.7,33.05) v2(180.7,32.42) v2(180.68,31.78) v2(180.68,31.12) v2(181.31,32.75) v2(181.28,32.11) v2(181.34,31.48) v2(181.36,33.38) v2(203.34,11.44) v2(203.79,11) v2(203.94,11.61) v2(204.22,10.44) v2(204.45,11.16) v2(204.48,9.86) v2(204.83,10.62) v2(205.08,10.05) v2(211.97,83.93) v2(215.01,17.28) v2(215.02,16.65)
+3V_+1.8V_CR: length 15.8
  IN1 w0.508: v2(41.71,27.77) 44.05,27.77 44.48,28.2 45.31,28.2 46.08,27.43 v2(46.08,27.36)
  IN2 w0.508: v2(46.34,32.31) 46.52,32.14 46.52,27.92 46.08,27.49 v2(46.08,27.36) 46.08,26.78 v2(46.13,26.73)
  IN2 w0.762: v2(41.71,27.77) 41.26,28.22 41.26,31.81 40.71,32.35
  vias: v2(39.63,33.13) v2(40.11,32.67)
+3V_ALW: length 423.7
  TOP w0.254: v2(29.7,84.64) 31.1,86.04 41.26,86.04 41.77,85.53 41.77,82.61 41.53,82.37 PU8102.5
  TOP w0.381: v2(162.4,86.69) 162.42,86.68 R4146.2
  TOP w0.508: 45.31,63.04 R7505.1 ; 45.31,63.04 46.21,63.94 48.24,63.94 49.18,63 51.72,63 52.28,62.44 53.88,62.44 55.28,61.04 55.28,60.94 ; 45.31,63.04 43.47,64.88 v2(38.27,64.88) ; 79.48,35.18 82.53,35.18 83.19,35.84 85.38,35.84 v2(85.71,35.51) 85.71,34.48 85.45,34.22 85.45,31.43 85.71,31.17 86.6,31.17 87.61,30.16 ; 79.48,35.18 79.74,34.93 79.74,31.68 80.12,31.3 81.01,31.3 PD8501.1 ; 79.48,35.18 54.72,35.18 54.29,35.62 50.19,35.62 46.13,39.67 46.13,42.6 51.95,48.42 51.95,48.44 52,48.49 v2(52,48.54) ; R598.1 61.52,64.59 v2(61.45,64.52)
  IN1 w0.254: v2(28.94,81.46) 29.7,82.23 v2(29.7,84.64)
  IN1 w0.381: 195.35,46.89 194.71,47.54 194.45,47.8 193.95,47.8 192.59,49.16 189.95,49.16 188.66,50.45 187.74,51.37 186.97,51.37 179.6,58.73 179.5,58.73 175.52,62.71 175.52,65.51 176.94,66.94 176.94,70.15 177.15,70.35 177.18,70.35 179.19,72.36 179.19,74.3 179.46,74.57 179.46,76.21 179.92,76.68 179.92,77.84 179.19,78.58 179.19,79.03 178.27,79.95 178.27,82.18 178.04,82.41 175.48,82.41 174.25,83.64 174.25,85.46 173.71,86 172.69,86 172.14,86.55 172.14,87.55 171.85,87.85 169.64,87.85 168.11,86.33 167.34,86.33 167.11,86.55 165.83,86.55 164.91,87.47 164.91,87.72 164.57,88.06 163.78,88.06 v2(162.4,86.69) ; 196.98,45.03 197.47,44.54 197.47,40.96 197.69,40.73 197.69,38.58 197.07,37.96 197.07,37.11 198.53,35.65 198.53,30.69 198.24,30.4 198.24,24.05 196.2,22 196.2,21.65 195.05,20.5 195.05,19.61 194.07,18.63 193.44,18.63 192.7,17.89 185.98,17.89 184.86,19.01 v2(183.64,19.01)
  IN1 w0.508: v2(85.71,35.51) 85.71,35.82 86.15,36.26 92.44,36.26 92.63,36.45 111.59,36.45 112.29,37.15 118.11,37.15 121.91,33.35 128.55,33.35 129.05,33.85 135.53,33.85 139.59,29.79 139.59,25.74 141.39,23.95 141.39,20.4 143.08,18.71 147.44,18.71 147.75,18.41 152.55,18.41 153.35,19.21 v2(154.36,19.21)
  IN2 w0.381: 177.66,23.66 177.66,21.77 179.18,20.25 v2(179.3,19.84)
  IN2 w0.508: v2(38.27,64.88) 37.79,65.37 37.79,71.95 35.86,73.87 34.11,73.87 30.95,77.04 30.95,78.78 28.94,80.8 v2(28.94,81.46) 28.94,82.79 19.13,92.6 19.13,96.88 v2(13.96,102.06) ; v2(154.36,19.21) 156.42,21.27 156.83,21.27 158.86,23.3 161.91,23.3 162.9,24.29 v2(165.18,24.29) 165.58,24.29 167.27,22.6 167.27,22.09 168.44,20.91 171.78,20.91 173.69,22.81 174.91,22.81 175.95,23.86 177.46,23.86 ; v2(52,48.54) 52.31,48.54 52.69,48.92 52.69,49.59 53.2,50.09 54.47,50.09 57.01,52.63 57.01,54.29 56.24,55.05 56.24,56.37 v2(55.89,56.72) 56.24,57.08 56.24,58.35 61.45,63.55 v2(61.45,64.52)
  BOTTOM w0.381: v2(179.3,19.84) 179.38,19.84 180.21,19.01 v2(183.64,19.01) ; v2(13.96,102.06) 10.97,105.05 8.92,105.05 6.47,107.5 6.47,108.53 4.92,110.08 PR8107.1
  BOTTOM w0.508: v2(154.36,19.21) 154.49,19.08 PR8718.2 ; v2(165.18,24.29) 164.83,24.64 PR9300.1
  vias: v2(178,24.69)
+3V_CAM: length 1.8
  BOTTOM w0.254: v2(25.93,130.84) 26.15,131.06 v2(26.15,131.46) 26.15,131.46 CN3400.35
  vias: v2(43.04,130.87) v2(43.42,130.36)
+3V_DEEP_SUS: length 786.9
  TOP w0.203: v2(155.23,92.51) 155.14,92.42 R659.1 153.17,92.88 C462.2 152.03,92.88 R443.1 151.3,93.16 151.14,92.99 R424.1 ; R431.2 150.53,87.16 v2(150.4,87.03) ; R4729.1 212.65,59.11 v2(212.33,58.79) ; R421.1 160.51,94.77 v2(160.92,94.77) 161.02,94.87 R422.1
  TOP w0.254: v2(198.91,81.79) 198.28,81.17 198.28,80.83 197.85,80.4 C4222.1 197.2,80.1 196.83,79.74 U4201.5 ; v2(155.41,87.74) 155.38,87.76 R423.2 ; v2(139.71,70.69) 139.6,70.58 138.74,70.58 138.44,70.87 R496.2 ; R426.2 151.17,86.01 v2(151.49,85.69) 151.53,85.65 R473.2 ; v2(79.77,126.2) 79.67,126.2 78.71,125.23 R625.2 R626.2 ; v2(142.57,69.08) 142.57,69.54 142.81,69.78 R490.2
  TOP w0.305: R7728.1 26.34,122.11 26.02,121.79 26.02,120.59 20.9,115.47 20.9,113 19.31,111.42 19.31,105.47 v2(19.52,105.26) ; v2(189.16,57.92) 188.73,57.49 Q4700.5 Q4700.2 ; v2(151.37,97.85) 151.54,98.02 R477.2
  TOP w0.381: v1(131.15,92.23) 131.2,92.19 C434.2 C442.2 ; v2(204.63,69.68) 203.44,68.48 v2(203.44,66.22) ; R420.1 161.39,96.98 v2(161.39,96.62) 161.39,96.45 R419.1 ; L402.1 127.79,107.42 C477.1 C475.1 127.79,110.89 127.24,111.44 126.48,111.44 v2(125.59,112.32) ; v2(151.37,97.85) R478.1
  TOP w0.508: v2(148.19,68) 148.19,68.77 R660.2 ; v2(129.17,57.46) 128.74,57.03 110.31,57.03 108.9,58.44 65.43,58.44 63.23,60.64 63.23,63.42 63.88,64.07 63.88,65.37 62.75,66.5 62.25,66.5 61.71,67.04 v2(52.54,67.04) ; v2(50.66,73.7) 54,70.36 68.94,70.36 71.44,72.86 v2(71.74,72.86) R548.1 73.21,72.86 R549.1 ; v2(149.59,68.21) 153.19,68.21 153.84,67.56 155.04,67.56 155.7,66.9 159.26,66.9 160.15,67.79 162.42,67.79 162.65,67.56 R5600.2
  IN1 w0.381: 157.97,95.05 157.84,95.18 157.84,96.58 157.3,97.12 155.16,97.12 154.68,97.59 152.85,97.59 152.6,97.85 v2(151.37,97.85)
  IN1 w0.508: v2(19.52,105.26) 20.33,104.45 v2(20.56,104.45) 23.63,107.53 23.63,109.9 25.98,112.24 39.19,112.24 43.54,116.59 44.12,116.59 50.05,122.52 52.91,122.52 53.36,122.96 59.04,122.96 59.63,123.55 64.17,123.55 64.26,123.64 69.67,123.64 70.35,122.96 71.24,122.96 71.62,122.59 72.24,122.59 ; v2(125.59,112.32) 125.21,111.94 123.17,111.94 122.79,111.56 121.52,111.56 120.83,110.87 v2(120.76,110.87) 120.11,111.52 115.64,111.52 113.93,113.24 102.31,113.24 102.07,113 90.4,113 89.6,113.8 89.6,117.68 88.87,118.41 83.15,118.41 80.11,121.46 76.74,121.46 76.22,121.98 73.75,121.98 73.11,122.61 ; v2(71.74,72.86) 75.88,77 v2(75.88,81.71)
  IN1 w0.635: 134.08,81.31 135.37,80.02 136.37,80.02 137.25,79.15 137.25,78.69 140.42,75.52 141.47,75.52 144.31,72.67 145.71,72.67 146.32,72.07 146.32,69.85 146.72,69.45 147.08,69.45 147.37,69.16 148.63,69.16 v2(149.59,68.21) 149.59,67.72 149.11,67.24 149.11,66.58 150.33,65.37 150.33,65.33 152.98,62.68 152.98,58.92 155.94,55.96 v2(157.26,54.64) 157.84,54.06 159.44,54.06 161.17,52.33 162.62,52.33 162.92,52.03 162.92,50.97 163.25,50.63 165.95,50.63 165.99,50.67 180.43,50.67 180.5,50.6 182.72,50.6 185.53,47.78 185.62,47.78 186.38,47.03 186.38,46.49 187.04,45.83 190.73,45.83 192.85,43.72 192.85,43.24 192.6,42.99 192.6,40.15 v2(191.98,39.53)
  IN2 w0.254: v2(204.63,69.68) 203.56,70.75 203.56,71.3 201.66,73.21 200.64,73.21 198.65,75.2 198.65,76 197.47,77.18 197.47,79.61 198.26,80.4 198.26,81.14 v2(198.91,81.79)
  IN2 w0.635: 187.87,56.62 185.23,56.62 183.33,58.53 183.33,62.61 181.58,64.36 181.58,68.73 180.83,69.47 180.83,71.55 179.83,72.55 179.21,72.55 177.68,74.07 177.68,75.09 178.17,75.57 178.17,78.28 177.61,78.84 177.08,78.84 ; v4(170.57,34.7) 172.73,36.86 181.95,36.86 183.14,38.05 188.38,38.05 189.03,37.39 190.41,37.39 191.22,38.2 191.22,38.9 191.86,39.53 v2(191.98,39.53)
  BOTTOM w0.102: v2(147.09,83.2) 146.68,82.79 R628.1 ; U400.BP23 126.24,88.75
  BOTTOM w0.254: R474.2 149.03,89.26 150.4,87.89 v2(150.4,87.03) ; R7701.2 159.87,79.19 160.51,79.82 161.01,79.82 161.95,80.77 v2(161.95,81.29) ; R417.1 144.2,93.33 144.74,93.33 v2(144.76,93.35) 145.17,93.35 R418.1 ; v2(155.23,92.51) 153.82,93.92 153.13,93.92 151.99,95.06 v2(151.88,95.06) 151.88,95.07 151.83,95.01 150.88,95.01 R531.2 ; R535.1 151.95,97.84 151.38,97.84 v2(151.37,97.85) ; R4706.2 144.68,87.18 v2(144.18,87.68) 143.74,88.12 R476.2 ; v2(79.77,126.2) 79.65,126.2 78.73,125.28 78.73,125.03 78.65,124.95 78.65,123.87 78.02,123.24 72.55,123.24 72.51,123.2 v2(72.51,123.21) ; C467.2 141.89,84.97 140.56,84.97 v2(140.47,84.88) 140.28,84.68 139.65,84.68 139.62,84.65 138.42,84.65 U400.CP29 ; R536.2 151.07,96.53 v2(151.42,96.53) ; v1(131.15,92.23) 131.15,92.34 U400.CB16 ; v2(144.54,94.21) 144.48,94.14 R4116.1 ; v2(120.76,110.87) 120.85,110.96 R468.2
  BOTTOM w0.305: 203.14,64.06 203.14,62.71 202.81,62.38 202.81,60.82 203.11,60.53 210.22,60.53 210.73,60.03 211.16,60.03 212.33,58.85 v2(212.33,58.79)
  BOTTOM w0.381: PR8103.1 164.59,19.92 166.09,21.41 166.09,25.62 165.43,26.28 165.43,27.51 164.85,28.08 164.85,30.21 165.51,30.87 169.4,30.87 169.81,31.27 169.81,33.94 v4(170.57,34.7) ; PR8120.1 10.63,109.45 11.11,108.96 11.11,108.27 11.74,107.65 17.61,107.65 19.52,105.74 v2(19.52,105.26) ; v2(203.44,66.22) 203.14,65.92 203.14,64.06 201.43,64.06 200.83,63.47 200.83,63.46 200.53,63.16 200.53,61.07 200.39,60.93 v2(200.39,60.16) 197.71,60.16 197.2,59.64 194.46,59.64 193.57,60.53 191.41,60.53 191.14,60.27 187.96,60.27 186.68,58.98 v2(186.22,58.98)
  BOTTOM w0.508: v2(157.26,54.64) 155.84,56.06 132.34,56.06 130.95,57.46 v2(129.17,57.46) ; v2(149.59,68.21) 149.38,68 v2(148.19,68) 148.19,68.38 147.84,68.74 147.52,68.74 147.42,68.84 144.93,68.84 144.67,68.59 143.06,68.59 v2(142.57,69.08) ; PR8248.1 134.38,31.5 134.98,32.1 134.98,34.83 134.02,35.8 125.86,35.8 124.95,36.71 124.95,38.79 122.59,41.15 122.59,43.26 124.01,44.68 124.01,46.47 120.89,49.59 120.89,55.39 119.58,56.7 110.31,56.7 105.05,61.96 86.69,61.96 76.64,72 76.64,80.95 v2(75.88,81.71) ; 167.86,81.26 168.18,80.94 169.87,80.94 171.26,79.55 172.22,79.55 v2(172.44,79.32) ; v2(52.54,67.04) 52.54,67.9 51.29,69.14 51.29,73.07 v2(50.66,73.7) 50.66,74.34 45.93,79.08 37.6,79.08 36.94,78.42 32.75,78.42 31.1,80.07 31.1,82.37 20.56,92.92 v2(20.56,104.45)
  vias: v1(128.5,88.02) v1(129.22,88.03) v1(131.74,87.94) v1(132.32,87.99) v2(165.14,84.12) v2(165.79,84.13) v2(175.48,78.6)
+3V_ECACC: length 11.6
  TOP w0.305: U4701.D1 202.95,48.39 202.9,48.34 202.9,47.75 202.95,47.7 202.95,46.93 202.65,46.63 200.61,46.63 v2(200.49,46.51) 200.49,46.35 199.47,45.32 197.61,45.32 196.93,44.64 C4719.2 C4718.1 196.6,43.67 196.23,43.3 R4736.1
+3V_RTC: length 219.6
  TOP w0.076: 211.2,50.55 C4702.1
  TOP w0.079: U4701.L4 207.83,51.34 208.44,51.34
  TOP w0.254: 208.44,51.34 208.49,51.38 208.95,51.38 209.27,51.06 210.65,51.06 210.84,50.87
  TOP w0.508: 211.2,50.55 C4701.1 211.06,49.64 210.3,50.39 v2(209.75,50.39) ; C4702.1 211.06,50.65 210.84,50.87 ; v2(173.19,63.71) 172.83,64.06 170.42,64.06 170.18,63.83 169.55,63.83 169.12,63.4 168.12,63.4 167.72,63.79 156.43,63.79 156.14,63.51 150.1,63.51 147.53,60.94 v2(146.74,60.94) 143.35,57.55 140.4,57.55 138.92,56.06 109.91,56.06 108.5,57.47 65.02,57.47 62.57,59.92 C428.1 C429.1 61.89,61.55 D400.3 ; v2(130.11,81.18) 129.18,80.26 129.18,78.63 131.35,76.46 131.35,73.56 130.92,73.13 v2(130.92,72.83) v2(132.01,72.83) ; v2(177.91,58.4) 178.56,59.05 178.56,60.33 181.54,63.3 184.36,63.3 185.29,62.37 185.73,62.37 185.89,62.2 v2(186.44,62.2) ; C470.2 126.52,88.28 v1(126.52,88.03)
  IN1 w0.508: 131.79,80.31 133.77,80.31 135.61,78.48 136.17,78.48 141.04,73.6 141.04,71.59 142.56,70.08 143.34,70.08 143.91,69.5 143.91,63.76 v2(146.74,60.94) ; v2(177.91,58.4) 173.19,63.12 v2(173.19,63.71)
  IN2 w0.508: v2(186.44,62.2) 186.44,62.02 188.13,60.34 195.68,60.34 196.96,59.06 200.39,59.06 201,58.45 201,57.73 202.03,56.71 203.43,56.71 203.63,56.5 206.41,56.5 208.3,54.61 208.3,53.72 208.93,53.09 209.21,53.09 210.04,52.26 210.04,51.28 209.75,50.99 v2(209.75,50.39)
  BOTTOM w0.305: U400.BR23 126.89,88.4 v1(126.52,88.03)
  BOTTOM w0.381: v2(132.01,72.83) 132.06,72.88 R601.2 133.05,73.58 R599.2 ; v2(130.92,72.83) 130.83,72.83 R461.2 C471.1
+3V_RTC_0: length 83.7
  TOP w0.102: C7629.1 44.63,24.54 44.63,25.37 v2(44.65,25.39) ; v2(40.4,68.17) 40.52,68.29 40.52,72.22 41.92,73.61 44.78,73.61 47.15,71.24 49.39,71.24 49.64,71 49.64,69.89 51.2,68.33 51.2,67.07 52,66.27 53.95,66.27 55.61,64.62 58.27,64.62 59.07,63.82 59.07,63.19 59.26,63 R602.2
  IN1 w0.114: v2(44.65,25.39) 45.08,25.83 45.94,25.83 46.85,26.73 46.85,27.27 45.35,28.76 45.35,31.23 43.41,33.17 43.41,33.7 42.63,34.47 41.84,34.47 39.47,36.84 39.47,44.14 39.76,44.43 39.76,46.39 40.52,47.15 40.52,48.14 39.6,49.06 39.6,55.43 40.15,55.98 40.77,55.98 41.32,56.53 41.32,59.91 42.27,60.85 42.27,65.18 41.51,65.94 41.51,67.06 v2(40.4,68.17)
  BOTTOM w0.102: CN7601.3 43.74,26.02 43.92,25.84 44.2,25.84 v2(44.65,25.39)
+3V_RTC_1: length 6.4
  TOP w0.102: Q7702.2 59.41,65.63 R9649.1 59.77,64.4 R602.1 60.19,63.45 60.36,63.62 D400.1 60.78,62 v2(60.51,61.73)
+3V_RTC_2: length 3.1
  TOP w0.102: v2(61.25,66.01) 61.56,66.01 62.3,65.28 R598.2
  TOP w0.508: D400.2 62.08,64.13 62.3,64.35 R598.2
+3V_SENSOR: length 45.7
  TOP w0.508: v2(68.94,126.43) 68.94,126.12 70.2,124.85 73.85,124.85 74.28,125.28 76.56,125.28 77,125.71 v2(77,127.26) 77.63,127.89 77.63,131.58 76.93,132.28 v2(76.67,132.28)
  IN1 w0.381: v2(77,127.26) 77.02,127.24 77.7,127.24 79.52,125.42 85.6,125.42 90.05,129.87 90.05,131.35 91.15,132.45 93.61,132.45 v2(94.63,131.43)
  BOTTOM w0.254: R7629.1 77.69,126.57 v2(77,127.26) ; v2(94.63,131.43) 94.63,132.25 94.44,132.45 Q7602.2 Q7602.5 ; CN7602.7 76.57,132.19 v2(76.67,132.28)
+3V_SSD: length 6
  BOTTOM w0.254: 205.09,6.38 205.38,6.09 CN4300.4 207.18,6.09 207.37,6.28 ; 204.35,6.38 205.14,5.59 CN4300.2 207.32,5.59 207.5,5.77
  vias: v2(199.22,8.3) v2(199.58,8.81) v2(199.86,8.23) v2(200.29,8.78) v2(200.7,15.2) v2(200.87,14.53) v2(201.32,15.64) v2(201.35,14.98)
+3V_THR: length 3.3
  BOTTOM w0.508: C5405.1 42.37,110.6 R5403.1 42.35,111.71 v2(41.43,111.71) 40.98,112.16 U5401.5
+3V_VCC: length 94.3
  TOP w0.254: C4715.2 197.86,52.9 198.55,52.21 199.8,52.21 200.06,52.48 200.06,52.7 200.34,52.98 200.98,52.98 U4701.A7 ; C4713.2 211.07,53.77 210.91,53.61 U4701.M8
  TOP w0.305: v2(199.34,47.68) 199.47,47.68 200.07,48.28 201.12,48.28 201.65,48.82 U4701.B1
  TOP w0.381: U4701.D12 202.26,56.9 v2(202.26,57.3) ; v2(199.34,47.68) 199.04,47.68 198.49,48.23 C4712.1 ; C4715.2 198.17,53.24 v2(198.59,52.82) ; C4713.2 210.04,54.81 209.3,54.81 v2(209.29,54.8) ; v2(210.9,59.37) 210.4,58.86 208.01,58.86 207.25,58.1 205.4,58.1 v2(205.15,57.84)
  TOP w0.508: PQ8004.2 206.79,96.7 v2(206.79,95.74) 206.75,95.7 PR8011.1 ; v2(202.26,57.3) 199.59,57.3 198.68,58.21 C4716.2 197.16,58.21 197.11,58.26 C4714.2 195.44,59.02 R4731.1
  IN1 w0.508: v2(212.58,62.95) 211.89,63.64 211.76,63.64 209.93,65.47 209.93,67.87 209.53,68.27 209.53,71.3 205.98,74.86 205.98,76.13 206.21,76.36 206.21,79.08 205.5,79.78 205.5,80.12 205.37,80.25 205.37,81.36 205.04,81.69 205.04,83.93 203.03,85.94 203.03,86.9 204.07,87.94 204.07,94.59 205.22,95.74 v2(206.79,95.74)
  IN2 w0.508: v2(202.26,57.3) 202.84,57.87 205.11,57.87 v2(205.15,57.84) 205.3,57.69 206.14,57.69 208.89,54.95 209.15,54.95 v2(209.29,54.8) ; v2(198.59,52.82) 197.89,52.82 197.44,53.28 196.91,53.28 196.13,52.49 v2(196.13,51.52)
  BOTTOM w0.305: v2(210.9,59.37) 210.9,59.01 211.69,58.22 212.58,58.22 212.86,58.5 212.86,60.28 213.34,60.76 213.34,62.16 212.58,62.92 v2(212.58,62.95)
+3V_VCC_READER:
  vias: v2(42.16,33.46) v2(42.81,33.56) v2(42.84,32.24)
