# Allegro board dax8jmb16e0-e-www.DeviceDB.xyz_.brd (continued)
## Nets (continued)
KSO9: C5012.2 CN5000.27 U4701.C10(KSO09/GPIO10/CR_SIN)
KSO10: C5013.2 CN5000.19 U4701.B11(KSO10&P80_CLK/GPIO07)
KSO11: C5014.2 CN5000.1 U4701.B10(KSO11&P80_DAT/GPIO06)
KSO12: CN5000.28 R6832.1 U4701.C11(KSO12/GPIO05)
KSO13: CN5000.29 U4701.D11(KSO13/GPIO04)
L_SPK+: L3600.2 U3600.35(SPK-L+)
L_SPK+_R: C3635.2 CN3600.4 L3600.1
L_SPK-: L3601.2 U3600.36(SPK-L-)
L_SPK-_R: C3636.2 CN3600.3 L3601.1
LAD0: CN7701.2 R436.1 U4701.H1(LAD0/ESPI_IO0/GPIO46)
LAD0_L: R436.2 U400.CA29(GPP_A1/LAD0/ESPI_IO0)
LAD1: CN7701.7 R437.1 U4701.J1(LAD1/ESPI_IO1/GPIO47)
LAD1_L: R437.2 U400.BY29(GPP_A2/LAD1/ESPI_IO1)
LAD2: CN7701.1 R439.1 U4701.K1(LAD2/ESPI_IO2/GPIO51)
LAD2_L: R439.2 U400.BY27(GPP_A3/LAD2/ESPI_IO2)
LAD3: CN7701.6 R441.1 U4701.L1(LAD3/ESPI_IO3/GPIO52)
LAD3_L: R441.2 U400.BV27(GPP_A4/LAD3/ESPI_IO3)
LAN_AMBLED: C4014.2 CN4000.11(LED_AMB_N) R4008.2
LAN_AMBLED#: C4037.1 CN4000.12(LED_AMB_P) TP4002.1 U4000.27(LED0)
LAN_DIS#: TP426.1 U400.BU34(GPD11/LANPHYPC)
LAN_MCTG0: R4017.1 U4001.15(MCT4)
LAN_MCTG1: R4016.1 U4001.18(MCT3)
LAN_MCTG2: R4015.1 U4001.21(MCT2)
LAN_MCTG3: R4014.1 U4001.24(MCT1)
LAN_PWR_ON: PR9507.2 U4701.L7(GPIOE3/I2C6_SDA1)
LAN_WLED: C4013.2 CN4000.9(LED_WHITE_N) R4007.2
LAN_WLED#: C4036.1 CN4000.10(LED_WHITE_P) Q4000.4(S) TP4001.1 U4000.26(LED1/GPO)
LANLINK_STATUS: Q4000.1(S) R423.1 U400.CG20(GPP_D0/SPI1_CS0#/BK0/SBK0)
LANRSET: R4000.2 U4000.31(RSET)
LED#: C7602.1 CN7600.19 Q7600.6(D) R7619.2
LED_3S_SATA#: C7628.1 CN7601.21 D4300.2 R568.2 U400.CN7(GPP_E8/SATALED#/SPI1_CS1#)
LED_PWRSTBY#: Q7600.5(G) R4734.1 R4738.2 R7619.1 U4700.6(1Y)
LFRAME#: CN7701.5 U400.CA28(GPP_A5/LFRAME#/ESPI_CS#) U4701.L2(L\F\R\A\M\E\/E\S\P\I\_\C\S\/GPI)
LID_OFF_CN: C3424.2 Q3400.3(D) Q3401.2(G) R3424.1
LID_SW#_3: CN3400.38 D6200.1 EC3400.2 Q7501.1(S) R3400.2 R4742.1 R7510.1 R7616.1 U4701.H4(GPIO65)
LID_SW#_3_Q: Q7501.6(D) Q7502.2(G) R7504.2 R7510.2
LID_SW#_R: C7603.2 CN7600.17 R7616.2
LIMIT_SIGNAL: EC9700.1 PCN8000.6(AD_ID) PR8503.2
LPC_ESPI_CLK: C402.1 CN7701.8 R442.2 R4702.1 R7712.1 U4701.M1(PCI_CLK/ESPI_CLK/GPIO55)
LPC_ESPI_RESET#: CN7701.9 R446.1 U400.CA27(GPP_A14/SUS_STAT#/ESPI_RESET#) U4701.K3(L\R\E\S\E\T\/E\S\P\I\_\R\S\T\/G)
M_A_A0: JDIM2800.144(A0) U400.AC37(DDR0_CAB_9/DDR0_MA_0)
M_A_A1: JDIM2800.133(A1) U400.AC36(DDR0_CAB_8/DDR0_MA_1)
M_A_A2: JDIM2800.132(A2) U400.AC34(DDR0_CAB_5/DDR0_MA_2)
M_A_A3: JDIM2800.131(A3) U400.AC35(NC/DDR0_MA_3)
M_A_A4: JDIM2800.128(A4) U400.AA35(NC/DDR0_MA_4)
M_A_A5: JDIM2800.126(A5) U400.AB35(DDR0_CAA_0/DDR0_MA_5)
M_A_A6: JDIM2800.127(A6) U400.AA37(DDR0_CAA_2/DDR0_MA_6)
M_A_A7: JDIM2800.122(A7) U400.AA36(DDR0_CAA_4/DDR0_MA_7)
M_A_A8: JDIM2800.125(A8) U400.AB34(DDR0_CAA_3/DDR0_MA_8)
M_A_A9: JDIM2800.121(A9) U400.W36(DDR0_CAA_1/DDR0_MA_9)
M_A_A10: JDIM2800.146(A10/AP) U400.Y31(DDR0_CAB_7/DDR0_MA_10)
M_A_A11: JDIM2800.120(A11) U400.W34(DDR0_CAA_7/DDR0_MA_11)
M_A_A12: JDIM2800.119(A12) U400.AA34(DDR0_CAA_6/DDR0_MA_12)
M_A_A13: JDIM2800.158(A13) U400.AC32(DDR0_CAB_0/DDR0_MA_13)
M_A_ACT#: JDIM2800.114(ACT#) U400.V35(DDR0_CAA_8/DDR0_ACT#)
M_A_ALERT#: JDIM2800.116(ALERT#) U400.W37(NC/DDR0_ALERT#)
M_A_BG#0: JDIM2800.115(BG0) U400.V34(DDR0_CAA_5/DDR0_BG_0)
M_A_BG#1: JDIM2800.113(BG1) U400.W35(DDR0_CAA_9/DDR0_BG_1)
M_A_BS#0: JDIM2800.150(BA0) U400.W32(DDR0_CAB_4/DDR0_BA_0)
M_A_BS#1: JDIM2800.145(BA1) U400.AB31(DDR0_CAB_6/DDR0_BA_1)
M_A_CAS#: JDIM2800.156(A15/CAS#) U400.AB32(DDR0_CAB_1/DDR0_MA_15)
M_A_CB0: JDIM2800.92(CB0) R2804.2
M_A_CB1: JDIM2800.91(CB1) R2805.2
M_A_CB2: JDIM2800.101(CB2) R2806.2
M_A_CB3: JDIM2800.105(CB3) R2807.2
M_A_CB4: JDIM2800.88(CB4) R2808.2
M_A_CB5: JDIM2800.87(CB5) R2809.2
M_A_CB6: JDIM2800.100(CB6) R2810.2
M_A_CB7: JDIM2800.104(CB7) R2811.2
M_A_CKE0: JDIM2800.109(CKE0) U400.U36(DDR0_CKE_0/DDR0_CKE_0)
M_A_CKE1: JDIM2800.110(CKE1) U400.U37(DDR0_CKE_1/DDR0_CKE_1)
M_A_CLKN0: JDIM2800.139(CK0#) U400.V32(DDR0_CKN_0/DDR0_CKN_0)
M_A_CLKN1: JDIM2800.140(CK1#) U400.T32(DDR0_CKN_1/DDR0_CKN_1)
M_A_CLKP0: JDIM2800.137(CK0) U400.V31(DDR0_CKP_0/DDR0_CKP_0)
M_A_CLKP1: JDIM2800.138(CK1) U400.T31(DDR0_CKP_1/DDR0_CKP_1)
M_A_CS#0: JDIM2800.149(S0#) U400.AE32(DDR0_CS#_0/DDR0_CS#_0)
M_A_CS#1: JDIM2800.157(S1#) U400.AF32(DDR0_CS#_1/DDR0_CS#_1)
M_A_DQ0: JDIM2800.4(DQ4) U400.A26(DDR0_DQ_0/DDR0_DQ_0)
M_A_DQ1: JDIM2800.3(DQ5) U400.D26(DDR0_DQ_1/DDR0_DQ_1)
M_A_DQ2: JDIM2800.16(DQ6) U400.D28(DDR0_DQ_2/DDR0_DQ_2)
M_A_DQ3: JDIM2800.20(DQ2) U400.C28(DDR0_DQ_3/DDR0_DQ_3)
M_A_DQ4: JDIM2800.8(DQ0) U400.B26(DDR0_DQ_4/DDR0_DQ_4)
M_A_DQ5: JDIM2800.7(DQ1) U400.C26(DDR0_DQ_5/DDR0_DQ_5)
M_A_DQ6: JDIM2800.17(DQ7) U400.B28(DDR0_DQ_6/DDR0_DQ_6)
M_A_DQ7: JDIM2800.21(DQ3) U400.A28(DDR0_DQ_7/DDR0_DQ_7)
M_A_DQ8: JDIM2800.49(DQ17) U400.B30(DDR0_DQ_8/DDR0_DQ_8)
M_A_DQ9: JDIM2800.45(DQ21) U400.D30(DDR0_DQ_9/DDR0_DQ_9)
M_A_DQ10: JDIM2800.58(DQ22) U400.B33(DDR0_DQ_10/DDR0_DQ_10)
M_A_DQ11: JDIM2800.59(DQ23) U400.D32(DDR0_DQ_11/DDR0_DQ_11)
M_A_DQ12: JDIM2800.46(DQ20) U400.A30(DDR0_DQ_12/DDR0_DQ_12)
M_A_DQ13: JDIM2800.50(DQ16) U400.C30(DDR0_DQ_13/DDR0_DQ_13)
M_A_DQ14: JDIM2800.63(DQ19) U400.B32(DDR0_DQ_14/DDR0_DQ_14)
M_A_DQ15: JDIM2800.62(DQ18) U400.C32(DDR0_DQ_15/DDR0_DQ_15)
M_A_DQ16: JDIM2800.67(DQ29) U400.J22(DDR1_DQ_0/DDR0_DQ_16)
M_A_DQ17: JDIM2800.80(DQ31) U400.H25(DDR1_DQ_1/DDR0_DQ_17)
M_A_DQ18: JDIM2800.71(DQ25) U400.G22(DDR1_DQ_2/DDR0_DQ_18)
M_A_DQ19: JDIM2800.66(DQ28) U400.H22(DDR1_DQ_3/DDR0_DQ_19)
M_A_DQ20: JDIM2800.83(DQ26) U400.F25(DDR1_DQ_4/DDR0_DQ_20)
M_A_DQ21: JDIM2800.84(DQ27) U400.J25(DDR1_DQ_5/DDR0_DQ_21)
M_A_DQ22: JDIM2800.79(DQ30) U400.G25(DDR1_DQ_6/DDR0_DQ_22)
M_A_DQ23: JDIM2800.70(DQ24) U400.F22(DDR1_DQ_7/DDR0_DQ_23)
M_A_DQ24: JDIM2800.29(DQ9) U400.D22(DDR1_DQ_8/DDR0_DQ_24)
M_A_DQ25: JDIM2800.24(DQ12) U400.C22(DDR1_DQ_9/DDR0_DQ_25)
M_A_DQ26: JDIM2800.37(DQ15) U400.C24(DDR1_DQ_10/DDR0_DQ_26)
M_A_DQ27: JDIM2800.42(DQ11) U400.D24(DDR1_DQ_11/DDR0_DQ_27)
M_A_DQ28: JDIM2800.28(DQ8) U400.A22(DDR1_DQ_12/DDR0_DQ_28)
M_A_DQ29: JDIM2800.25(DQ13) U400.B22(DDR1_DQ_13/DDR0_DQ_29)
M_A_DQ30: JDIM2800.41(DQ10) U400.A24(DDR1_DQ_14/DDR0_DQ_30)
M_A_DQ31: JDIM2800.38(DQ14) U400.B24(DDR1_DQ_15/DDR0_DQ_31)
M_A_DQ32: JDIM2800.195(DQ40) U400.H37(DDR0_DQ_16/DDR0_DQ_32)
M_A_DQ33: JDIM2800.191(DQ44) U400.H34(DDR0_DQ_17/DDR0_DQ_33)
M_A_DQ34: JDIM2800.203(DQ46) U400.K34(DDR0_DQ_18/DDR0_DQ_34)
M_A_DQ35: JDIM2800.208(DQ43) U400.K35(DDR0_DQ_19/DDR0_DQ_35)
M_A_DQ36: JDIM2800.194(DQ41) U400.H36(DDR0_DQ_20/DDR0_DQ_36)
M_A_DQ37: JDIM2800.190(DQ45) U400.H35(DDR0_DQ_21/DDR0_DQ_37)
M_A_DQ38: JDIM2800.204(DQ47) U400.K36(DDR0_DQ_22/DDR0_DQ_38)
M_A_DQ39: JDIM2800.207(DQ42) U400.K37(DDR0_DQ_23/DDR0_DQ_39)
M_A_DQ40: JDIM2800.211(DQ52) U400.N36(DDR0_DQ_24/DDR0_DQ_40)
M_A_DQ41: JDIM2800.216(DQ48) U400.N34(DDR0_DQ_25/DDR0_DQ_41)
M_A_DQ42: JDIM2800.228(DQ50) U400.R37(DDR0_DQ_26/DDR0_DQ_42)
M_A_DQ43: JDIM2800.224(DQ54) U400.R34(DDR0_DQ_27/DDR0_DQ_43)
M_A_DQ44: JDIM2800.212(DQ53) U400.N37(DDR0_DQ_28/DDR0_DQ_44)
M_A_DQ45: JDIM2800.215(DQ49) U400.N35(DDR0_DQ_29/DDR0_DQ_45)
M_A_DQ46: JDIM2800.225(DQ55) U400.R36(DDR0_DQ_30/DDR0_DQ_46)
M_A_DQ47: JDIM2800.229(DQ51) U400.R35(DDR0_DQ_31/DDR0_DQ_47)
M_A_DQ48: JDIM2800.173(DQ33) U400.G31(DDR1_DQ_16/DDR0_DQ_48)
M_A_DQ49: JDIM2800.169(DQ37) U400.G32(DDR1_DQ_17/DDR0_DQ_49)
M_A_DQ50: JDIM2800.186(DQ35) U400.H29(DDR1_DQ_18/DDR0_DQ_50)
M_A_DQ51: JDIM2800.187(DQ34) U400.H28(DDR1_DQ_19/DDR0_DQ_51)
M_A_DQ52: JDIM2800.170(DQ36) U400.G28(DDR1_DQ_20/DDR0_DQ_52)
M_A_DQ53: JDIM2800.174(DQ32) U400.G29(DDR1_DQ_21/DDR0_DQ_53)
M_A_DQ54: JDIM2800.183(DQ38) U400.H31(DDR1_DQ_22/DDR0_DQ_54)
M_A_DQ55: JDIM2800.182(DQ39) U400.H32(DDR1_DQ_23/DDR0_DQ_55)
M_A_DQ56: JDIM2800.233(DQ61) U400.L31(DDR1_DQ_24/DDR0_DQ_56)
M_A_DQ57: JDIM2800.236(DQ57) U400.L32(DDR1_DQ_25/DDR0_DQ_57)
M_A_DQ58: JDIM2800.250(DQ59) U400.N29(DDR1_DQ_26/DDR0_DQ_58)
M_A_DQ59: JDIM2800.249(DQ58) U400.N28(DDR1_DQ_27/DDR0_DQ_59)
M_A_DQ60: JDIM2800.232(DQ60) U400.L28(DDR1_DQ_28/DDR0_DQ_60)
M_A_DQ61: JDIM2800.237(DQ56) U400.L29(DDR1_DQ_29/DDR0_DQ_61)
M_A_DQ62: JDIM2800.246(DQ63) U400.N31(DDR1_DQ_30/DDR0_DQ_62)
M_A_DQ63: JDIM2800.245(DQ62) U400.N32(DDR1_DQ_31/DDR0_DQ_63)
M_A_DQSN0: JDIM2800.11(DQS#0) U400.C27(DDR0_DQSN_0/DDR0_DQSN_0)
M_A_DQSN1: JDIM2800.53(DQS#2) U400.D31(DDR0_DQSN_1/DDR0_DQSN_1)
M_A_DQSN2: JDIM2800.74(DQS#3) U400.H24(DDR1_DQSN_0/DDR0_DQSN_2)
M_A_DQSN3: JDIM2800.32(DQS#1) U400.C23(DDR1_DQSN_1/DDR0_DQSN_3)
M_A_DQSN4: JDIM2800.198(DQS#5) U400.J35(DDR0_DQSN_2/DDR0_DQSN_4)
M_A_DQSN5: JDIM2800.219(DQS#6) U400.P34(DDR0_DQSN_3/DDR0_DQSN_5)
M_A_DQSN6: JDIM2800.177(DQS#4) U400.G30(DDR1_DQSN_2/DDR0_DQSN_6)
M_A_DQSN7: JDIM2800.240(DQS#7) U400.L30(DDR1_DQSN_3/DDR0_DQSN_7)
M_A_DQSN8: JDIM2800.95(DQS#8) R2803.2
M_A_DQSP0: JDIM2800.13(DQS0) U400.D27(DDR0_DQSP_0/DDR0_DQSP_0)
M_A_DQSP1: JDIM2800.55(DQS2) U400.C31(DDR0_DQSP_1/DDR0_DQSP_1)
M_A_DQSP2: JDIM2800.76(DQS3) U400.G24(DDR1_DQSP_0/DDR0_DQSP_2)
M_A_DQSP3: JDIM2800.34(DQS1) U400.D23(DDR1_DQSP_1/DDR0_DQSP_3)
M_A_DQSP4: JDIM2800.200(DQS5) U400.J34(DDR0_DQSP_2/DDR0_DQSP_4)
M_A_DQSP5: JDIM2800.221(DQS6) U400.P35(DDR0_DQSP_3/DDR0_DQSP_5)
M_A_DQSP6: JDIM2800.179(DQS4) U400.H30(DDR1_DQSP_2/DDR0_DQSP_6)
M_A_DQSP7: JDIM2800.242(DQS7) U400.N30(DDR1_DQSP_3/DDR0_DQSP_7)
M_A_DQSP8: JDIM2800.97(DQS8) R2802.2
M_A_ODT0: JDIM2800.155(ODT0) U400.AE31(DDR0_ODT_0/DDR0_ODT_0)
M_A_ODT1: JDIM2800.161(ODT1) U400.AF31(NC/DDR0_ODT_1)
M_A_PARITY: JDIM2800.143(PARITY) U400.W31(NC/DDR0_PAR)
M_A_RAS#: JDIM2800.152(A16/RAS#) U400.Y32(DDR0_CAB_3/DDR0_MA_16)
M_A_WE#: JDIM2800.151(A14/WE#) U400.AC31(DDR0_CAB_2/DDR0_MA_14)
M_B_A0: JDIM2801.144(A0) U400.AG36(DDR1_CAB_9/DDR1_MA_0)
M_B_A1: JDIM2801.133(A1) U400.AG35(DDR1_CAB_8/DDR1_MA_1)
M_B_A2: JDIM2801.132(A2) U400.AF34(DDR1_CAB_5/DDR1_MA_2)
M_B_A3: JDIM2801.131(A3) U400.AG37(NC/DDR1_MA_3)
M_B_A4: JDIM2801.128(A4) U400.AE35(NC/DDR1_MA_4)
M_B_A5: JDIM2801.126(A5) U400.AF35(DDR1_CAA_0/DDR1_MA_5)
M_B_A6: JDIM2801.127(A6) U400.AE37(DDR1_CAA_2/DDR1_MA_6)
M_B_A7: JDIM2801.122(A7) U400.AC29(DDR1_CAA_4/DDR1_MA_7)
M_B_A8: JDIM2801.125(A8) U400.AE36(DDR1_CAA_3/DDR1_MA_8)
M_B_A9: JDIM2801.121(A9) U400.AB29(DDR1_CAA_1/DDR1_MA_9)
M_B_A10: JDIM2801.146(A10/AP) U400.AG34(DDR1_CAB_7/DDR1_MA_10)
M_B_A11: JDIM2801.120(A11) U400.AC28(DDR1_CAA_7/DDR1_MA_11)
M_B_A12: JDIM2801.119(A12) U400.AB28(DDR1_CAA_6/DDR1_MA_12)
M_B_A13: JDIM2801.158(A13) U400.AK35(DDR1_CAB_0/DDR1_MA_13)
M_B_ACT#: JDIM2801.114(ACT#) U400.W28(DDR1_CAA_8/DDR1_ACT#)
M_B_ALERT#: JDIM2801.116(ALERT#) U400.Y29(NC/DDR1_ALERT#)
M_B_BG#0: JDIM2801.115(BG0) U400.W29(DDR1_CAA_5/DDR1_BG_0)
M_B_BG#1: JDIM2801.113(BG1) U400.Y28(DDR1_CAA_9/DDR1_BG_1)
M_B_BS#0: JDIM2801.150(BA0) U400.AJ37(DDR1_CAB_4/DDR1_BA_0)
M_B_BS#1: JDIM2801.145(BA1) U400.AJ36(DDR1_CAB_6/DDR1_BA_1)
M_B_CAS#: JDIM2801.156(A15/CAS#) U400.AK34(DDR1_CAB_1/DDR1_MA_15)
M_B_CB0: JDIM2801.92(CB0) R2829.2
M_B_CB1: JDIM2801.91(CB1) R2830.2
M_B_CB2: JDIM2801.101(CB2) R2831.2
M_B_CB3: JDIM2801.105(CB3) R2833.2
M_B_CB4: JDIM2801.88(CB4) R2834.2
M_B_CB5: JDIM2801.87(CB5) R2835.2
M_B_CB6: JDIM2801.100(CB6) R2836.2
M_B_CB7: JDIM2801.104(CB7) R2837.2
M_B_CKE0: JDIM2801.109(CKE0) U400.T28(DDR1_CKE_0/DDR1_CKE_0)
M_B_CKE1: JDIM2801.110(CKE1) U400.T29(DDR1_CKE_1/DDR1_CKE_1)
M_B_CLKN0: JDIM2801.139(CK0#) U400.AF28(DDR1_CKN_0/DDR1_CKN_0)
M_B_CLKN1: JDIM2801.140(CK1#) U400.AE28(DDR1_CKN_1/DDR1_CKN_1)
M_B_CLKP0: JDIM2801.137(CK0) U400.AF29(DDR1_CKP_0/DDR1_CKP_0)
M_B_CLKP1: JDIM2801.138(CK1) U400.AE29(DDR1_CKP_1/DDR1_CKP_1)
M_B_CS#0: JDIM2801.149(S0#) U400.AL37(DDR1_CS#_0/DDR1_CS#_0)
M_B_CS#1: JDIM2801.157(S1#) U400.AL35(DDR1_CS#_1/DDR1_CS#_1)
M_B_DQ0: JDIM2801.20(DQ2) U400.AN35(DDR0_DQ_32/DDR1_DQ_0)
M_B_DQ1: JDIM2801.3(DQ5) U400.AN34(DDR0_DQ_33/DDR1_DQ_1)
M_B_DQ2: JDIM2801.16(DQ6) U400.AR35(DDR0_DQ_34/DDR1_DQ_2)
M_B_DQ3: JDIM2801.4(DQ4) U400.AR34(DDR0_DQ_35/DDR1_DQ_3)
M_B_DQ4: JDIM2801.17(DQ7) U400.AN37(DDR0_DQ_36/DDR1_DQ_4)
M_B_DQ5: JDIM2801.21(DQ3) U400.AN36(DDR0_DQ_37/DDR1_DQ_5)
M_B_DQ6: JDIM2801.7(DQ1) U400.AR36(DDR0_DQ_38/DDR1_DQ_6)
M_B_DQ7: JDIM2801.8(DQ0) U400.AR37(DDR0_DQ_39/DDR1_DQ_7)
M_B_DQ8: JDIM2801.182(DQ39) U400.AU35(DDR0_DQ_40/DDR1_DQ_8)
M_B_DQ9: JDIM2801.169(DQ37) U400.AU34(DDR0_DQ_41/DDR1_DQ_9)
M_B_DQ10: JDIM2801.187(DQ34) U400.AW35(DDR0_DQ_42/DDR1_DQ_10)
M_B_DQ11: JDIM2801.173(DQ33) U400.AW34(DDR0_DQ_43/DDR1_DQ_11)
M_B_DQ12: JDIM2801.170(DQ36) U400.AU37(DDR0_DQ_44/DDR1_DQ_12)
M_B_DQ13: JDIM2801.174(DQ32) U400.AU36(DDR0_DQ_45/DDR1_DQ_13)
M_B_DQ14: JDIM2801.186(DQ35) U400.AW36(DDR0_DQ_46/DDR1_DQ_14)
M_B_DQ15: JDIM2801.183(DQ38) U400.AW37(DDR0_DQ_47/DDR1_DQ_15)
M_B_DQ16: JDIM2801.24(DQ12) U400.AJ29(DDR1_DQ_32/DDR1_DQ_16)
M_B_DQ17: JDIM2801.25(DQ13) U400.AJ30(DDR1_DQ_33/DDR1_DQ_17)
M_B_DQ18: JDIM2801.37(DQ15) U400.AM32(DDR1_DQ_34/DDR1_DQ_18)
M_B_DQ19: JDIM2801.38(DQ14) U400.AM31(DDR1_DQ_35/DDR1_DQ_19)
M_B_DQ20: JDIM2801.41(DQ10) U400.AM30(DDR1_DQ_36/DDR1_DQ_20)
M_B_DQ21: JDIM2801.42(DQ11) U400.AM29(DDR1_DQ_37/DDR1_DQ_21)
M_B_DQ22: JDIM2801.29(DQ9) U400.AJ31(DDR1_DQ_38/DDR1_DQ_22)
M_B_DQ23: JDIM2801.28(DQ8) U400.AJ32(DDR1_DQ_39/DDR1_DQ_23)
M_B_DQ24: JDIM2801.194(DQ41) U400.AR31(DDR1_DQ_40/DDR1_DQ_24)
M_B_DQ25: JDIM2801.191(DQ44) U400.AR32(DDR1_DQ_41/DDR1_DQ_25)
M_B_DQ26: JDIM2801.207(DQ42) U400.AV30(DDR1_DQ_42/DDR1_DQ_26)
M_B_DQ27: JDIM2801.208(DQ43) U400.AV29(DDR1_DQ_43/DDR1_DQ_27)
M_B_DQ28: JDIM2801.190(DQ45) U400.AR30(DDR1_DQ_44/DDR1_DQ_28)
M_B_DQ29: JDIM2801.195(DQ40) U400.AR29(DDR1_DQ_45/DDR1_DQ_29)
M_B_DQ30: JDIM2801.204(DQ47) U400.AV32(DDR1_DQ_46/DDR1_DQ_30)
M_B_DQ31: JDIM2801.203(DQ46) U400.AV31(DDR1_DQ_47/DDR1_DQ_31)
M_B_DQ32: JDIM2801.45(DQ21) U400.BA35(DDR0_DQ_48/DDR1_DQ_32)
M_B_DQ33: JDIM2801.62(DQ18) U400.BA34(DDR0_DQ_49/DDR1_DQ_33)
M_B_DQ34: JDIM2801.58(DQ22) U400.BC35(DDR0_DQ_50/DDR1_DQ_34)
M_B_DQ35: JDIM2801.46(DQ20) U400.BC34(DDR0_DQ_51/DDR1_DQ_35)
M_B_DQ36: JDIM2801.50(DQ16) U400.BA37(DDR0_DQ_52/DDR1_DQ_36)
M_B_DQ37: JDIM2801.49(DQ17) U400.BA36(DDR0_DQ_53/DDR1_DQ_37)
M_B_DQ38: JDIM2801.63(DQ19) U400.BC36(DDR0_DQ_54/DDR1_DQ_38)
M_B_DQ39: JDIM2801.59(DQ23) U400.BC37(DDR0_DQ_55/DDR1_DQ_39)
M_B_DQ40: JDIM2801.67(DQ29) U400.BE35(DDR0_DQ_56/DDR1_DQ_40)
M_B_DQ41: JDIM2801.70(DQ24) U400.BE34(DDR0_DQ_57/DDR1_DQ_41)
M_B_DQ42: JDIM2801.84(DQ27) U400.BG35(DDR0_DQ_58/DDR1_DQ_42)
M_B_DQ43: JDIM2801.79(DQ30) U400.BG34(DDR0_DQ_59/DDR1_DQ_43)
M_B_DQ44: JDIM2801.71(DQ25) U400.BE37(DDR0_DQ_60/DDR1_DQ_44)
M_B_DQ45: JDIM2801.66(DQ28) U400.BE36(DDR0_DQ_61/DDR1_DQ_45)
M_B_DQ46: JDIM2801.80(DQ31) U400.BG36(DDR0_DQ_62/DDR1_DQ_46)
M_B_DQ47: JDIM2801.83(DQ26) U400.BG37(DDR0_DQ_63/DDR1_DQ_47)
M_B_DQ48: JDIM2801.216(DQ48) U400.BA32(DDR1_DQ_48/DDR1_DQ_48)
M_B_DQ49: JDIM2801.211(DQ52) U400.BA31(DDR1_DQ_49/DDR1_DQ_49)
M_B_DQ50: JDIM2801.225(DQ55) U400.BD31(DDR1_DQ_50/DDR1_DQ_50)
M_B_DQ51: JDIM2801.224(DQ54) U400.BD32(DDR1_DQ_51/DDR1_DQ_51)
M_B_DQ52: JDIM2801.212(DQ53) U400.BA30(DDR1_DQ_52/DDR1_DQ_52)
M_B_DQ53: JDIM2801.215(DQ49) U400.BA29(DDR1_DQ_53/DDR1_DQ_53)
M_B_DQ54: JDIM2801.229(DQ51) U400.BD29(DDR1_DQ_54/DDR1_DQ_54)
M_B_DQ55: JDIM2801.228(DQ50) U400.BD30(DDR1_DQ_55/DDR1_DQ_55)
M_B_DQ56: JDIM2801.236(DQ57) U400.BG31(DDR1_DQ_56/DDR1_DQ_56)
M_B_DQ57: JDIM2801.237(DQ56) U400.BG32(DDR1_DQ_57/DDR1_DQ_57)
M_B_DQ58: JDIM2801.245(DQ62) U400.BK32(DDR1_DQ_58/DDR1_DQ_58)
M_B_DQ59: JDIM2801.249(DQ58) U400.BK31(DDR1_DQ_59/DDR1_DQ_59)
M_B_DQ60: JDIM2801.233(DQ61) U400.BG29(DDR1_DQ_60/DDR1_DQ_60)
M_B_DQ61: JDIM2801.232(DQ60) U400.BG30(DDR1_DQ_61/DDR1_DQ_61)
M_B_DQ62: JDIM2801.250(DQ59) U400.BK30(DDR1_DQ_62/DDR1_DQ_62)
M_B_DQ63: JDIM2801.246(DQ63) U400.BK29(DDR1_DQ_63/DDR1_DQ_63)
M_B_DQSN0: JDIM2801.11(DQS#0) U400.AP35(DDR0_DQSN_4/DDR1_DQSN_0)
M_B_DQSN1: JDIM2801.177(DQS#4) U400.AV34(DDR0_DQSN_5/DDR1_DQSN_1)
M_B_DQSN2: JDIM2801.32(DQS#1) U400.AL31(DDR1_DQSN_4/DDR1_DQSN_2)
M_B_DQSN3: JDIM2801.198(DQS#5) U400.AU31(DDR1_DQSN_5/DDR1_DQSN_3)
M_B_DQSN4: JDIM2801.53(DQS#2) U400.BB35(DDR0_DQSN_6/DDR1_DQSN_4)
M_B_DQSN5: JDIM2801.74(DQS#3) U400.BF34(DDR0_DQSN_7/DDR1_DQSN_5)
M_B_DQSN6: JDIM2801.219(DQS#6) U400.BC31(DDR1_DQSN_6/DDR1_DQSN_6)
M_B_DQSN7: JDIM2801.240(DQS#7) U400.BH31(DDR1_DQSN_7/DDR1_DQSN_7)
M_B_DQSN8: JDIM2801.95(DQS#8) R2838.2
M_B_DQSP0: JDIM2801.13(DQS0) U400.AP34(DDR0_DQSP_4/DDR1_DQSP_0)
M_B_DQSP1: JDIM2801.179(DQS4) U400.AV35(DDR0_DQSP_5/DDR1_DQSP_1)
M_B_DQSP2: JDIM2801.34(DQS1) U400.AL30(DDR1_DQSP_4/DDR1_DQSP_2)
M_B_DQSP3: JDIM2801.200(DQS5) U400.AU30(DDR1_DQSP_5/DDR1_DQSP_3)
M_B_DQSP4: JDIM2801.55(DQS2) U400.BB34(DDR0_DQSP_6/DDR1_DQSP_4)
M_B_DQSP5: JDIM2801.76(DQS3) U400.BF35(DDR0_DQSP_7/DDR1_DQSP_5)
M_B_DQSP6: JDIM2801.221(DQS6) U400.BC30(DDR1_DQSP_6/DDR1_DQSP_6)
M_B_DQSP7: JDIM2801.242(DQS7) U400.BH30(DDR1_DQSP_7/DDR1_DQSP_7)
M_B_DQSP8: JDIM2801.97(DQS8) R2832.2
M_B_ODT0: JDIM2801.155(ODT0) U400.AL36(DDR1_ODT_0/DDR1_ODT_0)
M_B_ODT1: JDIM2801.161(ODT1) U400.AL34(NC/DDR1_ODT_1)
M_B_PARITY: JDIM2801.143(PARITY) U400.AE34(NC/DDR1_PAR)
M_B_RAS#: JDIM2801.152(A16/RAS#) U400.AJ34(DDR1_CAB_3/DDR1_MA_16)
M_B_WE#: JDIM2801.151(A14/WE#) U400.AJ35(DDR1_CAB_2/DDR1_MA_14)
MAIN_BAT_DET#: C4721.1 PR8222.1 PR8515.1 R4765.2
MDI0+: U4000.1(MDIP0) U4001.2(TD1+)
MDI0+_1: CN4000.1(TX0+) U4001.23(MX1+)
MDI0-: U4000.2(MDIN0) U4001.3(TD1-)
MDI0-_1: CN4000.2(TX0-) U4001.22(MX1-)
MDI1+: U4000.4(MDIP1) U4001.5(TD2+)
MDI1+_1: CN4000.3(RX0+) U4001.20(MX2+)
MDI1-: U4000.5(MDIN1) U4001.6(TD2-)
MDI1-_1: CN4000.6(RX0-) U4001.19(MX2-)
MDI2+: U4000.6(MDIP2(NC)) U4001.8(TD3+)
MDI2+_1: CN4000.4(TX1+) U4001.17(MX3+)
MDI2-: U4000.7(MDIN2(NC)) U4001.9(TD3-)
MDI2-_1: CN4000.5(TX1-) U4001.16(MX3-)
MDI3+: U4000.9(MDIP3(NC)) U4001.11(TD4+)
MDI3+_1: CN4000.7(RX1+) U4001.14(MX4+)
MDI3-: U4000.10(MDIN3(NC)) U4001.12(TD4-)
MDI3-_1: CN4000.8(RX1-) U4001.13(MX4-)
ME_UNLOCK#: Q407.2(G) R4740.1 U4701.G4(GPIO64)
MIC2-VREFO: R3619.2 U3600.23(MIC2-VREFO)
MOD_ID1: R6101.2 R6104.1 U6100.29(UART_TX/GPIO_P4.0)
MOD_ID2: R6102.1 R6105.1 U6100.30(UART_RX/GPIO_P4.1)
MODEM_CLKREQ: R577.1 R4122.2 U400.CH29(GPP_H2/I2S2_TXD/CNV_BT_I2S_SDI/)
MODEM_CLKREQ_L: CN4100.14(PCM_OUT) R4122.1
MP2949A_ALT#: PR8820.1 PU8800.27(ALT#)
MP2949A_EN: PC8805.1 PR8811.1 PU8800.34(EN)
MP2949A_IMONA: PC8809.1 PR8836.1 PU8800.20(IMONA)
MP2949A_IMONB: PC8810.1 PR8838.2 PU8800.21(IMONB)
MP2949A_IMONC: PC8811.1 PR8840.2 PU8800.22(IMONC)
MP2949A_IREF: PR8831.2 PU8800.23(IREF)
MP2949A_PE: PC8807.1 PR8825.2 PR8827.2 PR8830.1 PU8800.33(PE)
MP2949A_SCL_P: PR8809.2 PU8800.31(SCL_P)
MP2949A_SCLK: PR8823.2 PU8800.25(SCLK)
MP2949A_SDA_P: PR8815.2 PU8800.30(SDA_P)
MP2949A_SDIO: PR8821.2 PU8800.26(SDIO)
MP2949A_STB: PR8812.1 PU8800.32(STB)
MP2949A_TEMP: PC8814.2 PR8847.2 PR8851.1 PR8865.1 PU8800.41(TEMP)
MP2949A_VDD18: PC8803.2 PR8852.1 PR8853.1 PR8854.1 PR8858.1 PR8860.1 PR8867.1 PU8800.24(VDD18)
MP2949A_VIN_SEN: PC8804.2 PR8807.2 PR8808.2 PU8800.43(VIN_SEN)
MP2949A_VRHOT#: PR8810.2 PU8800.29(VRHOT#)
MP2949A_VRRDY: PR8818.1 PU8800.28(VRRDY)
MSATA_DET#: Q4300.3(D) R554.2 R659.2 R4306.1 U400.CP10(GPP_E2/SATAXPCIE2/SATAGP2)
MSATA_DET#_R: CN4300.69(PEDET) Q4300.2(G) R4305.1 R4306.2
MSR_ENABLE_N: CN7700.60(GND17) R7724.1
MUX_I2C_SCL: Q5800.1(S) R5803.2 U5800.21(CSCL)
MUX_I2C_SDA: Q5800.4(S) R5802.2 U5800.22(CSDA)
MUX_SBU1: U5800.27(SBU1) U6100.36(AUX_P/GPIO_P4.2)
MUX_SBU2: U5800.26(SBU2) U6100.37(AUX_N/GPIO_P4.3)
NFC_DWL_REQ: R490.1 R491.1 U400.CC27(GPP_B15/GSPI0_CS0#)
NGFF_RESET#_R: C4208.1 CN4200.67(RESET#) Q4200.3(D) R4242.1 R4246.2
NMI_SMI_DBG#: C404.2 CN7701.10 Q4701.1(S) R484.1 U400.CC29(GPP_B20/GSPI1_CLK)
NPCE576H_AGND: C4710.1 C4711.1 C4718.2 C4719.1 C4726.1 C4727.1 R4716.2 U4701.E1(AVSS)
NUM_LOCK_LED#: C5024.2 CN7701.29 R4745.1 R5006.1 U4701.D7(KSO15/GPIO83)
OCP_CHG#: PR8221.1 PR8520.1
OCP_ID_ADC2: PR8504.1 PR8508.1 R4710.2
OCP_ID_SEL: PQ8502.2(G) PR8509.2 R4750.1 U4701.K9(GPIO91/I2C2_SDA0)
OCP_IN_ADC_R: R4707.2 U4701.K10(GPIOB2/I2C7_SDA0/D\S\R\)
OCP_PWM_OUT: PQ8503.2(G) U4701.G6(GPIO60/PWM7)
ON_OFF#: C7601.1 CN7600.18 Q7502.1(S)
ON_OFF#1: Q7501.3(D) Q7502.3(D) R7505.2 R7506.1 R7507.1
ON_OFF#1_Q: Q7501.4(S) R4754.1 R7506.2 R7705.2 R7717.2
OUT_DPST_PWM: R3405.2 R3414.2 R3416.1
OVP_DET: PQ8206.2(G) PQ8506.3(COLLECTOR) PR8242.2 PR8518.2
PCH_DISP_ON: R3410.2 U400.CG11(EDP_VDDEN) U3400.3(ON/O\F\F\)
PCH_DPST_PWM: R3416.2 U400.CH11(EDP_BKLTCTL)
PCH_KBC_CLK: PU8201.1(SMBCLK) Q4700.6(D) Q5402.6(D) R4727.2 R7633.1 U4701.K8(GPIO90/I2C1_SCL0) U5301.1(SCL/SPC)
PCH_KBC_CLK_C: C7622.2 CN7602.1 R7633.2
PCH_KBC_DATA: CN7602.2 PU8201.5(SMBDATA) Q4700.3(D) Q5402.3(D) R4726.2 U4701.K7(GPIO87/I2C1_SDA0) U5301.4(SDA/SDI/SDO)
PCH_LAN_RST#: R477.1 U400.CG12(GPP_C12/UART1_RXD/ISH_UART1_RXD)
PCH_LVDS_BLON: R3404.2 R3415.2 R3423.2 U400.CK11(EDP_BKLTEN)
PCH_OPI_RCOMP: R412.2 U400.BW25(PCH_OPIRCOMP)
PCH_PWROK: R451.1 R452.1 R466.1 U400.BP31(PCH_PWROK) U401.4(OUT Y)
PCH_SLP_S0IX#: R4756.2 TP4706.1 U4701.J3(GPIO67/PS2_CLK0)
PCH_SLP_SUS#: U400.BU29(SLP_SUS#) U4701.J6(GPIO75/32KHZ_OUT)
PCH_SMB_CLK: Q401.3(D) R421.2 U400.CK14(GPP_C0/SMBCLK)
PCH_SMB_DATA: Q401.6(D) R422.2 U400.CH15(GPP_C1/SMBDATA)
PCH_SMBCLK: CN7700.53(SCL) JDIM2800.253(SCL) JDIM2801.253(SCL) Q401.4(S) R447.2
PCH_SMBDATA: CN7700.51(SDA) JDIM2800.254(SDA) JDIM2801.254(SDA) Q401.1(S) R450.2
PCH_SPI1_CLK: R5102.1 R5110.2 R5606.1 TP5601.1 U5100.19(SCLK) U5600.6(SCK)
PCH_SPI1_CLK_E1: R4709.2 R5110.1
PCH_SPI1_CLK_E2: R4709.1 U4701.F12(SHD_SCLK/GPIOA2)
PCH_SPI1_CLK_R1: C401.1 R425.2 R5606.2
PCH_SPI1_CLK_R2: R425.1 U400.CH37(SPI0_CLK)
PCH_SPI1_SI: R5112.2 R5602.1 R5608.1 R7727.1 TP5602.1 U5100.21(MOSI) U5600.5(SI)
PCH_SPI1_SI_E1: R4711.2 R5112.1
PCH_SPI1_SI_E2: R4711.1 U4701.H11(SHD_MOSI_DIO0/GPIOA4/TB1_TACH2P)
PCH_SPI1_SI_R1: R428.2 R5608.2
PCH_SPI1_SI_R2: R428.1 U400.CF36(SPI0_MOSI)
PCH_SPI1_SO: R5111.2 R5607.1 TP5603.1 U5100.24(MISO) U5600.2(SO)
PCH_SPI1_SO_E1: R4713.2 R5111.1
PCH_SPI1_SO_E2: R4713.1 U4701.G12(SHD_MISO_DIO1/GPIO96)
PCH_SPI1_SO_R1: R427.2 R5607.2
PCH_SPI1_SO_R2: R427.1 U400.CF37(SPI0_MISO)
PCH_SPI_CS0#: R5601.2 R5611.1 R5614.2 TP5600.1 U5600.1(CE#)
PCH_SPI_CS0#_E1: R4757.2 R5614.1
PCH_SPI_CS0#_E2: R4757.1 U4701.G11(S\H\D\_\C\S\0\/GPIOA0)
PCH_SPI_CS0#_R1: R433.2 R5611.2
PCH_SPI_CS0#_R2: R433.1 U400.CG36(SPI0_CS0#)
PCH_SPI_IO2: R5604.1 R5605.1 R5609.2 R5612.2 R7724.2 U5600.3(WP#)
PCH_SPI_IO2_R1: R430.2 R5609.1
PCH_SPI_IO2_R2: R430.1 U400.CF34(SPI0_IO2)
PCH_SPI_IO3: R5603.2 R5610.2 R5613.2 U5600.7(HOLD#)
PCH_SPI_IO3_R1: R432.2 R5610.1
PCH_SPI_IO3_R2: R432.1 U400.CG34(SPI0_IO3)
PCH_TCK: CN7700.55(TCK1) R7735.2 U400.W6(PCH_TCK)
PCH_TDI: CN7700.56(TDI) Q7700.3(D) R7737.2 U400.U5(PCH_TDI)
PCH_TDO: CN7700.52(TDO) Q7701.3(D) R7738.2 U400.W5(PCH_TDO)
PCH_TMS: CN7700.58(TMS) Q7700.6(D) R7736.2 U400.P5(PCH_TMS)
PCH_WAKE#: Q4001.3(COLLECTOR) Q4104.3 R456.2 R462.2 R4006.1 R4105.2 R4212.2
PCH_WAKE#_C: CN4200.23(WAKE_OUT_WWAN) R4212.1
PCH_WAKE#_R: R462.1 U400.BU30(WAKE#)
PCH_WLAN_RST#: R478.2 U400.CH12(GPP_C13/UART1_TXD/ISH_UART1_TXD)
PCI_PLTRST#: C4106.2 CN4100.52(PERST0#) CN4300.50(PERST#/NC_50) Q4701.2(G) Q5100.2(G) R467.2 R469.2 R4215.1 R5103.2 U402.4(O) U4000.19(PERSTB) U4201.1(B)
PCI_PLTRST#_R: CN4200.50(NC#12) R4215.2 R4240.2 U4201.4(Y)
PCIE_CLKREQ5#: C4238.1 CN4200.52(NC#13) R593.1 U400.CF31(GPP_B10/SRCCLKREQ5#)
PCIE_CLKREQ_LAN#: C4035.1 R595.1 U400.CF30(GPP_B7/SRCCLKREQ2#) U4000.12(CLKREQB)
PCIE_CLKREQ_SSD#: C4318.2 CN4300.52(CLKREQ#/NC_52) R597.1 U400.CF32(GPP_B5/SRCCLKREQ0#)
PCIE_CLKREQ_WLAN#: Q4101.1(S) R594.1 R4103.2 U400.CE31(GPP_B8/SRCCLKREQ3#)
PCIE_RCOMPN: R567.2 U400.CE6(P\C\I\E\_\R\C\O\M\P\)
PCIE_RCOMPP: R567.1 U400.CE5(PCIE_RCOMP_P)
PCIE_RXN5_LAN: C4002.2 U400.BP5(PCIE9_RXN)
PCIE_RXN5_LAN_L: C4002.1 U4000.18(HSON)
PCIE_RXN6_WLAN: CN4100.43(PERN0) U400.BN6(PCIE10_RXN)
PCIE_RXN8_SSD: C4301.2 U400.BL6(PCIE12_RXN/SATA1A_RXN)
PCIE_RXN9_SSD: CN4300.5(PERN3) U400.BK6(PCIE13_RXN)
PCIE_RXN10_SSD: CN4300.17(PERN2) U400.BJ6(PCIE14_RXN)
PCIE_RXN10_WWAN: CN4200.41(NC#5) U400.BY7(PCIE3_RXN/USB31_3_RXN)
PCIE_RXN11_SSD: R4308.2 U400.BG5(PCIE15_RXN/SATA1B_RXN)
PCIE_RXN11_SSD_C: CN4300.29(PERN1) R4308.1
PCIE_RXN12_SSD: R4304.2 U400.BE5(PCIE16_RXN/SATA2_RXN)
PCIE_RXN12_SSD_C: C4301.1 CN4300.43(PERP0/SATA-B-) R4304.1
PCIE_RXP5_LAN: C4003.2 U400.BP6(PCIE9_RXP)
PCIE_RXP5_LAN_L: C4003.1 U4000.17(HSOP)
PCIE_RXP6_WLAN: CN4100.41(PERP0) U400.BN5(PCIE10_RXP)
PCIE_RXP8_SSD: C4300.2 U400.BL5(PCIE12_RXP/SATA1A_RXP)
PCIE_RXP9_SSD: CN4300.7(PERP3) U400.BK5(PCIE13_RXP)
PCIE_RXP10_SSD: CN4300.19(PERP2) U400.BJ5(PCIE14_RXP)
PCIE_RXP10_WWAN: CN4200.43(NC#6) U400.BY6(PCIE3_RXP/USB31_3_RXP)
PCIE_RXP11_SSD: R4309.2 U400.BG6(PCIE15_RXP/SATA1B_RXP)
PCIE_RXP11_SSD_C: CN4300.31(PERP1) R4309.1
PCIE_RXP12_SSD: R4302.2 U400.BE6(PCIE16_RXP/SATA2_RXP)
PCIE_RXP12_SSD_C: C4300.1 CN4300.41(PERN0/SATA-B+) R4302.1
PCIE_TXN5_LAN: C416.2 U4000.14(HSIN)
PCIE_TXN5_LAN_C: C416.1 U400.BR2(PCIE9_TXN)
PCIE_TXN6_WLAN: C418.2 CN4100.37(PETN0)
PCIE_TXN6_WLAN_C: C418.1 U400.BR4(PCIE10_TXN)
PCIE_TXN8_SSD: C4306.2 U400.BN2(PCIE12_TXN/SATA1A_TXN)
PCIE_TXN9_SSD: C4314.2 U400.BM4(PCIE13_TXN)
PCIE_TXN9_SSD_C: C4314.1 CN4300.11(PETP3)
PCIE_TXN10_SSD: C4316.2 U400.BL2(PCIE14_TXN)
PCIE_TXN10_SSD_C1: C4316.1 CN4300.23(PETP2)
PCIE_TXN10_WWAN: C407.1 CN4200.47(NC#7)
PCIE_TXN10_WWAN_C: C407.2 U400.BY4(PCIE3_TXN/USB31_3_TXN)
PCIE_TXN11_SSD: C4308.2 U400.BL4(PCIE15_TXN/SATA1B_TXN)
PCIE_TXN11_SSD_C: C4308.1 CN4300.35(PETN1)
PCIE_TXN12_SSD: C4310.2 U400.BJ4(PCIE16_TXN/SATA2_TXN)
PCIE_TXN12_SSD_C: C4306.1 C4310.1 CN4300.47(PETN0/SATA-A-)
PCIE_TXP5_LAN: C417.2 U4000.13(HSIP)
PCIE_TXP5_LAN_C: C417.1 U400.BR1(PCIE9_TXP)
PCIE_TXP6_WLAN: C419.2 CN4100.35(PETP0)
PCIE_TXP6_WLAN_C: C419.1 U400.BR3(PCIE10_TXP)
PCIE_TXP8_SSD: C4307.2 U400.BN1(PCIE12_TXP/SATA1A_TXP)
PCIE_TXP9_SSD: C4315.2 U400.BM3(PCIE13_TXP)
PCIE_TXP9_SSD_C: C4315.1 CN4300.13(PETN3)
PCIE_TXP10_SSD: C4317.2 U400.BL1(PCIE14_TXP)
PCIE_TXP10_SSD_C1: C4317.1 CN4300.25(PETN2)
PCIE_TXP10_WWAN: C409.1 CN4200.49(NC#8)
PCIE_TXP10_WWAN_C: C409.2 U400.BY3(PCIE3_TXP/USB31_3_TXP)
PCIE_TXP11_SSD: C4309.2 U400.BL3(PCIE15_TXP/SATA1B_TXP)
PCIE_TXP11_SSD_C: C4309.1 CN4300.37(PETP1)
PCIE_TXP12_SSD: C4311.2 U400.BJ3(PCIE16_TXP/SATA2_TXP)
PCIE_TXP12_SSD_C: C4307.1 C4311.1 CN4300.49(PETP0/SATA-A+)
PCIE_WAKE#_R: Q4001.1(EMITTER) R4005.1 R4006.2 U4000.21(LANWAKEB)
PD_ADP_DIS1: PQ8005.2(G) PR8013.2 U4701.H7(GPIOC5/K\B\R\S\T\)
PD_I2C_SCL: R6118.2 R6120.1 R7731.1 U6100.17(I2C_SCL_SCB1_EC/GPIO_P6.1)
PD_I2C_SCL3: R4705.2 R6118.1 U4701.F8(GPIOD1/I2C3_SCL0)
PD_I2C_SCL_C: CN7702.2 R7731.2
PD_I2C_SDA: R6117.2 R6119.1 R7730.1 U6100.16(I2C_SDA_SCB1_EC/GPIO_P6.0)
PD_I2C_SDA3: R4704.2 R6117.1 U4701.F9(GPIOD0/I2C3_SDA0)
PD_I2C_SDA_C: CN7702.1 R7730.2
PDB: C3611.1 D3604.2(ANODE) Q3600.3(COLLECTOR) R3620.2 R3621.1 U3600.40(PDB)
PIRQA#: R496.1 U400.CC32(GPP_A7/PIRQA#/GSPI0_CS1#)
PLAY_MUTE_LED: Q5001.3(D) R5007.1
PLAY_MUTE_LED_CNTR: Q5001.2(G) R3610.1 R5010.1 U3600.10(DC DET/EAPD)
PLT_DET: R4729.2 R4730.2 U4701.K11(GPIOA5/A20M/P\V\T\_\C\S\1\)
PLT_ID1: R512.2 R513.1 U400.CJ17(GPP_F8/CNV_MFUART2_RXD)
PLT_ID2: R515.2 R516.1 R3425.2 U400.CH17(GPP_F9/CNV_MFUART2_TXD)
PLT_ID4: R529.2 R652.1 U400.CF17(GPP_F23/A4WP_PRESENT)
PLT_RST#_KBC: R4761.2 U4701.J5(GPIO76/E\C\_\S\C\I\)
PLTRST#: Q408.2(G) R469.1 R657.2 R4761.1 U402.1(I1) U402.2(I0)
PLTRST#_PCH: R657.1 U400.BJ35(GPP_B13/PLTRST#)
PM_EXTTS#0: JDIM2800.134(EVENT#) R2800.2
PM_EXTTS#1: JDIM2801.134(EVENT#) R9648.2
PM_PWROK: R466.2 R4747.1 U400.CR10(SYS_PWROK) U4701.K4(GPIO61/R\E\S\E\T\_\O\U\T\)
PM_SLP_A#: PR8114.2 R7702.1 U400.BU37(GPD6/SLP_A#)
PM_THRMTRIP#: R405.1 U400.BJ1(THRMTRIP#)
PRE: R3504.1 R3505.1 U3501.15(PRE)
PROC_POPIRCOMP: R411.1 U400.BP27(PROC_POPIRCOMP)
PVADPTR: C7824.2 C7825.2 C7827.2 C7828.2 C7829.2 C7830.2 C7831.2 C7832.2 PC8200.1 PC8201.2 PD8001.1 PD8202.2(ANODE) PQ8006.1(S1) PQ8006.2(S2) PQ8006.3(S3) PQ8007.1(S1) PQ8007.2(S2) PQ8007.3(S3) PQ8012.1(E1) PQ8013.1(E1) PR8200.1 PR8201.2 PR8209.2 PR8240.1 PR8500.1 PR8511.2
PVCORE_PG: PR8816.2 PR8818.2 R449.1 U401.1(INB)
PVT_CS#: TP4701.1 U4701.L10(P\V\T\_\C\S\0\/GPIO97)
PVT_MOSI_L: TP4703.1 U4701.K12(PVT_MOSI_DIO0/SPIP_MOSI/GPIOA3)
PVT_SCLK_L: TP4702.1 U4701.L12(PVT_SCLK/SPIP_SCLK/GPIOA1)
PVT_SPI_MISO: TP4704.1 U4701.M12(PVT_MISO_DIO1/SPIP_MISO/GPIO95)
PWM_LED#: Q5003.2(G) U4701.H10(GPIOC2/PWM1/I2C6_SCL0)
PWR1_3290_A3: R6320.1 U6302.A3(ILIM)
PWR1_3290_A4: R6319.1 U6302.A4(F\L\T\)
PWR1_3290_C4: R6322.1 U6302.C4(FO)
PWR1_3290_D4: C6304.1 U6302.D4(CAP)
PWR1_3290_EN: Q6301.3(D) R6323.2 R6324.1 U6302.B4(EN)
PWR_BTN_OUT#: R4753.2 R4755.1 U400.BU28(GPD3/PWRBTN#) U4701.D9(KSO16/GPIO03)
PWR_GOOD_3: C4729.1 PC8104.2 PR8117.2 PR8119.1 PU8100.1(OUT) Q402.2(G) Q7700.2(G) Q7700.5(G) Q7701.2(G) Q7701.5(G) R3311.1 U4701.M4(PWRGD/GPIO72)
PWRBTN#: C4722.2 R4752.2 R4754.2 R4755.2 U4701.G5(GPIO73/PS2_CLK3/TA2)
R_SPK+: L3603.2 U3600.38(SPK-R+)
R_SPK+_R: C3638.2 CN3600.1 L3603.1
R_SPK-: L3602.2 U3600.37(SPK-R-)
R_SPK-_R: C3637.2 CN3600.2 L3602.1
REC_MUTE_LED: Q5000.3(D) R5002.1
RECORD_MUTE_LED_CNTRL: Q5000.2(G) R5009.1 U3600.24(LINE1-VREFO-L)
REGN6V: PC8210.1 PD8203.1 PU8200.24(REGN)
REQ_WLAN#: C4107.1 CN4100.53(CLKREQ0#) Q4101.3(D) R4101.2 R4103.1
REXT_PS: R5800.2 U5800.2(REXT)
RSMRST#: D4700.2 R4762.2 R7720.1 U400.BR36(RSMRST#)
RSMRST#_R: R4762.1 R4763.1 U4701.M10(GPIO84)
RSMRST_PG: D4700.1 PR8118.2 PR8120.2 PU8100.7(OUT) U4701.H9(GPIOC1/I2C6_SDA0)
RTC_DET#: Q7702.3(D) R444.1 U400.BV29(GPP_A0/RCIN#/TIME_SYNC1)
RTC_RST#: C426.1 C427.1 Q7500B.3(D) R599.1 R7704.1 U400.BR34(RTCRST#)
RTC_X1: C421.1 R586.1 U400.BN31(RTCX1) Y401.1
RTC_X2: C422.1 R586.2 U400.BN32(RTCX2) Y401.2
RUNSCI_EC#: R479.1 U400.CM12(GPP_C23/UART2_CTS#)
S_SD_CD#: CN7601.20 U7600.23(CCD#)
S_SD_CLK: R7625.1 U7600.18(CCLK)
S_SD_CLK_C: C7618.2 CN7601.12 R7625.2
S_SD_CMD: CN7601.14 U7600.19(CCMD)
S_SD_DATA0: R7638.2 U7600.17(CDATA0)
S_SD_DATA0_C: C7626.2 CN7601.10 R7638.1
S_SD_DATA1: R7639.2 U7600.16(CDATA1)
S_SD_DATA1_C: C7623.2 CN7601.8 R7639.1
S_SD_DATA2: R7641.2 U7600.21(CDATA2)
S_SD_DATA2_C: C7624.2 CN7601.18 R7641.1
S_SD_DATA3: R7640.2 U7600.20(CDATA3)
S_SD_DATA3_C: C7625.2 CN7601.16 R7640.1
S_SD_WP: CN7601.6 R7600.2 R7615.1
SAR_DPR: CN4200.25(BODYSAR_DET) R4214.2
SATA_LED#_C: CN4300.10(DAS/DSS#) D4300.1
SATA_RXN7: C4405.1 U400.BN10(PCIE11_RXN/SATA0_RXN)
SATA_RXN7_C: C4405.2 CN4400.6
SATA_RXP7: C4404.1 U400.BN8(PCIE11_RXP/SATA0_RXP)
SATA_RXP7_C: C4404.2 CN4400.5
SATA_TXN7: C4406.1 U400.BN4(PCIE11_TXN/SATA0_TXN)
SATA_TXN7_C: C4406.2 CN4400.8
SATA_TXP7: C4407.1 U400.BN3(PCIE11_TXP/SATA0_TXP)
SATA_TXP7_C: C4407.2 CN4400.9
SCL_BAT_CHG: PD8500.3 PR8220.2 PR8516.2 R4724.2 U4701.C12(GPIOB5/I2C0_SCL0)
SD_CD#_BH: D7601.1(CATHODE) U7600.24(HCD#)
SD_CD#_PCH: D7601.2(ANODE) U400.CH35(GPP_G5/SD_CD#)
SD_CLK: C7621.1 R623.2 U7600.4(HCLK)
SD_CLK_R: R623.1 U400.CK36(GPP_G6/SD_CLK)
SD_CMD: R7624.2 U400.CH36(GPP_G0/SD_CMD)
SD_CMD_C: R7624.1 U7600.3(HCMD)
SD_DATA0: R7626.2 U400.CL35(GPP_G1/SD3_DATA0)
SD_DATA0_C: R7626.1 U7600.5(HDATA0)
SD_DATA1: R7627.2 U400.CL36(GPP_G2/SD3_DATA1)
SD_DATA1_C: R7627.1 U7600.6(HDATA1)
SD_DATA2: R7622.2 U400.CM35(GPP_G3/SD3_DATA2)
SD_DATA2_C: R7622.1 U7600.1(HDATA2)
SD_DATA3: R7623.2 U400.CN35(GPP_G4/SD_DATA3)
SD_DATA3_C: R7623.1 U7600.2(HDATA3)
SD_PWR_EN#: D7600.1(CATHODE) R574.1 U400.BW36(GPP_A17/SD_VDD1_PWR_EN#/ISH_GP7)
SD_PWR_EN#_R: R7610.1 R7611.1 U7600.11(SD_PWR_EN#)
SD_PWR_POL: R7621.1 U7600.9(SD_PWR_POL)
SD_WP_BH: D7602.1(CATHODE) U7600.25(HWP)
SD_WP_PCH: D7602.2(ANODE) U400.CK34(GPP_G7/SD_WP)
SDA_BAT_CHG: PD8501.3 PR8219.2 PR8517.2 R4725.2 U4701.B12(GPIOB4/I2C0_SDA0)
SG_IN: R521.2 R522.1 U400.CN20(GPP_F3)
SHD_DIO2: R4773.1 U4701.E11(GPIO93/TA1_TACH1/SHD_DIO2)
SHD_DIO2_E1: R4773.2 R5612.1
SHD_DIO3: R4774.1 U4701.J11(GPIOA7/PS2_DAT3/TB2/SHD_DIO3)
SHD_DIO3_E1: R4774.2 R5613.1
SLEEVE_C: C3640.2 CN3601.3 D3605.1 R3600.1
SLEEVE_L: R3600.2 R3619.1 U3600.14(SLEEVE/MIC2-R)
SLP_LAN#: PR9508.2 R648.2 R4767.1
SLP_LAN#_C: R648.1 U400.BT31(SLP_LAN#)
SLP_S3#_3R: CN7701.11 PQ8703.2(G) PR8113.2 PR9215.2 PR9509.2 PR9510.2 PR9610.2 PR9617.2 PU9202.1(INB) PU9600.1(A) PU9600.2(B) PU9601.2(B) R655.1 R4741.1
SLP_S3#_3R_3: PC9524.1 PR9505.1 PR9509.1
SLP_S3#_3R_5: PC9525.1 PR9506.2 PR9510.1
SLP_S3#_3R_KBC: R4741.2 U4701.D6(KSO14/GPIO82)
SLP_S3#_3R_PCH: R655.2 U400.BU36(GPD4/SLP_S3#)
SLP_S3_5R: PQ8703.5(G) PQ8703.6(D) PR8718.1 R4145.1
SLP_S4#_3R: CN7600.16 CN7701.13 D3300.1 PD8700.2(ANODE) PR8721.1 PR9608.2 Q4110.2 R656.1 R3301.1 R4739.1 U5701.4(EN) U5801.4(EN)
SLP_S4#_3R_PCH: R656.2 U400.BU27(GPD5/SLP_S4#)
SLP_S4#_KBC: R4739.2 U4701.F11(GPIOA6/PS2_CLK3/TA2/S\H\D\_\C\S)
SLP_S4_5R: Q4102.2(G) Q4110.3 R4145.2 R4146.1
SLP_S5#_3R: R7700.1 U400.BT29(GPD10/SLP_S5#)
SLP_WLAN_PCH#: TP406.1 U400.BT30(GPD9/SLP_WLAN#)
SM_INTRUDER#: R461.1 U400.BR35(INTRUDER#)
SM_RCOMP_0: R545.1 U400.BN28(DDR_COMP_0)
SM_RCOMP_1: R546.1 U400.BN27(DDR_COMP_1)
SM_RCOMP_2: R547.1 U400.BN29(DDR_COMP_2)
SM_VREF: C2828.1 R2813.1 U400.F36(DDR_VREF_CA)
SMB_ME0_CLK: R419.2 U400.CH14(GPP_C3/SML0CLK)
SMB_ME0_DAT: R420.2 U400.CF15(GPP_C4/SML0DATA)
SMB_PCH_CLK: Q4700.1(S) R417.2 U400.CN15(GPP_C6/SML1CLK)
SMB_PCH_DAT: Q4700.4(S) R418.2 U400.CM15(GPP_C7/SML1DATA)
SMC: PC8507.2 PCN8500.5(SMC) PR8516.1
SMD: PC8508.2 PCN8500.6(SMD) PR8517.1
SMDDR_VREF_DQ0_M3: TP418.1 U400.D35(DDR0_VREF_DQ_0)
SMDDR_VREF_DQ1_M1: C2855.1 C2856.1 R2822.2 R2839.1 R2840.2 R2841.2
SMDDR_VREF_DQ1_M3: C2857.1 R2841.1 U400.E36(DDR1_VREF_DQ)
SN3V: PC8610.1 PR8605.1
SP_CLK: R4720.2 U4701.H2(GPIO62/PS2_CLK1)
SP_DATA: R4722.2 U4701.J2(GPIO63/PS2_DAT1)
SPI_TPM_CS#: R5101.2 TP5100.1 U400.CH34(SPI0_CS2#) U5100.20(CS#)
SRTC_RST#: C430.1 Q7500A.3(D) R601.1 U400.BR37(SRTCRST#)
SUSCLK32_KBC: R4120.1 U400.BT32(GPD8/SUSCLK) U4701.L5(GPIOE7/32KCLKIN)
SUSCLK32_KBC_WLAN: CN4100.50(SUSCLK(32KHZ)) R4120.2
SY8270C_LX: PC8629.2 PL8601.1 PR8615.2 PU8601.2(LX1) PU8601.12(LX2)
SY8270CBST: PC8629.1 PU8601.13(BS)
SY8270CEN: PC8637.1 PR8616.1 PR8628.2 PU8601.6(EN1)
SY8270CFB: PR8619.1 PU8601.7(FF)
SY8270CFB_S: PC8641.1 PR8619.2
SY8270CLDOEN: PR8625.1 PR8626.2 PU8601.5(EN2)
SY8270CPG: PR8627.2 PU8601.4(PG)
SY8270CVOUT: PC8641.2 PR8617.2 PU8601.8(OUT)
SY8286BBST: PR8601.1 PU8600.1(BS)
SY8286BBST_S: PC8608.1 PR8601.2
SY8286BBSW: PC8608.2 PL8600.1 PR8605.2 PU8600.6(LX#1) PU8600.19(LX#2) PU8600.20(LX#3)
SY8286BEN: PC8609.1 PR8602.2 PR8604.1 PU8600.12(EN1)
SY8286BFB: PR8608.1 PU8600.13(FF)
SY8286BFB_S: PC8620.1 PR8608.2
SY8286BLDOEN: PR8609.1 PR8610.2 PU8600.11(EN2)
SY8286BPG: PR8603.2 PU8600.9(PG)
SY8286BVOUT: PC8620.2 PR8606.1 PU8600.14(OUT)
TACH_FAN_IN: C5403.1 CN5400.2 R5402.2 U4701.E10(GPIOD3/TB1_TACH2PWM_IN)
THERM_SCI#: R414.2 U400.CE9(GPP_E3/CPU_GP0) U5400.6(ALERT#)
THERM_SCL: C5303.1 Q5402.1(S) R5408.2 U5300.1(SCL/SPC) U5400.8(SCLK)
THERM_SDA: C5302.1 Q5402.4(S) R5407.2 U5300.4(SDA/SDI/SDO) U5400.7(SDA)
THERMDA_1: C5406.1 Q5401.2(BASE) Q5401.3(COLLECTOR) U5400.2(DXP)
THERMDC_1: C5406.2 Q5401.1(EMITTER) U5400.3(DXN)
TLS_ENCRYPTION: R424.2 U400.CJ15(GPP_C2/SMBALERT#)
TOUCH_INT#: CN3400.39 R3420.2 U400.CM14(GPP_C11/UART0_CTS#)
TOUCH_RST#: CN3400.26 R3428.2 U400.CG14(GPP_C15/UART1_CTS#/ISH_UART1_CT)
TP_SCAN_DISABLE#: CN6200.8 D6200.2 R6213.2 U4701.D8(KSO17/GPIOB1)
TPCLK-1: C6202.1 CN6200.6 R6211.2
TPDATA-1: C6203.1 CN6200.5 R6212.2
TPM_PIRQ#: R5100.2 U400.CG25(GPP_D4/IMGCLKOUT0/BK4/SBK4) U5100.18(PIRQ)
TPM_PLTRST#: Q5100.3(D) R5103.1 R5106.2 U5100.17(RST#)
TPM_PP: R5105.1 R5107.1 U5100.7(PP)
TRA_V_DAC: C4023.1 U4001.1(TCT1) U4001.4(TCT2) U4001.7(TCT3) U4001.10(TCT4)
TX0_HDMI+: CN3500.7(D0+) R3502.1 U3501.22(OUT_D0P)
TX0_HDMI-: CN3500.9(D0-) R3502.2 U3501.21(OUT_D0N)
TX1_HDMI+: CN3500.4(D1+) R3501.1 U3501.24(OUT_D1P)
TX1_HDMI-: CN3500.6(D1-) R3501.2 U3501.23(OUT_D1N)
TX2_HDMI+: CN3500.1(D2+) R3500.1 U3501.27(OUT_D2P)
TX2_HDMI-: CN3500.3(D2-) R3500.2 U3501.26(OUT_D2N)
TXC_HDMI+: CN3500.10(CK+) R3503.1 U3501.19(OUT_CKP)
TXC_HDMI-: CN3500.12(CK-) R3503.2 U3501.18(OUT_CKN)
TXLOUT0+: C3416.1 CN3400.13
TXLOUT0-: C3417.1 CN3400.14
TXLOUT1+: C3414.1 CN3400.16
TXLOUT1-: C3415.1 CN3400.17
TYPEC1_USB0: PQ8001.5(D) PQ8006.5(D) PQ8008.3(D) PR8246.2
TYPEC3_RX1N: C5828.1 U5800.31(RX1N)
TYPEC3_RX1N_C: C5828.2 CN6300.B10(RX1N) R6330.1 U6303.2(IN2) U6303.9(NC_2)
TYPEC3_RX1P: C5827.1 U5800.30(RX1P)
TYPEC3_RX1P_C: C5827.2 CN6300.B11(RX1P) R6329.1 U6303.1(IN1) U6303.10(NC_1)
TYPEC3_RX2N: C5830.1 U5800.39(RX2N)
TYPEC3_RX2N_C: C5830.2 CN6300.A10(RX2N) R6331.1 U6301.2(IN2) U6301.9(NC_2)
TYPEC3_RX2P: C5829.1 U5800.40(RX2P)
TYPEC3_RX2P_C: C5829.2 CN6300.A11(RX2P) R6332.1 U6301.1(IN1) U6301.10(NC_1)
TYPEC3_TX1N: C5816.2 U5800.34(TX1N)
TYPEC3_TX1N_C: C5816.1 CN6300.A3(TX1N) R6325.1 U6301.4(IN3) U6301.7(NC_3)
TYPEC3_TX1P: C5815.2 U5800.33(TX1P)
TYPEC3_TX1P_C: C5815.1 CN6300.A2(TX1P) R6326.1 U6301.5(IN4) U6301.6(NC_4)
TYPEC3_TX2N: C5820.2 U5800.36(TX2N)
TYPEC3_TX2N_C: C5820.1 CN6300.B3(TX2N) R6328.1 U6303.4(IN3) U6303.7(NC_3)
TYPEC3_TX2P: C5819.2 U5800.37(TX2P)
TYPEC3_TX2P_C: C5819.1 CN6300.B2(TX2P) R6327.1 U6303.5(IN4) U6303.6(NC_4)
TYPEC_CC1: C6105.2 CN6300.A5(CC1) D6303.1 U6100.9(CC1)
TYPEC_CC2: C6104.2 CN6300.B5(CC2) D6304.1 U6100.7(CC2)
TYPEC_P_EN: Q6301.2(G) R6116.2 U6100.11(VBUS_P_CTRL)
TYPEC_SBU1: CN6300.A8(RFU1) D6301.1 R6300.2 U6100.35(SBU1)
TYPEC_SBU2: CN6300.B8(RFU2) D6302.1 R6301.2 U6100.34(SBU2)
TYPEC_VBUS: C6302.2 D6300.1 PC8003.1 PC8004.1 PQ8001.1(S1) PQ8001.2(S2) PQ8001.3(S3) PQ8003.1(S) PR8003.2 PR8005.2 PR8007.1 R6111.2 R6302.2 R6303.2 U6302.C2(VBUS #1) U6302.D1(VBUS #2) U6302.D2(VBUS #3)
TYPEC_VBUS_C: C6303.2 CN6300.A4(VBUS_1) CN6300.A9(VBUS_2) CN6300.B4(VBUS_3) CN6300.B9(VBUS_4) R6302.1 R6303.1
UART0_RXD: R7709.2 R7713.1 U400.CR14(GPP_C8/UART0_RXD)
UART0_RXD_R: CN7701.17 R7703.1 R7709.1
UART0_TXD: R7707.2 R7714.1 U400.CP14(GPP_C9/UART0_TXD)
UART0_TXD_R: CN7701.16 R7705.1 R7707.1
UIM_CLK: CN4200.32(SIM_CLK) CN4201.3(CLK)
UIM_DATA: CN4200.34(SIM_IO) CN4201.7(I_O) R4222.1
UIM_RESET: CN4200.30(SIM_RST) CN4201.2(RST)
UIM_VPP: CN4201.6(VPP) TP4200.1
ULT_EDP_HPD: CN3400.10 R541.1 R542.1 U400.CM7(GPP_E17/EDP_HPD/DISP_MISC4)
USB2_ID: R563.1 U400.CE8(USB2_ID)
USB2_VBUSSENSE: R564.2 U400.CC6(USB2_VBUSSENSE)
USB30_RX1+: CN5701.6 U400.CB6(PCIE1_RXP/USB31_1_RXP) U5702.2(IN2) U5702.9(NC_2)
USB30_RX1-: CN5701.5 U400.CB5(PCIE1_RXN/USB31_1_RXN) U5702.1(IN1) U5702.10(NC_1)
USB30_RX3+: CN5700.6 U400.BY9(PCIE2_RXP/USB31_2_RXP/SSIC_1_RX) U5700.2(IN2) U5700.9(NC_2)
USB30_RX3-: CN5700.5 U400.BY8(PCIE2_RXN/USB31_2_RXN/SSIC_1_RX) U5700.1(IN1) U5700.10(NC_1)
USB30_RX4+: C5813.1 U400.BW5(PCIE4_RXP/USB31_4_RXP)
USB30_RX4+_C: C5813.2 U5800.5(SSRXP)
USB30_RX4-: C5814.1 U400.BW6(PCIE4_RXN/USB31_4_RXN)
USB30_RX4-_C: C5814.2 U5800.4(SSRXN)
USB30_TX1+: C5712.1 U400.CA3(PCIE1_TXP/USB31_1_TXP)
USB30_TX1+_C: C5712.2 CN5701.9 U5702.5(IN4) U5702.6(NC_4)
USB30_TX1-: C5711.1 U400.CA4(PCIE1_TXN/USB31_1_TXN)
USB30_TX1-_C: C5711.2 CN5701.8 U5702.4(IN3) U5702.7(NC_3)
USB30_TX3+: C5704.1 U400.CA1(PCIE2_TXP/USB31_2_TXP/SSIC_1_TX)
USB30_TX3+_C: C5704.2 CN5700.9 U5700.5(IN4) U5700.6(NC_4)
USB30_TX3-: C5703.1 U400.CA2(PCIE2_TXN/USB31_2_TXN/SSIC_1_TX)
USB30_TX3-_C: C5703.2 CN5700.8 U5700.4(IN3) U5700.7(NC_3)
USB30_TX4+: C5817.1 U400.BW1(PCIE4_TXP/USB31_4_TXP)
USB30_TX4+_C: C5817.2 U5800.8(SSTXP)
USB30_TX4-: C5818.1 U400.BW2(PCIE4_TXN/USB31_4_TXN)
USB30_TX4-_C: C5818.2 U5800.7(SSTXN)
USB_BIAS: R566.1 U400.CC5(USB2_COMP)
USB_C_INT#: R4715.1 U4701.A11(GPIOE2/JTAG_TDI1)
USB_CYPRESS_BOT_DN: R6318.2 U6100.25(DMINUS_BOT)
USB_CYPRESS_BOT_DP: R6317.2 U6100.26(DPLUS_BOT)
USB_CYPRESS_BOT_L_DN: CN6300.B7(DN2) R6318.1 U6300.2(IN2) U6300.9(NC_2)
USB_CYPRESS_BOT_L_DP: CN6300.B6(DP2) R6317.1 U6300.1(IN1) U6300.10(NC_1)
USB_CYPRESS_TOP_DN: R6316.2 U6100.27(DMINUS_TOP)
USB_CYPRESS_TOP_DP: R6315.2 U6100.28(DPLUS_TOP)
USB_CYPRESS_TOP_L_DN: CN6300.A7(DN1) R6316.1 U6300.4(IN3) U6300.7(NC_3)
USB_CYPRESS_TOP_L_DP: CN6300.A6(DP1) R6315.1 U6300.5(IN4) U6300.6(NC_4)
USBP1+: L5701.2 R5701.1 U400.CE4(USB2_1P)
USBP1+_C: C5713.1 CN5701.3 L5701.1 R5701.2
USBP1-: L5701.3 R5700.1 U400.CE3(USB2_1N)
USBP1-_C: C5713.2 CN5701.2 L5701.4 R5700.2
USBP2+: U400.CC2(USB2_6P) U6100.23(DPLUS_SYS)
USBP2-: U400.CC1(USB2_6N) U6100.24(DMINUS_SYS)
USBP3+_TS: R7634.2 U400.CG4(USB2_3P)
USBP3+_TS_C: CN7603.9 R7634.1
USBP3-_TS: R7635.2 U400.CG3(USB2_3N)
USBP3-_TS_C: CN7603.10 R7635.1
USBP4+: L7600.3 U400.CD4(USB2_4P)
USBP4+_C: CN7600.14 L7600.4
USBP4-: L7600.2 U400.CD3(USB2_4N)
USBP4-_C: CN7600.13 L7600.1
USBP5+: L5700.2 R5703.1 U400.CG6(USB2_5P)
USBP5+_C: C5705.1 CN5700.3 L5700.1 R5703.2
USBP5-: L5700.3 R5702.1 U400.CG5(USB2_5N)
USBP5-_C: C5705.2 CN5700.2 L5700.4 R5702.2
USBP6+: R3409.2 U400.CE2(USB2_2P)
USBP6+_C: CN3400.32 R3409.1
USBP6-: R3408.2 U400.CE1(USB2_2N)
USBP6-_C: CN3400.33 R3408.1
USBP7+: R4109.2 U400.CC4(USB2_10P)
USBP7+_C: CN4100.3(USB_D+) R4109.1
USBP7-: R4110.2 U400.CC3(USB2_10N)
USBP7-_C: CN4100.5(USB_D-) R4110.1
USBP8+: L5200.2 R5206.2 U400.CG9(USB2_7P)
USBP8+_C: C5208.2 CN5201.4 L5200.1 R5206.1
USBP8-: L5200.3 R5205.2 U400.CG8(USB2_7N)
USBP8-_C: C5208.1 CN5201.3 L5200.4 R5205.1
USBP10+_WWAN: L4200.1 R4247.2 U400.CH6(USB2_9P)
USBP10+_WWAN_C: CN4200.7(USB_DP) L4200.2 R4247.1
USBP10-_WWAN: L4200.4 R4248.2 U400.CH5(USB2_9N)
USBP10-_WWAN_C: CN4200.9(USB_DN) L4200.3 R4248.1
USIM_DETECT: CN4200.66(SIM_DET) R4223.1 R4225.1
V_ADP_ADC4: PC8502.2 PR8502.1 PR8507.1 R4712.2
V_ADP_ADC4_R: C4711.2 R4712.1 U4701.C2(GPIO41/ADC4)
VADJ1: C3402.1 CN3400.6 R3405.1
VADPBL: PQ8000.5(D) PQ8007.5(D) PQ8009.3(D) PR8245.2
VCONN_5V_P1: C6107.2 C6108.1 R6115.2 U6100.8(VCONN_V5V)
VCORE_CS1: PR8813.1 PR8903.1 PU8800.4(CS1)
VCORE_CS2: PR8814.2 PR8920.1 PU8800.3(CS2)
VCORE_CS_SUM: PR8813.2 PR8814.1 PR8852.2 PR8855.1 PU8800.17(CS_SUMA)
VCORE_PE: PR8827.1 U4701.G3(GPIOF1/ADC8)
VCORE_PWM1: PR8901.1 PU8800.39(PWM1)
VCORE_PWM2: PR8916.1 PU8800.38(PWM2)
VCORE_VDIFF: PC8815.1 PR8822.1 PU8800.5(VDIFFA)
VCORE_VFB: PC8815.2 PR8822.2 PR8824.1 PR8858.2 PR8859.2 PU8800.6(VFBA)
VCORE_VORTN: PR8829.1 PU8800.8(VORTNA)
VCORE_VOSEN: PR8828.1 PU8800.7(VOSENA)
VGT_VCCSENSE: PR8835.1 PR8837.2 U400.E3(VCCGT_SENSE)
VGT_VSSSENSE: PR8839.2 PR8841.1 U400.D2(VSSGT_SENSE)
VOL_DOWN#: R4764.2 U4701.J8(GPIO85/I2C4_SCL0/RXD)
VR_SCL_P: PR8805.2 PR8809.1 U4701.D5(GPIO33/I2C5_SCL0/C\T\S\)
VR_SDA_P: PR8806.2 PR8815.1 U4701.D4(GPIO36/I2C5_SDA0/RTS)
VR_SVID_ALERT#: C546.2 PR8802.2 PR8820.2 R611.1 R612.2
VR_SVID_CLK: C641.2 PR8803.2 PR8823.1 R613.2 U400.AA1(VIDSCK)
VR_SVID_DATA: PR8801.2 PR8821.1 R614.2 U400.AA2(VIDSOUT)
VR_SYNC: PR8812.2 PR8907.1 PR8922.1 PR9007.1 PR9022.1
VR_VTEMP: PR8847.1 PR8906.1 PR8921.1 PR9003.1 PR9018.1
VRAVDDQ_FB: PR8712.2 PR8713.1 PR8714.1 PU8700.6(FB)
VRAVR_ON: PR8811.2 R3311.2
VRPPM_SLP_S0_N: R7703.2 U400.BJ37(GPP_B12/SLP_S0#)
VRPVDDQ_PG: PR8106.2 PR8700.1 PR9216.2
VSYS: R6100.2 R6109.1 U6100.19(VSYS)
WIRELESS_ON: CN4100.6(LED#1) CN4100.16(LED#2) Q5004.2(G) Q5004.3(D) Q5005.3(D) R5012.2
WL_LED_ALL#_Q: R5005.1 R5014.2
WLAN_ALERT#: CN4100.62(ALERT#) TP4102.1
WLAN_DISABLE: Q4109.5(G) R4141.2 R4749.2 U4701.E4(GPO32/T\R\I\S\)
WLAN_DISABLE#: Q4109.1(S) Q4109.3(D) R4136.2
WLAN_I2CCLK: CN4100.60(NFC I2C SM CLK) TP4101.1
WLAN_I2DATA: CN4100.58(NFC I2C SM DATA) TP4100.1
WLAN_LED_EN: Q5005.2(G) R535.2 R5015.2 U400.CN4(GPP_E23/DPPD_CTRLDATA)
WLAN_TRANSMIT_OFF#: R4106.2 R4116.2 U400.CP12(GPP_C21/UART2_TXD)
WLAN_WAKE#: CN4100.55(PEWAKE0#) Q4104.1 R4105.1 R4117.1
WR_CLK_DN: CN4100.21(SDIO WAKE(I)) U400.CN31(CNV_WR_CLKN)
WR_CLK_DP: CN4100.23(SDIO RESET) U400.CP31(CNV_WR_CLKP)
WR_LANE0_DN: CN4100.15(SDIO DAT1(IO)) U400.CR30(CNV_WR_D0N)
WR_LANE0_DP: CN4100.17(SDIO DAT2(IO)) U400.CP30(CNV_WR_D0P)
WR_LANE1_DN: CN4100.9(SDIO CLK(O)) U400.CM30(CNV_WR_D1N)
WR_LANE1_DP: CN4100.11(SDIO CMDIO)) U400.CN30(CNV_WR_D1P)
WT_CLK_DN: CN4100.71(RESERVED1) U400.CP34(CNV_WT_CLKN)
WT_CLK_DP: CN4100.73(RESERVED2) U400.CN34(CNV_WT_CLKP)
WT_LANE0_DN: CN4100.65(PERP1) U400.CN32(CNV_WT_D0N)
WT_LANE0_DP: CN4100.67(PERN1) U400.CM32(CNV_WT_D0P)
WT_LANE1_DN: CN4100.59(PETP1) U400.CP33(CNV_WT_D1N)
WT_LANE1_DP: CN4100.61(PETN1) U400.CN33(CNV_WT_D1P)
WW_LED#: Q5004.4(S) R4209.1 R5013.2
WW_LED#_C: CN4200.10(LED) R4209.2
WWAN_CONFIG_2: CN4200.75(CONFIG_2) R426.1 U400.CH23(GPP_D22/SPI1_IO3)
WWAN_CONFIG_3: D4201.2 Q4200.2(G) R431.1 U400.CG23(GPP_D21/SPI1_IO2)
WWAN_CONFIG_3_C: CN4200.1(CONFIG3) D4201.1 Q4202.5(G) R4250.2
WWAN_DET#: R4202.2 R4700.1 U4701.E6(GPIO01)
WWAN_I2C_INT#_C: CN4200.20(GPIO_5) Q4202.1(S)
WWAN_I2C_INT#_L: Q4202.6(D) R4251.2
WWAN_I2C_SCL: R4252.1 R4770.2 R6120.2 U4701.F5(GPIOF3/I2C4_SCL1)
WWAN_I2C_SCL_C: CN4200.28(GPIO_8) Q4201.4(S)
WWAN_I2C_SCL_L: Q4201.3(D) R4252.2
WWAN_I2C_SDA: R4253.1 R4771.2 R6119.2 U4701.F6(GPIOF2/I2C4_SDA1)
WWAN_I2C_SDA_C: CN4200.22(GPIO_6) Q4201.1(S)
WWAN_I2C_SDA_L: Q4201.6(D) R4253.2
WWAN_IOT_INT#: R4251.1 R4772.1 U4701.G9(GPIOC3/PWM0)
WWAN_OFF#: CN4200.6(PWR_ON/OFF) R4203.2 R4746.2 U4202.1(INB) U4701.K2(GPO35/T\E\S\T\)
WWAN_RST#: R571.1 R4235.2 U400.CE28(GPP_B16/GSPI0_CLK) U4201.6(C)
WWAN_TRANSMIT_OFF#: D4200.1(CATHODE) Q5004.5(G) R474.1 R4213.1 U400.CN22(GPP_D9/ISH_SPI_CS#/GSPI2_CS0#)
WWAN_TRANSMIT_OFF#_R: CN4200.8(W_DISABLE) D4200.2(ANODE) R4210.2 R4213.2
WWAN_WAKE#: R531.1 R4245.1 U400.CP7(GPP_E15/DPPD_HPD2/DISP_MISC2)
WWAN_WAKE#_R: CN4200.54(NC#14) R4245.2
WWANSSD_M2: CN4200.21(CONFIG0) R476.1 U400.CR24(GPP_D16/ISH_UART0_CTS#/SML0BALE)
XCLK_BIASREF: R587.2 R627.1 U400.CJ1(CLK_BIASREF)
XDP_BPM0: CN7700.21(OBSFN_B0) U400.U1(BPM#_0)
XDP_BPM1: CN7700.23(OBSFN_B1) U400.U2(BPM#_1)
XDP_DBRESET#: C7702.2 CN7700.48(DBR#/HOOK7) CN7701.18 R7719.1 U400.CN10(SYS_RESET#)
XDP_TRST#: CN7700.54(TRSTN) Q7701.6(D)
XTAL1: C4000.2 R4002.2 U4000.28(CKXTAL1) Y4000.1
XTAL2: C4001.2 R4018.2 Y4000.3
XTAL2_LAN: R4002.1 R4018.1 U4000.29(CKXTAL2)
XTAL24_IN: L401.2 R589.1 U400.CK3(XTAL_IN)
XTAL24_IN_C: C424.1 L401.1 R589.2 R591.1 Y400.1
XTAL24_OUT: L401.3 R590.1 U400.CK2(XTAL_OUT)
XTAL24_OUT_C: C425.1 L401.4 R590.2 R591.2 Y400.3
XTAL_FREQ_SELECT: R628.2 R629.2 U400.CF25(GPP_H21)
N16923117: C3300.2 R3300.1 R3312.1
N17267000: PC8800.1 PR8800.1 PU8800.40(VDD33)
N17285713: R5104.1 U5100.6(GPIO)
N17286719: R7507.2 U7500.2(S\R\0\)
N17777419: L4700.1 R4736.2
N17791245: Q402.5(G) Q402.6(D) R468.1
N17791654: R458.2 U400.BJ2(VCCST_PWRGOOD)
N18345378: R5406.1 U5401.1(SET)
N18697825: C7700.2 R7712.2
N18697895: C4704.2 R4702.2
N18861075: C5100.2 R5102.2
N18940787: Q4001.2(BASE) R4003.1 R4005.2
N20385398: C631.1 R620.1 U400.BL27(VCCPLL_OC1) U400.BM26(VCCPLL_OC2)
N20937188: Q5400.3(D) R5400.2 R5401.1
N20937236: Q5400.4(S) Q5400.6(D)
N23161371: Q5100.6(D) R5108.2 R5109.1
N23161400: C5104.1 Q5100.5(G) R5109.2
N23590926: Q404.2(BASE) R551.2 R552.1
N23590933: Q403.2(G) Q404.3(COLLECTOR) R549.2
N25107404: Q7501.2(G) R7508.2 R7509.1
N25257440: PQ8005.3(D) PQ8005.6(D) PR8008.2
N25318825: PQ8004.3(D) PR8006.1
N25319146: PQ8002.2(G) PR8001.2 PR8006.2
N25319276: PC8002.2 PQ8000.4(G) PQ8002.3(D) PR8000.2 PR8009.1
N25580644: CN5201.1 CN5201.2 F5200.1
N26734829: R5301.2 R5302.1 U5300.3(SDO/SA0)
N27228992: PCN8000.8(WLED) PR8004.1
N27229026: PCN8000.7(ALED) PR8002.2
N27235971: PQ8503.3(D) PR8519.2 PR8520.2
N27239944: PR8709.1 PU8700.3(GND)
N27239982: PD8700.1(CATHODE) PR8719.2
N27239997: PC8722.2 PR8707.1
N27241425: PC9209.1 PR9202.1
N27241434: PC9210.2 PR9204.1
N27265621: PC9506.1 PC9508.1 PR9502.1 PU9501.8(OUT2#1) PU9501.9(OUT2#2)
N27265632: PC9504.1 PC9505.1 PR9500.2 PU9501.13(VOUT1#1) PU9501.14(VOUT1#2)
N27265640: PC9517.1 PR9504.2 PU9501.5(ON2)
N27265648: PC9518.1 PU9501.12(CT1)
N27265649: PC9519.1 PU9501.10(CT2)
N27265652: PC9520.1 PR9507.1 PR9508.1 PU9501.3(ON1)
N27265672: PC9510.1 PC9511.1 PR9503.1 PU9500.8(OUT2#1) PU9500.9(OUT2#2)
N27265684: PC9507.1 PC9509.1 PR9501.2 PU9500.13(VOUT1#1) PU9500.14(VOUT1#2)
N27265691: PC9514.1 PR9505.2 PU9500.5(ON2)
N27265699: PC9515.1 PU9500.12(CT1)
N27265700: PC9516.1 PU9500.10(CT2)
N27265702: PC9521.1 PR9506.1 PU9500.3(ON1)
N27267900: PC8100.1 PR8107.2 PR8109.2 PU8100.2(INPUT-) PU8100.6(INPUT-)
N27267906: PC8101.2 PD8100.3(COMMON ANODE) PR8101.1 PR8102.1 PR8104.1 PR8106.1 PR8111.1 PR8115.1
N27267915: PR8111.2 PR8117.1 PU8100.3(INPUT+)
N27267917: PC8102.2 PR8103.2 PR8105.2 PR8108.1 PR8110.1 PR8112.2 PR8116.1
N27267918: PR8112.1 PR8118.1 PU8100.5(INPUT+)
N27303100: PC9526.1 PC9527.1 PR9511.2 PU9502.13(VOUT1#1) PU9502.14(VOUT1#2)
N27303319: PC9528.1 PC9529.1 PR9512.1 PU9502.8(OUT2#1) PU9502.9(OUT2#2)
N27303349: PC9532.1 PR9514.2 PU9502.5(ON2)
N27303375: PC9535.1 PR9515.1 PU9502.3(ON1)
N27329196: PQ9602.2(G) PR9605.1
N27329277: PQ9604.2(G) PR9611.1 PR9614.1
N27329284: PR9610.1 PR9613.1 PR9614.2 PU9602.2(B)
N27329341: PR9608.1 PR9609.1 PU9602.1(A)
N27332808: PQ9600.2(G) PR9601.2
N27334099: PQ9601.5(G) PQ9601.6(D) PR9602.2 PR9603.1
N27339065: PQ9603.5(G) PQ9603.6(D) PR9606.2 PR9607.1
N27342806: PQ9605.5(G) PQ9605.6(D) PR9615.2 PR9616.1
N27342823: PQ9605.3(D) PR9612.2
N27347933: PD8100.2(CATHODE2) PR8113.1
N27347950: PD8100.1(CATHODE1) PR8114.1
N27365118: PQ9601.3(D) PR9600.2
N27365824: PQ9603.3(D) PR9604.2
N27381080: PC8501.2 PR8500.2 PR8502.2
N27585860: PC8806.1 PR8824.2
N27585915: PC8812.1 PR8849.2
N27671965: PC8500.2 PQ8500.1(EMITTER) PR8503.1 PR8504.2 PR8505.1
N27672021: PR8501.2 PR8505.2 PR8506.2
N27672045: PQ8501.1(EMITTER) PQ8502.3(D) PR8506.1
N27672058: PQ8501.2(BASE) PR8501.1
N27673930: PQ8702.3(D) PR8712.1
N30957248: L3400.1 U3400.1(OUT)
N30974767: Q407.3(D) Q408.1(S)
N30974776: Q407.1(S) R584.2
N31445230: C4024.2 R4014.2 R4015.2 R4016.2 R4017.2
N31510805: R5806.2 U5800.35(CE_USB)
N31547751: C6103.1 U6100.33(VCCD)
N31652171: PC8808.1 PR8834.2
N31667829: PC9311.1 PC9312.1 PC9313.1 PC9315.1 PC9316.1 PL9300.2 PR9308.2 PR9314.1
N31667845: PC9309.1 PR9303.1
N31667871: PC9314.2 PR9307.1
N31839995: CN5000.39 R5005.2
N31840009: CN5000.38 R5000.1
N31840035: CN5000.37 R5001.1
N31840061: CN5000.36 R5006.2
N31840087: CN5000.35 R5002.2
N31840108: CN5000.34 R5007.2
N31840152: CN5000.32 R5003.2
N31840183: CN5000.31 R5004.2
N31840189: CN5000.30 R5008.1
N32130761: CN4201.9(CD) R4223.2
N32484985: PQ8010.2(BASE) PR8014.2 PR8015.1
N32484987: PR8015.2 PR8020.2 PR8021.1
N32485009: PQ8010.3(COLLECTOR) PQ8011.2(BASE) PR8019.1
N32485094: PC8003.2 PC8004.2 PQ8001.4(G) PQ8003.3(D) PR8005.1 PR8010.2
N32485347: PQ8003.2(G) PR8003.1 PR8008.1
N32890326: CN4300.12(3.3VAUX_12) R4300.1
N33445262: TP4000.1 U4000.25(LED2(LED1))
N33535539: CN4200.69(CONFIG_1) R4202.1
N33823362: R5801.2 U5800.29(I2C_EN)
N34650123: Q4105.2(BASE) R4106.1
N34650132: Q4103.2(BASE) Q4105.3(COLLECTOR) R4108.2 R4111.1
N34650897: Q4000.3(D) Q4000.6(D)
N36049795: CN4100.38(CLINK RESET) R4113.2
N36049798: CN4100.40(CLINK DATA) R4114.2
N36049801: CN4100.42(CLINK CLK) R4115.2
N36294800: C4236.2 CN4200.56(NC#15)
N36294820: C4237.2 CN4200.58(NC#16)
N36756780: PQ8703.3(D) PR8720.2
N37057994: PC9218.1 PC9219.1 PC9220.1 PR9212.2 PU9201.8(VOUT)
N37096665: PQ8012.3(C2) PR8016.1
N37096667: PQ8006.4(G) PQ8012.6(C1) PR8023.2
N37096688: PQ8012.2(B1) PQ8012.5(B2) PR8025.1
N37096692: PD8001.2 PQ8008.2(G) PQ8009.2(G) PR8018.2
N37096694: PQ8013.3(C2) PR8017.1
