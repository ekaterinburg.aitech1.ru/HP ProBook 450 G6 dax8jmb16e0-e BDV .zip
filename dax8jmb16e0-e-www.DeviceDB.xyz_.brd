# Allegro board dax8jmb16e0-e-www.DeviceDB.xyz_.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND: length 1719.7
  TOP w0.102: 143.83,42.96 v2(143.77,42.96) ; PR8857.2 v2(34.93,99.88)
  TOP w0.152: U7500.5 53.18,58.61 53.02,58.45 52.71,58.45 v2(52.38,58.78)
  TOP w0.178: v2(187.32,29.01) 187.71,29.41 PU9500.11 ; 168.49,32.33 PU9501.11 ; 213.37,87.63 U3501.14 ; PU9502.11 v2(154.57,31.37)
  TOP w0.203: v2(196.68,45.71) 196.33,46.05 R4749.1 ; v2(224.77,97.24) 224.8,97.26 C6304.2 ; v2(168.23,57.84) 168.18,57.89 PC8725.1 ; R445.2 v2(151.09,92.08) ; v2(24.35,120.55) 24.6,120.8 R3404.1 ; R2821.1 92.89,38.21 v2(93.02,38.33) ; v2(198.91,81.09) 198.91,80.46 R4240.1 ; v2(170.11,38.33) 170.09,38.33 169.96,38.2 R2828.2 ; R4235.1 194.32,78.57 v2(194.19,78.44) ; R561.1 156.92,99.04 157.52,99.04 v2(157.54,99.02) ; C7624.1 37.79,27.26 38.7,26.35 CN7603.8 ; U4701.A8 200.9,53.61 200.78,53.49 199.98,53.49 199.86,53.61 199.71,53.76 v2(199.43,54.04) 199.07,53.68 197.87,53.68 197.62,53.93 R4751.1
  TOP w0.254: 168.3,72.76 v2(168.56,73.03) 168.13,73.46 U5100.32 ; Q7600.4 13.07,106.19 12.94,106.33 12.53,106.33 12.17,105.97 v2(12.17,105.77) ; C4702.2 211.98,50.67 211.35,51.3 211.12,51.3 C4728.1 ; 168.38,88.09 168.38,87.73 167.6,86.94 v2(167.54,86.94) ; PR9616.2 117.8,59.31 119.54,59.31 119.67,59.44 119.67,59.7 120.13,60.16 v2(121.64,60.16) ; v2(170.95,65.67) 170.36,65.67 Q5100.1 ; R6113.2 190,104.99 190,105.11 190.1,105.21 190.1,105.54 v2(190.09,105.54) ; v2(211.19,113.89) 211.36,114.06 R6332.2 ; v2(206.16,73.54) 206.26,73.44 U4202.3 ; C404.1 138.71,69.76 138.64,69.83 R501.2 ; PC8810.2 v2(35.21,97.9) ; R643.1 36.57,111.17 v2(36.57,111.35) 36.57,111.41 36.26,111.72 CN7700.20 ; Y4000.4 190.55,61.05 v2(190.63,60.96) ; v2(127.49,75.54) 127.49,75.08 R464.1 ; C7870.1 179.94,39.22 v2(180.6,38.56) ; U4701.G1 204.91,48.66 205.19,48.38 v2(205.32,48.38) ; R640.1 38.95,109.85 v2(38.99,109.81) ; R547.2 125.5,76 124.9,76 124.62,75.72 v1(124.52,75.72) ; C4723.1 211.88,52.33 212.07,52.14 R4748.2 212.43,51.69 v2(212.56,51.57) 212.82,51.31 C4720.2 ; v2(174.35,73.59) 174.42,73.52 C5103.1 173.11,72.88 172.97,72.73 U5100.23 ; v2(212.1,110.63) 212.1,110.53 212.03,110.46 R6325.2 ; Q5100.4 167.53,67.64 167.24,67.92 v2(167.24,67.97) ; v2(71.97,25.33) 71.97,25.18 71.23,24.44 71.23,24.08 70.68,23.53 U5300.5 ; CN7700.8 39.26,111.4 v2(39.21,111.35) ; U4701.E12 203.6,56.7 203.35,56.96 v2(203.35,57.29) ; CN7700.13 37.76,119.79 37.43,120.12 v2(37.43,120.23) 37.43,120.46 37.52,120.55 R634.1 ; v2(70.66,25.33) 70.66,25.24 70.23,24.81 U5300.7 ; C5018.1 52.36,32.44 51.9,32.44 v2(51.54,32.09) ; v2(14.97,108.63) 14.6,108.63 14.37,108.4 Q7600.1 ; CN7603.8 38.7,25 v2(38.59,24.9) ; v2(6.16,106.64) 6.16,106.89 6.61,107.34 CN7600.15 ; R6331.2 212.17,112.21 212.44,112.48 v2(212.68,112.48) ; v2(26.26,117.06) CN7700.59 ; R642.1 37.4,110.17 37.62,110.39 v2(37.62,110.7) ; v2(50.59,67.64) 50.17,68.06 Q5400.1 ; v2(168.42,81.6) 168.17,81.84 Q4103.1 ; R4111.2 165.8,82.18 v2(165.18,81.56) ; v2(153.21,100.16) 153.2,100.16 153.2,99.43 C405.1 ; Q4110.1 164.23,89.77 v2(164.23,88.79) ; Q4102.1 163.89,86.29 163.48,86.7 v2(163.32,86.7) ; R646.1 R647.1 33.05,109.96 v2(33.18,110.09) ; v2(193.78,62.92) 193.78,62.79 193.4,62.41 191.04,62.41 C4000.1 190.5,62.75 190.5,63.23 190.16,63.57 188.4,63.57 v2(187.79,62.95) 187.67,62.84 187.67,60.52 188.22,59.97 C4001.1 189.75,59.43 191.76,59.43 192.81,60.47 193.01,60.47 194.57,62.03 v2(194.8,62.03) ; v2(168.34,98.75) 168.65,99.06 C5404.2 ; v2(40.16,40.54) 40.19,40.52 C5017.1 ; Q4102.4 166.58,84.99 166.92,85.33 v2(166.92,85.9) ; U4701.A5 200.68,51.66 200.68,51.66 200.43,51.66 v2(200.29,51.52) ; R651.2 143.34,85.53 v2(143.84,85.03) ; CN7700.49 v2(28.76,120.15) ; PC8809.2 v2(35.21,98.74) ; R633.1 37.32,121.7 37.7,122.08 v2(37.76,122.08) ; v2(229.31,111.9) 229.68,111.52 229.68,111.45 R6328.2 230.26,111.25 230.35,111.16 R6330.2 ; R644.1 34.27,111.15 34.46,111.33 v2(34.81,111.33) 34.81,111.62 34.76,111.66 CN7700.26 ; C4722.1 191.31,52.3 v2(191.08,52.53) ; U4701.A1 200.77,48.82 200.03,48.82 199.73,49.12 v2(199.73,49.28) ; R6329.2 230.21,113.04 229.48,113.04 v2(229.32,113.2) ; C462.1 152.49,91.85 151.32,91.85 v2(151.09,92.08) ; v2(31.4,110.24) 31.5,110.24 31.89,110.62 31.89,111.46 31.76,111.58 CN7700.38 ; v2(40.18,51.81) 40.2,51.79 40.88,51.79 40.99,51.9 42.84,51.9 C5025.1 ; v2(212.09,16.34) 212.35,16.08 C3626.1 ; R635.1 36.21,120.96 36.07,120.83 v2(36.07,120.45) 36.07,120.05 36.26,119.86 CN7700.19 ; U5300.8 69.73,25.07 v2(70.02,25.35) ; v2(212.08,9.93) 212.08,9.68 212.56,9.2 EC3609.1 ; CN7700.31 33.26,119.87 33.32,119.93 v2(33.32,120.15) 33.32,120.52 33.36,120.55 R638.1 33.36,121.22 33.23,121.34 R639.1 ; v2(33.66,121.98) 34.1,121.98 34.4,121.67 R637.1 34.76,121.13 CN7700.25 ; R645.1 33.16,111.31 v2(33.16,111.31) 33.16,111.59 33.26,111.69 CN7700.32 ; U4701.M3 208.38,50.36 208.57,50.17 v2(208.67,50.17) ; R540.2 v2(155.16,98.87) ; v2(179.36,109.39) 179.36,110.85 180.03,111.52 PQ9601.1 ; v2(212.1,55.81) 212,55.71 211.97,55.71 R4763.2 ; CN7700.2 40.76,114.21 41.41,114.86 v2(41.41,115.4) ; v2(143.36,86.87) 143.78,86.45 R4147.2 ; v2(129.59,65.27) 129.59,65.15 129.32,64.88 128.67,64.88 128.45,65.1 U401.3 ; U5300.6 70.54,24.03 70.77,24.26 70.77,24.67 71.31,25.2 v2(71.31,25.33) ; v2(35.97,24.97) 36.2,25.2 CN7603.3 ; U5100.2 168.3,72.73 ; v2(212.84,108.34) 212.13,108.34 R6326.2 ; v2(28.76,111.08) CN7700.50 ; v2(45.87,45.37) 46.25,45.76 C5016.1 ; Q4109.4 177.77,89.49 177.98,89.69 178.24,89.69 178.33,89.6 v2(178.33,89.29) ; R2817.1 121.17,38.46 121.47,38.16 v2(121.57,38.16) 121.6,38.19 R2840.1 ; CN7700.14 37.76,111.71 37.67,111.63 v2(37.67,111.33) 37.77,111.33 R641.1 ; v2(43.72,24.49) 43.72,24.16 44.51,23.37 R7600.1 ; R6327.2 229.38,109.79 228.97,110.2 v2(228.97,110.31) ; v2(205.9,57.09) 206.21,56.78 U4701.J12 ; U4701.M9 208.82,54.26 v2(208.88,54.32) ; PU8102.3 39.04,80.61 39.73,79.92 PC8105.2 39.73,78.23 v2(39.35,77.86) ; v2(185.05,60.46) 184.84,60.25 U4700.2 ; v2(207.39,64.1) Q4202.4 ; v2(54.16,61.3) 54.22,61.24 C7500.2 ; PC8811.2 v2(35.21,97.06) ; CN7700.7 39.26,120.12 v2(39.23,120.15) 39.23,120.18 38.55,120.86 R632.1 ; CN7700.37 31.76,119.99 v2(31.5,120.25)
  TOP w0.305: 197.09,76.89 196.2,76.89 195.94,76.64 195.94,76.26 195.6,75.92 C4238.2 ; PC8501.1 199.36,30.27 198.86,29.77 198.86,29.32 198.68,29.14 ; v2(34.91,79.43) 35.15,79.67 PQ8100.1 35.15,81.37 35.32,81.54 36.23,81.54 36.45,81.76 PQ8100.4 ; v2(51.18,30.79) 51.18,31.16 50.91,31.43 50.68,31.43 49.92,32.19 49.13,32.19 48.7,32.62 C7614.1 ; v2(52.41,33.76) 52.59,33.94 C5019.1 C5012.1 ; C4712.2 197.68,49.01 197.66,48.99 195.94,48.99 v2(195.85,48.9) ; 225.53,98.48 226.04,98.48 v2(226.68,97.85) 226.55,97.72 R6322.2 ; R5301.1 71.21,22.15 v2(70.9,22.46) 71.2,22.75 C5302.2 ; R7722.1 40.6,121.83 v2(40.95,121.49) ; PR8129.2 90.6,34.47 v2(91.11,33.97) ; v2(72.88,39.09) 72.88,39.61 C2800.1 ; C4014.1 228.65,98.24 v2(228.76,98.13) ; v2(159.98,102.21) 160.14,102.38 U5400.5 ; v2(213.52,57.97) 213.17,57.97 213.16,57.96 R4750.2 ; 224.39,108.77 224.4,108.76 EC9700.2 ; 111.41,62.21 111.95,62.21 112.08,62.07 PU9602.3 ; U402.3 128.34,61.89 128.74,61.5 128.74,59.7 C403.1
  TOP w0.381: v2(205.42,105.87) 205.79,105.5 R5811.1 ; PC8508.1 82.78,29.27 PC8504.2 ; v2(128.63,57.91) 128.63,58.86 128.45,59.04 C403.1 ; v2(201.51,70.67) 201.28,70.44 200.77,70.44 199.7,71.51 C4016.2 ; v2(30.21,108.69) 30.21,109 30.2,109 C7702.1 ; C7603.1 C7601.2 v2(9.28,106.71) ; PR8856.2 46.08,108.67 v2(46.01,108.74) ; R4307.1 206.61,24.49 v2(206.74,24.62) ; Q3400.1 24.36,124.13 24.11,123.88 24.11,122.99 23.86,122.74 v2(23.48,122.74) ; R654.1 134.56,70.78 v2(134.44,70.66) ; PC9512.2 188.07,35.35 188.37,35.64 v2(188.76,35.64) 188.76,35.11 PC9521.2 ; C404.1 139.6,69.76 v2(139.78,69.94) ; v2(191.45,115.6) 191.58,115.47 191.58,114.6 C6103.2 ; v2(199.93,43.6) 200.5,44.17 200.5,44.79 ; C2854.2 168.11,40.98 v2(167.37,40.24) 166.7,40.24 C2834.2 ; v2(101.46,74.3) 102.02,74.3 C613.1 ; v2(199.31,68.83) 199.31,69.24 C4007.2 ; PQ8005.1 201.54,93.11 200.96,92.52 v2(200.82,92.52) 200.7,92.41 PR8012.2 ; v2(15.35,114.94) 15.35,115.5 15.73,115.88 C3424.1 ; C7610.2 38.3,31.92 v2(39.07,31.15) ; C7701.1 28.48,121.82 v2(28.06,122.25) ; C3617.1 224.34,15.13 v2(224.34,15.11) ; R5605.2 v2(171.86,74.86) ; v2(51.84,39.84) 52.12,40.12 C2809.2 ; R6301.1 227.32,115.09 v2(226.7,115.09) ; PR8855.2 45.07,108.77 v2(45.04,108.79) ; PR8021.2 195.28,89.11 v2(195.13,88.96) ; Q3401.1 19.03,114.71 19.03,114.14 v2(17.81,112.92) ; C3637.1 162.94,123.55 v2(162.94,124.5) ; C3623.1 212.57,10.97 v2(212.03,10.97) ; v1(99.01,95.72) 99.11,95.81 C574.1 C582.1 ; PC9200.2 122,129.22 v2(122.28,129.49) ; C5705.3 225.02,34.65 v2(225.09,34.72) ; PC8801.2 v2(37.27,94.32) PC8803.1 ; v2(123.53,59.95) 123.67,60.09 124.38,60.09 PQ9605.4 ; C4109.1 184.93,91.24 v2(184.75,91.06) ; v2(140.93,110.3) v2(141.39,110.76) 142.1,111.47 R566.2 142.59,111.47 142.63,111.43 R564.1 ; v2(125.54,60.71) 125.27,60.97 PC9608.2 125.47,61.7 PC9607.2 ; v2(214.36,83.75) R3505.2 R3509.1 v2(215.35,84.05) C3504.2 ; v2(149.81,39.65) 149.81,40.01 150.4,40.59 C2829.1 ; v2(28.03,105.39) 28.03,105.48 28.49,105.94 R7729.1 ; v2(69.58,126.42) 69.58,127.06 Q5301.1 ; v2(127.87,39.72) 127.87,40.5 C2846.2 ; PC8806.2 43.48,109.24 v2(43.92,109.68) ; v2(125.41,58.12) 125.83,58.54 125.83,58.64 PQ9605.1 ; v2(109.73,43.95) 110.25,43.95 C2812.2 ; v2(69.83,39.99) 69.13,40.7 EC2811.2 ; v2(125.84,39.35) 124.05,39.35 C2855.2 123.69,38.44 123.9,38.23 C2856.2 ; C604.1 110.98,73.17 110.82,73.34 v1(110.6,73.34) ; v2(211.08,84.31) 211.2,84.31 C3507.2 ; v1(127.82,87.99) 127.82,87.23 v1(127.9,87.15) 128.47,86.59 R412.1 ; C448.1 129.87,86.59 130.46,87.17 v1(130.46,87.18) 130.49,87.15 130.49,87.1 130.98,86.61 C447.1 C438.1 133.92,86.61 v1(133.98,86.54) ; D6302.2 229.36,114.8 v2(229.31,114.85) ; v1(99.01,90.14) 99.06,90.18 99.14,90.27 C583.1 ; v2(55.85,39.84) 55.85,40.39 C2805.2 ; v2(84.97,41.31) 84.6,41.68 84.07,41.68 C2802.2 ; v2(101.48,76.71) 101.92,76.71 102.32,76.32 C603.1 ; PR8207.2 115.36,34.51 v2(115.2,34.35) ; EC3611.1 213.31,12.73 213.14,12.73 212.7,12.29 C3622.1 212.67,12.07 v2(212.07,12.07) ; v2(42.46,48.74) 42.26,48.95 R6832.2 ; PQ8005.4 199.92,94.41 v2(199.6,94.72) ; v2(73.29,127.08) 73.18,126.96 C7622.1 ; R4768.1 187.55,58.79 186.53,59.8 v2(186.24,59.8) ; C510.1 119.45,85.01 v1(119.62,84.84) ; v2(212.35,7.94) 212.82,7.46 C3624.1 ; v2(180.42,91.19) 180.48,91.24 U4100.2 ; EC2812.2 106.08,39.02 v2(106.03,38.97) ; v2(125.41,73.61) 125.26,73.46 125.26,73.23 R451.2 124.47,73.39 R545.2 R546.2 123.23,74.06 122.72,74.58 v1(122.31,74.58) ; C4703.2 C4700.2 195.4,40.26 195.4,39.91 v2(195.55,39.76) ; v2(128.08,58.48) 128,58.4 127.64,58.4 R467.1 ; v2(215.18,9) 215.18,8.83 214.92,8.57 EC3612.1 ; C3411.2 39.94,129.38 v2(40.02,129.29) ; C4704.1 216.31,50.86 216.38,50.92 v2(217.01,50.92) ; v2(171.29,7.98) 171.79,8.48 PC8509.1 ; v2(135.42,43.67) 136.03,43.67 136.05,43.65 C2845.2 ; C6104.1 183.95,109.74 v2(183.57,110.11) 183.2,109.74 C6107.1 182.81,109.74 v2(182.44,110.11) 182.07,109.74 C6108.2 ; PC8814.1 47.27,99.32 v2(47.38,99.32) 47.54,99.32 PR8851.2 ; v2(161.25,13.81) 162.01,13.05 PQ8702.1 ; C2832.2 142.48,40.48 142.48,39.78 142.47,39.77 142.47,39.7 v2(142.46,39.7) ; v2(179.54,60.1) 179.55,60.12 C5023.1 ; PC9025.1 114.15,121.66 v2(114.64,121.66) ; C7853.1 C7854.1 149.19,40.04 v2(148.82,39.67) ; R6300.1 226.84,113.71 v2(226.66,113.88) ; v1(110.6,74.48) 110.94,74.48 C614.1 ; v2(217.97,18.01) 218.13,17.85 C3631.2 ; v2(223.48,111.56) 223.05,111.99 U6300.3 U6300.8 220.99,111.99 v2(220.98,112) ; C606.1 v1(120.4,74.75) ; C619.1 123.95,86.05 124.76,86.86 C631.2 124.85,87.16 124.57,87.44 v1(124.57,87.56) ; C4715.1 197.08,52.55 v2(197.06,52.53) 197.28,52.31 C4708.1 ; v2(190.33,68.59) 190.03,68.59 189.99,68.56 R4004.1 ; C2851.2 193.72,44.12 C2849.2 193.72,42.53 v2(193.43,42.25) ; C7611.2 40.62,26.35 40.28,26.01 40.28,25.19 40.06,24.97 v2(39.71,24.97) ; v2(186.35,105.82) 185.79,105.26 185.79,105.05 185.32,104.57 C6106.1 ; PC8813.1 47.34,102.79 v2(47.37,102.79) 47.47,102.79 PR8850.1 ; R6107.2 185.26,112.65 v2(186.01,112.65) ; C2852.2 178.46,40.52 178.46,39.42 178.76,39.12 v2(179.1,39.12) ; C587.1 108.2,95.97 v1(107.67,96.5) 107.14,95.97 C588.1 ; C7627.2 29.48,25.14 v2(29.26,25.37) ; v1(120.4,72.88) 121.23,72.88 C616.1 ; v2(135.19,111) 135.19,111.05 134.85,111.39 PC9601.2 ; v2(87.03,40.57) 87.29,40.31 87.53,40.31 87.83,40 C2808.2 ; EC2808.1 89.33,39.63 v2(88.73,39.63) ; R4747.2 v2(212.58,49.54) 212.08,49.54 C4701.2 C4702.2 ; v2(220.37,105.05) 220.32,105 C6302.1 ; R6105.2 193.9,112.61 v2(194.04,112.46) 194.43,112.08 R6104.2 ; v2(195.71,74.03) 195.71,73.99 196.1,73.6 v2(196.1,73.55) 196.1,73.1 195.74,72.74 C4035.2 C4019.2 ; v2(166.61,69.04) 166.23,69.42 R5107.2 ; v2(183.49,107.13) 183.49,106.82 183.94,106.37 C6105.1 ; v2(13.58,104.05) 12.67,104.05 12.07,104.65 C7600.1 ; v2(75.6,43.95) 75.4,43.74 C2801.2 ; C5812.1 204.39,102.3 v2(203.72,101.64) ; U5700.3 U5700.8 225.6,30.95 226.53,31.88 v2(226.53,31.93) 226.42,32.03 226.42,32.52 v2(226.53,32.62) ; EC2802.2 82.08,42.52 81.42,41.86 v2(81.26,41.86) ; v2(164.33,39.67) 163.96,40.04 C2848.2 ; PR8845.2 33.32,101.12 v2(32.93,101.12) ; C4208.2 R4246.1 204.29,78.61 v2(203.86,78.18) ; v2(63.35,39.85) 63.39,39.89 C2806.2 ; v2(123.55,41.71) 123.38,41.71 123.06,41.4 R2842.2 ; v2(99.7,42.28) 98.57,43.41 C2814.2 ; C3402.2 40.9,129.44 v2(40.84,129.38) 41.25,128.96 C7871.1 C7860.1 ; v2(111.62,39.98) 111.05,40.55 C2826.2 ; C4714.1 196.36,57.64 197.71,57.64 C4716.1 198.39,57.43 v2(198.51,57.55) ; v2(217.1,21.77) 217.19,21.85 C3611.2 ; v1(109.52,96.5) 110.05,95.97 C589.1 ; C570.1 99.08,92 v1(99.01,91.92) ; v2(32.3,129.67) 32.77,129.2 R3413.1 ; v2(202.77,96.93) 202.86,96.93 PC8001.2 ; C2838.2 143.89,43.02 143.83,42.96 ; C5000.2 40.04,56.51 40.48,56.51 v2(40.54,56.45) ; PC8903.2 PC8904.2 55.22,121.5 v2(55.05,121.67) ; v2(226.67,112.16) 227.04,111.78 U6303.3 U6303.8 228.67,111.78 228.78,111.9 v2(229.31,111.9) ; R652.2 146.46,92.36 v2(147.13,91.69) ; v2(162.12,73.67) 162.12,73.32 161.64,72.84 160.86,72.84 159.8,71.78 159.8,71.01 R446.2 ; v2(44.8,65.16) 45.24,65.16 C5403.2 ; C4100.2 176.49,93.82 176.79,94.12 v2(176.79,94.38) ; C2847.2 161.43,42.17 v2(160.87,42.17) ; v2(77.99,41.2) 78.21,41.2 78.5,41.49 EC2800.2 ; C584.1 104.41,96.01 v1(104.9,96.5) ; EC2810.1 76.54,41 76.61,40.92 v2(76.74,40.92) ; v2(47.48,91.68) PR8830.2 ; PC9514.2 185.94,35.46 v2(185.96,35.44) ; v2(71.68,68.46) 71.95,68.73 R550.2 ; v2(71.17,126.04) 71.05,125.92 Q5300.1 ; C5104.2 165.3,65.73 164.69,66.33 C7700.1 ; 111.41,62.21 v2(109.7,62.21) ; C3613.1 212.98,15.45 212.46,15.45 v2(212.03,15.02) ; PR8866.2 v2(33.37,103.04) ; v2(229.32,113.2) 229.7,113.58 D6301.2 ; R514.1 155.55,77.57 v2(155.11,77.13) 154.97,77.13 154.5,77.6 R576.2 ; C402.2 129.4,69.91 v2(129.55,69.75) ; C2804.2 60.36,40.2 v2(60.36,39.85) ; v2(80.93,40.34) 80.97,40.37 EC2801.2 ; v2(48.41,30.31) 48.25,30.46 C7621.2 ; Y4000.2 188.39,62.63 188.7,62.94 v2(189.07,62.94) ; v2(70.3,42.24) 70.3,42 C2813.2 ; C580.1 99.04,93.78 v1(99.01,93.81) ; C2841.2 v2(165.24,42.19) ; v2(93.12,40.85) 94.26,41.98 C2815.2 94.26,43.03 EC2815.2 ; EC2806.2 176.79,39.69 175.88,39.69 v2(175.82,39.63) ; v2(152.61,42.45) 152.61,42.47 152.57,42.52 152.57,44.11 EC2823.2 ; EC2813.1 102.37,42.5 v2(102.39,42.53) ; EC2809.2 65.34,40.6 v2(65.34,39.88) ; v2(126.3,124.13) 126.3,122.82 126.24,122.75 C3301.2 ; v2(171.33,38.99) 171.77,38.99 C2830.2 ; v2(48.45,96.53) 48.32,96.65 PC8805.2 ; v2(212.33,59.93) 212.37,59.97 C4705.2 C4706.1 214.25,59.97 v2(214.6,60.31) 214.77,60.14 R4730.1 ; C7700.1 163.93,66.33 v2(163.75,66.15) ; C7700.1 164.45,67.12 C5102.1 ; EC2804.2 53.86,39.95 v2(53.96,39.85) ; v2(40.19,107.42) 39.98,107.63 39.37,107.63 38.98,107.24 PR8861.1 ; v2(58.97,42.14) 57.92,41.1 C2816.2 ; EC3400.1 25.16,129.66 v2(25.38,129.44) ; C2811.2 105.66,41.13 v2(106.03,41.13) ; C421.2 154.69,83.37 v2(154.56,83.24) 154.44,83.37 C422.2 ; R3508.2 213.16,85.46 v2(212.81,85.81) ; v1(102.13,96.5) 102.59,96.04 C575.1 ; C3636.1 v2(162.57,125.09) ; v2(194.63,81.13) 195.36,80.4 C4222.2 ; v2(201.56,92.36) 201.89,92.04 PR8013.1 ; v2(48.55,56.22) 48.55,57.05 R5015.1 49.59,56.48 Q5005.1 ; C2803.2 76.55,39.41 v2(76.28,39.15) ; C4729.2 191.13,52.57 v2(191.08,52.53) ; C617.1 125.91,86.08 126.37,86.54 C458.1 126.77,86.96 v1(126.58,87.15) ; EC2821.2 160.85,40.05 v2(161.4,39.5) ; C7852.1 71.85,39.11 v2(71.86,39.09) ; v2(213.72,45.98) C4721.2 ; v1(114.61,72.8) 114.64,72.78 C597.1 ; R7621.2 C7609.1 45.24,35.07 45.24,35.53 v2(45.17,35.6) ; v2(138.34,39.68) 138.43,39.78 C2843.2 ; PC8210.2 121.72,22.95 120.98,22.95 120.58,22.56 v2(120.58,22.41) ; C3638.1 164.03,119.44 v2(164.12,119.36) ; EC2803.2 86.99,41.97 87.28,42.27 v2(87.89,42.27) 87.89,41.65 88.09,41.46 EC2805.2 ; C2844.2 190.22,44.55 C2842.2 ; PR8018.1 196.94,86.82 v2(196.34,86.22) ; R4138.1 174.88,86.58 174.52,86.94 v2(174.34,86.94) ; v2(60.85,65.16) 60.4,65.61 R9649.2 ; v2(82.94,39.48) 82.94,40.1 EC2814.2 ; C4107.2 v2(183.35,88.12) ; v2(196.86,100.74) 197.21,100.74 C5821.2 ; v2(175.65,42.59) 175.77,42.47 C2836.2 ; R603.2 106.28,105.78 106.28,105.06 106.69,104.65 v2(106.87,104.65) ; PC8800.2 46.86,97.96 45.88,98.94 v2(45.88,99.09) ; PR8808.1 47.86,104.12 v2(47.38,104.6) 47.37,104.6 PC8804.1 ; v2(112.89,92.77) C595.1 C596.1 ; C5101.1 164.6,74.05 v2(164.24,73.69) ; v2(219.59,93.91) 219.98,93.52 R6320.2 ; v2(43.95,125.99) 44.28,125.66 C3401.1 ; v2(117.86,72.35) 117.54,72.35 117.5,72.31 C615.1 ; PC9606.2 119.43,62.19 v2(119.77,61.85) ; PC9600.2 134.99,107.04 v2(134.3,106.35) ; C3412.2 38.95,129.37 v2(39.05,129.27) ; C3520.2 229.23,62.96 v2(229.27,63) ; C4713.1 212.1,53.78 v2(212.42,54.09) ; v2(42.79,106.61) PR8859.1 ; C2807.2 98.25,40.06 v2(98.23,40.09) 97.92,39.78 EC2807.1 ; R7735.1 v2(21.45,109.99) ; C605.1 110.41,71.4 v2(110.37,71.35) ; v2(208.76,115.58) 208.59,115.58 R5805.2 ; v2(67.45,23.17) 66.62,24 C5303.2 ; v2(201.02,100.89) 201.38,101.25 U5801.2 ; C2840.2 163.65,42.29 v2(164.01,42.64) ; v2(57.77,65.17) 57.32,65.63 Q7702.1 ; C5100.1 174,66.55 v2(173.86,66.41) 173.86,65.51 C5601.1 ; C7602.2 v2(9.3,105.62)
  TOP w0.508: 85.58,30.16 85.58,29.65 86.34,28.89 88.63,28.89 89.08,28.43 v2(89.08,28.07) ; v2(201.18,85.2) 200.85,84.87 PR8023.1 ; C4011.2 187.84,67.4 v2(187.84,66.81) ; v2(12.89,110.52) 13.42,109.99 C7616.2 R7618.2 ; R577.2 157.42,80.66 v2(156.95,80.19) ; v2(31.2,96.83) PR8864.1 ; D6304.2 228.45,116.16 v2(228.38,116.22) ; v2(53.7,93.38) 53.03,92.7 C7842.1 ; PU8200.35 127.32,23.39 PD8203.2 ; C2850.2 C7869.1 154.91,41.16 v2(154.91,41.15) ; v2(45.63,25.22) 45.53,25.12 C7629.2 45.74,24.2 C7620.2 ; C3422.2 C7861.1 42.52,127.31 v2(42.4,127.31) ; PR8831.1 v2(34.88,95.81) ; PR8518.1 165.37,12.1 165.11,11.84 v2(165.11,11) ; PR8009.2 214.02,106.18 v2(214.5,106.66) ; D3601.1 224.46,17.06 224.82,16.69 v2(224.95,16.69) ; v2(84.34,39.58) 84.73,39.97 C2810.2 ; C3404.2 22.53,130.81 v2(22.53,131.55) ; v2(40.95,133.76) 42.14,132.58 C3421.2 ; PR8024.1 200.16,86.99 200,87.15 v2(199.68,87.15) ; C2853.2 162.98,37.84 v2(162.48,38.34) ; PQ8500.3 159.47,11.94 v2(159.52,11.89) 159.77,11.65 PR8508.2 ; C4009.2 C4012.2 190.71,67.72 v2(190.97,67.98) ; v2(9.28,116.54) 9.28,116.13 9.39,116.02 C7606.2 ; C3420.2 22.58,129.34 v2(22.31,129.07) ; v2(31.2,98.51) 31.52,98.51 PR8862.2 ; v2(44.68,131.56) 44.66,131.53 C3413.2 ; 31.22,133.53 31.23,133.52 R3428.1 ; v2(217.31,93.5) 217.16,93.65 216,93.65 C3506.2 215.44,93.63 215.15,93.93 C3508.2 ; v1(117.83,75.48) 117.55,75.48 117.17,75.1 C602.1 ; v2(190.6,43.87) 190.22,44.25 C2842.2 ; v2(56.04,98.07) 56.42,98.46 C7843.1 ; v2(154.24,101.81) 154.57,101.48 R559.2 ; v2(176.23,21.42) 176.13,21.52 C7811.1 ; v2(64.15,24.9) 64.32,25.07 65.53,25.07 65.74,25.28 C5304.1 ; C429.2 C428.2 v2(60.49,59.92) ; C5301.2 66.35,30.82 66.5,30.67 C5300.2 67.4,30.67 v2(67.7,30.97) ; v2(163.52,28.88) PC9316.2 163.52,30.49 163.55,30.51 PC9315.2 ; C4023.2 209.89,72.6 v2(209.16,73.33) ; C3410.1 33.14,133.45 v2(32.83,133.76) ; v2(51.75,106.96) 52.1,106.61 C7841.1 ; PC8807.2 45.82,94.89 45.6,94.67 v2(45.3,94.67) 45.3,93.84 PC8802.2 ; PR8022.2 v2(191.6,87.15) ; C3403.2 44.61,126.65 v2(43.95,125.99) ; v2(15.28,99.11) 15.49,99.32 C3300.1 ; PR8010.1 220.28,101.47 v2(220.28,100.74) ; R563.2 155.08,104.2 v2(155.64,103.63) ; R5800.1 210.73,114.35 v2(211.19,113.89) ; v2(164.7,33.56) 164.7,34.29 PC9504.2 ; v2(72.25,74.6) 74.33,74.6 75.01,73.92 75.01,72.78 74.86,72.62 Q403.1 ; v2(90.38,28.07) 90.38,28.78 90.41,28.8 PC8507.1 ; v2(232.67,118.22) 233.56,117.33 D6303.2 ; v2(159.04,57.28) 159.72,57.97 PR8724.1 ; v2(31.2,97.85) PR8863.1 ; v2(191.6,85.18) PR8019.2
  BOTTOM w0.102: PR8109.1 v2(3.36,110.75)
  BOTTOM w0.127: 102.94,87.21 U400.U24 ; U400.U24 103.23,86.92 ; U400.U24 103.53,87.21 ; U400.U24 103.23,87.5 ; U400.AH25 110.07,87.04 ; U400.AH25 110.07,86.45 ; U400.AH25 109.78,86.75 ; U400.AH25 110.36,86.75 ; U400.U26 103.53,86.28 ; U400.U26 102.94,86.28 ; U400.U26 103.23,86.57 ; U400.AG24 109.61,87.5 ; U400.AG24 109.32,87.21 ; U400.AG24 109.91,87.21 ; U400.AG24 109.61,86.92 ; U400.AH24 110.53,87.5 ; U400.AH24 110.23,87.21 ; U400.AH24 110.53,86.92 ; U400.AH24 110.82,87.21 ; 108.7,86.92 U400.AE24 ; U400.AE24 108.7,87.5 ; U400.AE24 108.41,87.21 ; U400.AE24 109,87.21 ; U400.N25 101.25,86.75 ; U400.N25 100.96,87.04 ; U400.N25 100.66,86.75 ; U400.N25 100.96,86.45 ; U400.J24 98.98,87.7 ; U400.J24 98.68,87.41 ; U400.J24 98.39,87.7 ; U400.K24 99.63,87.7 ; U400.K24 99.04,87.7 ; U400.K24 99.33,87.41 ; 104.76,86.28 U400.Y26 ; U400.Y26 105.35,86.28 ; U400.Y26 105.06,86.57 ; 99.33,87.09 U400.K25 99.63,86.79 ; v2(112.29,98.48) 112.56,98.48 112.63,98.55 112.93,98.55 113.09,98.71 113.09,99.17 U400.AM5 ; U400.AE25 108.25,87.04 ; U400.AE25 107.95,86.75 ; U400.AE25 108.25,86.45 ; U400.AE25 108.54,86.75 ; 109.45,86.75 U400.AF25 ; U400.AF25 109.16,86.45 ; U400.AF25 109.16,87.04 ; U400.AF25 108.87,86.75 ; U400.G35 U400.G36 97.57,79.99 97.57,79.2 v1(97.33,78.96) ; U400.V26 104.15,86.57 ; U400.V26 103.85,86.28 ; U400.V26 104.44,86.28 ; U400.B31 93.73,83.32 93.44,83.03 93.11,83.03 92.84,82.76 92.41,82.76 92.07,82.41 91.97,82.41 v1(91.55,81.99) ; U400.AE26 109,86.28 ; U400.AE26 108.41,86.28 ; U400.AE26 108.7,86.57 ; U400.AG26 109.61,86.57 ; U400.AG26 109.32,86.28 ; U400.AG26 109.91,86.28 ; 110.98,87.04 U400.AJ25 110.69,86.75
  BOTTOM w0.152: v1(126.6,90.53) 126.56,90.49 126.56,89.59 U400.BR22 ; U400.BP4 v1(126.21,100.69) U400.BP3 ; U400.AK4 v1(111.36,100.7) U400.AK3 ; U400.BK2 U400.BK3 123.89,101.1 123.96,100.72 123.96,100.4 U400.BK4 ; U400.CF2 U400.CF3 133.71,101.05 133.71,100.39 U400.CF4 ; U400.AF4 v1(109.13,100.72) U400.AF3 ; v1(101.39,79) 101.39,79.06 101.35,79.11 U400.P36 ; U400.K3 v1(99.36,100.7) U400.K4 ; U400.D1 v1(95.7,102.7) ; U400.CB3 U400.CB2 ; U400.V36 103.86,79.32 v1(103.74,79.19) ; U400.F4 96.92,100.67 U400.F3 U400.F2 v1(96.92,102.76) ; U400.V3 v1(104.25,100.72) U400.V4 ; U400.P4 v1(101.8,100.72) U400.P3 ; 128.13,98.54 127.23,98.54 127.04,98.35 v1(127.04,97.85) 127.35,97.85 127.37,97.87 128.13,97.87 U400.BU7 128.13,98.54
  BOTTOM w0.178: U400.CP11 139.06,95.93 139.12,95.99 140.12,95.99 v2(140.22,95.9) ; v1(93.52,88.24) 93.63,88.35 U400.B23 ; v2(38.29,131.2) 38.28,131.2 37.84,131.65 37.81,131.65 37.65,131.81 CN3400.12 ; v2(139.38,93.45) 139.34,93.41 U400.CP15 ; v1(93.25,85.48) 93.61,85.84 U400.B27 ; v2(139.57,94.89) 139.43,94.75 138.63,94.75 138.48,94.67 U400.CP13 U400.CN13 U400.CM13 ; U400.BF36 121.48,79.08 v1(121.37,78.97) ; v2(123.3,103.41) 123.76,102.94 123.76,101.88 U400.BK2 ; U400.AP36 113.93,79.28 114.25,78.97 114.25,78.49 v1(114.36,78.38) ; U400.CP19 138.44,90.89 140.21,90.89 v2(140.37,90.73) ; PU8200.22 126.29,23.37 PU8200.36 ; U400.J36 98.83,79.01 v1(98.79,78.97) ; v2(106.18,78.11) 106.38,78.3 U400.AB36 ; v2(139.94,99.21) 139.85,99.12 138.77,99.12 U400.CR6 ; U400.AF36 108.9,76.31 ; v1(111.55,78.43) 111.42,78.56 U400.AK36 ; U400.AV36 116.46,79.89 116.46,77.85 v1(116.6,77.71) ; v2(139.23,97.31) 139.16,97.25 138.65,97.25 138.52,97.19 U400.CP9 U400.CN9 ; v2(133.79,103.1) 133.53,102.85 133.53,101.88 U400.CF2 ; U400.BB36 118.97,78.69 v1(119.11,78.55)
  BOTTOM w0.203: CN7602.3 75.29,130.19 74.89,130.59 v2(74.89,130.66) ; v1(108.77,73.46) 108.9,73.59 108.9,76.31 ; v1(135.33,81.29) 135.33,81.29 v1(135.33,81.29) ; v1(135.33,81.29) U400.CJ35 U400.CJ36 ; CN7701.28 164.54,75.45 164.09,75.01 162.89,75.01 162.12,74.25 v2(162.12,73.67) ; v2(142.19,17.64) 142.62,17.21 142.71,17.21 142.85,17.07 PU8700.14 ; U400.T7 102.71,98.09 103.4,98.09 U400.U7 103.75,98.44 v1(104.03,98.44) ; U400.CE35 U400.CE36 132.76,79.94 132.76,79.05 v2(132.82,78.99) ; R522.2 150.7,89.94 151.01,90.25 v2(151.9,90.25) ; v2(126.34,78.95) 126.34,79.2 126.47,79.33 126.47,79.86 U400.BP36 ; v2(28.63,130.92) 28.53,131.01 28.53,131.47 28.15,131.86 CN3400.31 ; CN7601.11 39.74,27.35 39.51,27.59 39.51,28.42 C7618.1 ; R649.2 154.82,95.53 v2(154.8,95.51) ; R5207.2 176.24,16.62 v2(175.89,16.97) 176.3,17.38 C5207.3 ; v2(145.83,17.33) 145.97,17.47 PU8700.1 ; C5009.1 50.75,30.36 v2(51.18,30.79) 51.32,30.64 C5013.1 ; U400.BK7 123.81,98.24 122.95,98.24 U400.BJ7 ; U400.A32 93.57,82.1 v1(93.38,82.1) ; C4106.1 174.3,93.36 174.62,93.68 174.62,94.38 v2(174.55,94.46) ; v2(124.69,78.98) 124.79,78.98 125.03,79.22 125.03,79.76 U400.BM36 ; C5022.1 53.35,30.25 v2(52.88,29.78) 52.66,30 C5004.1 ; U400.E31 96.41,82.83 96.43,82.81 96.43,82.12 U400.E33 ; U400.CL2 136.43,101.71 136.43,101.13 136.79,100.77 U400.CM4 ; U400.BY35 U400.BY36 ; v1(100.01,79) 100.02,79.01 100.02,79.82 100.09,79.89 U400.L36 U400.L35 ; R534.2 141.46,89.79 v2(141.26,89.6) ; v2(39.68,31.37) 39.68,31.3 39.85,31.14 40.93,31.14 C7623.1 ; U400.CK37 135.82,79.16 v1(135.91,79.08) ; v1(127.75,78.72) 127.75,79.13 127.72,79.15 127.72,79.94 U400.BT36 ; C5021.1 52.46,33.71 v2(52.41,33.76) 51.9,33.25 C5020.1 51.9,32.44 v2(51.54,32.09)
  BOTTOM w0.254: v2(129.37,30.31) 129.62,30.05 PR8215.2 PC8213.2 ; U400.BE8 120.89,97.56 v1(120.57,97.88) ; JDIM2801.217 182.07,43.46 v2(181.96,43.36) ; U400.BW24 129.49,87.52 130.14,86.87 U400.BY25 ; C7618.1 39.8,28.72 C7626.1 ; v2(136.35,39.71) 136.68,39.71 136.82,39.58 JDIM2801.44 ; v2(71.56,42.93) 72.1,43.48 JDIM2800.93 ; CN4100.57 174.7,81.65 v2(174.28,81.23) 174.02,81.23 173.2,82.05 CN4100.51 ; v2(59.34,39.84) 59.85,39.33 JDIM2800.44 ; JDIM2801.27 132.57,43.28 132.13,42.84 v2(132.05,42.84) ; JDIM2800.248 112.85,38.28 v2(112.94,38.36) ; JDIM2800.238 110.35,38.14 110.43,38.22 110.43,38.58 109.81,39.2 v2(109.66,39.2) 109.35,38.89 JDIM2800.234 ; U400.D21 95.89,89.61 v1(96.41,90.14) 96.73,89.81 U400.F21 ; U400.AN8 113.36,97.56 v1(113.22,97.7) 113.22,97.74 U400.AN7 ; v2(132.79,39.73) 132.73,39.73 132.32,39.32 JDIM2801.26 ; PC8637.2 194.55,22.9 195.34,23.69 v2(195.5,23.69) ; JDIM2801.30 133.32,38.77 v2(133.55,39) ; v2(180.45,43.28) 180.48,43.28 181.07,43.86 JDIM2801.213 ; v2(215.18,9) 215.01,8.84 CN4300.15 ; JDIM2801.197 177.07,44.25 177.07,44.25 177.07,43.71 176.64,43.28 v2(176.59,43.28) ; JDIM2800.10 51.35,39.63 51.56,39.84 v2(51.84,39.84) ; CN3400.37 25.15,131.83 24.95,131.63 24.95,130.92 24.94,130.9 24.94,129.89 v2(25.38,129.44) ; v2(147.04,42.34) 147.25,42.34 147.85,42.94 147.85,44.04 148.07,44.25 JDIM2801.89 ; v2(164.07,81.59) 163.7,81.96 CN4100.13 ; JDIM2800.192 98.85,38.63 98.89,38.66 98.89,39.66 98.47,40.09 v2(98.23,40.09) ; CN4200.71 205.95,73.34 v2(206.16,73.54) 206.45,73.25 CN4200.73 ; v2(55.15,42.93) 55.6,43.39 JDIM2800.27 ; v2(95.85,38.32) JDIM2800.180 ; v2(137.34,39.68) 137.65,39.68 137.82,39.52 JDIM2801.48 ; JDIM2801.94 149.32,39.34 148.99,39.67 v2(148.82,39.67) ; Q7601.1 94.54,135.23 v2(94.65,135.34) ; CN4100.1 v2(160.7,84.39) 160.28,84.39 CN4100.76 ; v2(140.86,43.03) 141.06,43.03 141.36,43.34 141.36,44 141.06,44.3 JDIM2801.61 ; JDIM2800.60 63.85,39.65 63.65,39.85 v2(63.35,39.85) ; v2(109.76,42.56) 110.4,41.91 111.16,41.91 111.34,42.09 111.34,42.45 111.16,42.63 111.16,42.91 110.6,43.47 JDIM2800.239 ; U400.CN29 U400.CM29 136.79,84.61 136.12,84.61 v1(136.1,84.63) 135.59,85.14 U400.CJ28 ; U400.BU20 128.19,90.18 v1(128.53,90.53) ; U400.BK7 124.12,98.21 v1(124.28,98.37) 124.45,98.21 U400.BL7 124.8,98.21 125.23,97.78 U400.BM9 ; v2(64.37,39.04) 64.6,39.04 64.85,38.79 JDIM2800.64 ; U400.AG5 109.64,99.51 v1(109.51,99.38) ; U400.BT16 U400.BU16 128.51,92.3 v1(128.51,92.23) ; C5208.3 v2(186.16,12.6) ; v2(232.77,114.15) 232.96,114.34 CN6300.3 ; v2(189.54,39.58) 189.72,39.58 190.82,38.48 JDIM2801.252 ; v2(92.31,41.41) 92.92,42.02 92.92,43.92 92.6,44.24 JDIM2800.167 ; v1(130.59,82.89) 130.59,82.89 130.59,82.14 U400.BY33 ; U400.CN9 137.51,97.19 v2(137.26,96.94) 137.01,97.19 U400.CM9 ; v2(105.24,39.45) 104.8,39.01 104.37,39.01 104.2,38.84 104.2,38.13 104.35,37.98 JDIM2800.214 ; v2(175.82,39.63) 175.42,39.23 175.42,38.44 175.82,38.04 JDIM2801.192 ; Q7601.4 92.08,133.93 v2(92.51,133.5) ; JDIM2800.227 107.6,43.26 v2(107.73,43.13) ; JDIM2800.176 94.85,38.81 94.67,38.99 v2(94.37,38.99) ; U400.F18 97.06,91.83 v1(97.06,91.92) ; PR8237.2 v2(132.7,26.22) 133.4,26.22 133.46,26.17 PC8223.2 ; v1(95.11,91.92) 95.11,91.83 U400.B18 ; JDIM2800.48 60.85,39.36 v2(60.36,39.85) ; v2(232.67,118.22) 232.99,118.54 CN6300.1 233.8,118.09 CN6300.A1 234.73,118.09 CN6300.B12 ; CN4300.27 212.31,11.84 v2(212.07,12.07) ; v2(69.83,39.99) 70.16,39.99 70.35,39.8 JDIM2800.86 ; v2(106.03,38.97) 106.29,38.97 106.51,38.75 106.51,38.13 106.35,37.97 JDIM2800.222 ; C5006.1 50.77,28.81 51.01,28.56 v2(51.01,28.44) 51.13,28.32 51.5,28.32 C5011.1 ; v1(115.06,96.5) 115.39,96.5 U400.AU10 ; JDIM2801.103 151.57,43.77 151.42,43.62 151.42,42.19 151.19,41.97 150.4,41.97 v2(150,42.37) 150.38,42.75 150.38,44.02 150.57,44.21 JDIM2801.99 ; v2(145.07,39.03) 145.32,38.79 JDIM2801.78 ; U400.B7 v1(93.96,98.45) ; U400.AM10 112.44,96.64 v1(112.3,96.5) ; v1(135.13,83.74) 134.73,83.34 134.68,83.29 U400.CH31 ; v2(58.97,42.14) 59.22,42.14 59.6,42.53 JDIM2800.43 ; v2(171.33,38.99) 171.46,38.99 171.81,38.63 JDIM2801.176 ; v1(126.57,93.81) 126.56,93.81 126.24,93.49 U400.BP15 126.53,93.17 126.53,92.98 U400.BR16 ; v2(178.32,38.33) JDIM2801.202 ; v2(70.32,43.58) 70.32,43.88 70.1,44.1 JDIM2800.85 ; v2(137.64,42.98) 137.96,43.3 137.96,43.89 137.57,44.29 JDIM2801.47 ; v1(117.84,96.5) 118.16,96.5 U400.BA10 ; CN5201.5 179.95,13.27 179.74,13.06 178.15,13.06 177.76,13.45 177.76,14.53 177.5,14.78 177.5,15.14 v2(177.76,15.4) ; CN3400.34 26.65,130.85 v2(26.6,130.8) ; JDIM2800.168 92.85,38.17 v2(93.02,38.33) ; CN4200.51 200.95,73.77 201,73.82 v2(201,74.12) ; JDIM2800.193 99.1,44.26 98.97,44.13 98.97,42.52 99.21,42.28 v2(99.7,42.28) 100.23,42.81 100.23,44.11 100.1,44.23 JDIM2800.197 ; v2(137.49,23.07) 137.35,23.21 PR8244.2 ; U400.BV31 129.25,83.22 129.53,82.94 129.56,82.94 v1(129.63,82.86) 129.61,82.85 129.61,82.45 129.07,81.91 129.03,81.87 U400.BV33 ; JDIM2801.180 v2(172.81,38.32) ; v2(177.26,21.13) 177.26,20.59 PR8609.2 ; JDIM2801.106 152.32,39.38 152.26,39.44 v2(152.26,39.68) 152,39.68 151.95,39.73 151.27,39.73 150.89,39.35 150.89,38.69 151.32,38.27 JDIM2801.102 ; v2(123.38,111.23) 123.38,110.62 Q402.1 122.48,110.43 122.31,110.27 122.31,109.5 121.94,109.13 Q402.4 ; v2(148.49,43.03) 149.07,43.6 JDIM2801.93 ; U400.CB2 131.14,101.92 131.14,103.01 v2(131.28,103.15) ; v2(51.24,43.69) 51.24,44.05 51.1,44.19 JDIM2800.9 ; CN7602.10 76.74,133.69 v2(77.5,132.92) ; JDIM2801.52 138.82,39.38 138.51,39.68 v2(138.34,39.68) ; U400.CM37 U400.CN37 U400.CP37 U400.CR36 138.96,79.84 139.45,79.84 v2(139.58,79.96) 139.58,80.19 139.63,80.24 139.63,80.63 138.93,81.33 U400.CR34 138.28,80.85 U400.CP35 ; JDIM2801.35 134.57,44.26 134.69,44.14 134.69,43.49 134.2,43.01 v2(134.2,43.01) ; JDIM2801.43 136.57,42.94 136.01,42.38 v2(135.42,42.38) ; U400.W7 104.66,98.21 v1(104.91,98.46) 105.16,98.21 U400.Y7 105.6,98.21 v1(105.82,98.43) 106.06,98.43 U400.AB7 ; JDIM2801.189 175.07,43.77 v2(175.61,43.23) ; JDIM2801.73 144.07,44.28 144.28,44.07 144.28,43.33 143.87,42.92 143.81,42.92 v2(143.77,42.96) ; JDIM2801.81 146.07,44.1 146.14,44.02 146.14,43.34 145.81,43.01 v2(145.65,43.01) 145.32,43.01 145.09,43.24 145.09,44.25 145.07,44.28 JDIM2801.77 ; JDIM2801.57 140.06,44.16 139.64,43.74 v2(139.61,43.74) ; CN4300.39 212.21,14.84 v2(212.03,15.02) ; v2(98.05,42.27) 97.93,42.4 97.93,43.24 98.1,43.41 JDIM2800.189 ; JDIM2800.201 101.1,42.66 100.77,42.32 100.77,41.84 101.08,41.52 v2(101.36,41.52) ; CN4300.73 212.62,23.34 212.53,23.25 v2(212.53,22.64) 212.73,22.84 CN4300.71 ; CN6300.2 233.21,116.2 232.15,116.2 v2(231.45,115.5) ; v2(106.03,41.13) 106.41,41.51 106.41,41.76 106.89,42.24 106.89,43.95 106.6,44.23 JDIM2800.223 ; U400.CJ11 135.51,96.62 v1(135.39,96.74) ; v2(144.01,39.02) 143.82,38.82 JDIM2801.72 ; JDIM2800.77 68.1,43.14 68.3,42.94 v2(68.71,42.94) 68.85,42.94 69.18,43.27 69.18,43.86 69.1,43.93 JDIM2800.81 ; JDIM2801.181 173.07,43.98 v2(172.7,43.62) ; JDIM2801.247 189.57,44.3 189.82,44.04 189.82,43.75 189.3,43.23 189.15,43.23 v2(189.13,43.2) ; v2(164.7,92.95) 164.7,92.03 164.95,91.77 CN4100.18 ; v1(135.28,90.68) 135.28,90.77 135.51,91.01 U400.CJ19 ; CN3400.18 34.65,131.72 34.45,131.52 v2(34.45,131) ; v1(99.01,93.81) 99.01,93.71 U400.J15 ; v2(63.15,41.74) 63.15,41.64 62.9,41.38 62.14,41.38 61.45,42.07 61.45,44 61.6,44.15 JDIM2800.51 ; v1(124.57,87.56) 124.57,87.42 124.65,87.34 U400.BL25 ; CN4100.7 162.2,83.76 161.59,84.37 161.47,84.37 v2(161.45,84.39) ; U400.CR2 139.16,101.74 v2(139.33,101.58) v2(139.98,101.58) v2(140.81,101.58) 141.69,101.58 142.17,101.09 143.18,101.09 143.96,100.31 v2(144.17,100.31) 144.94,99.54 149.19,99.54 149.28,99.63 152.04,99.63 152.49,100.09 v2(152.49,100.96) 152.49,101.85 v2(152.49,101.85) 152.49,101.86 151.66,102.68 v2(151.29,102.68) 150.84,103.14 149.9,103.14 v2(148.19,101.43) 147.43,102.19 145.37,102.19 145.12,102.44 143.85,102.44 v2(143.62,102.67) 143,103.29 141.1,103.29 140.57,103.81 v2(140.32,103.81) 140.32,103.45 139.8,102.92 139.32,102.92 138.87,103.38 v2(136.8,103.38) ; v2(194.05,70.58) 194.05,70.65 194.95,71.55 CN4200.27 ; JDIM2801.2 126.32,38.87 v2(125.84,39.35) ; v2(188.58,38.97) 188.82,38.73 JDIM2801.244 ; v2(152.48,97.18) 152.82,96.83 R539.2 ; U400.C4 95.32,99.71 v1(95.23,99.63) 94.89,99.63 U400.B5 ; v2(112.29,98.48) 112.11,98.48 U400.AL7 ; U400.BT15 127.54,93.48 127.87,93.81 v1(127.87,93.91) 127.87,93.97 U400.BT14 ; v2(36.36,131.3) 36.15,131.5 CN3400.15 ; v2(95.85,39.67) 96.24,39.67 96.85,39.05 JDIM2800.184 ; v2(54.86,39.36) 54.35,38.86 JDIM2800.22 ; v2(190.6,43.87) 190.57,43.9 JDIM2801.251 ; CN4300.3 211.54,5.84 v2(211.17,6.21) ; v2(53.96,39.85) 53.59,39.85 53.35,39.61 JDIM2800.18 ; CN4100.63 176.2,81.76 v2(176.18,81.74) ; v2(136.51,102.34) 136.51,102.34 U400.CL2 ; v2(136.51,102.34) 136.23,102.34 136.1,102.2 U400.CK1 ; v2(136.51,102.34) 136.87,102.34 U400.CM1 U400.CN1 ; v1(97.06,93.81) 97.06,93.71 U400.F15 ; v2(185.43,40.36) 185.64,40.36 186.1,39.9 186.1,38.22 186.32,38.01 JDIM2801.234 ; U400.AW1 117.29,102.38 v1(117.29,102.69) ; v2(62.34,39.85) 62.6,39.85 62.85,39.6 JDIM2800.56 ; C420.1 128.84,71.53 129.55,70.82 v2(129.55,69.75) ; v2(107.06,39.12) 107.27,39.12 107.53,38.86 107.53,38.14 107.35,37.96 JDIM2800.226 ; v2(185.4,38.97) 185.32,38.88 JDIM2801.230 ; U400.BW7 129.66,98.48 v1(129.88,98.48) ; v2(108.35,38.39) JDIM2800.230 ; v2(129.8,39.68) 129.54,39.68 129.32,39.45 JDIM2801.14 ; JDIM2801.23 131.57,44.12 131.48,44.04 131.48,42.73 132.03,42.18 v2(132.05,42.18) ; JDIM2800.2 v2(49.35,39.86) ; JDIM2800.202 v2(101.35,38.33) 101.58,38.56 101.58,38.71 101.96,39.09 102.32,39.09 102.57,38.84 102.57,38.18 102.35,37.96 JDIM2800.206 ; U400.CB3 U400.CB4 131.01,100.21 U400.BY5 ; JDIM2801.172 170.81,39.17 170.37,39.61 v2(170.16,39.61) ; JDIM2801.205 179.07,44.3 178.85,44.08 178.85,43.62 178.7,43.46 178.7,42.88 178.46,42.65 v2(178.06,42.65) ; v1(109.51,98.73) 109.51,98.66 U400.AF7 108.89,98.21 v1(108.62,98.48) 108.34,98.21 U400.AE7 ; v1(99.01,95.72) 99.01,95.59 U400.J12 ; U400.CP21 U400.CN21 137.46,89.63 v1(137.22,89.87) 136.98,89.63 U400.CM21 ; PU8600.18 PU8600.21 ; JDIM2801.226 184.32,39.88 183.91,40.29 v2(183.69,40.29) 183.57,40.29 183.17,39.89 183.17,39.04 183.32,38.89 JDIM2801.222 ; JDIM2800.243 111.6,44.24 111.41,44.05 111.41,43.67 v2(112.02,43.06) 112.09,43.06 112.81,43.77 112.81,44.02 112.6,44.23 JDIM2800.247 ; CN5001.1 140.95,14.84 140.78,15.02 140.6,15.02 140.45,14.86 CN5001.2 140.45,13.95 140.13,13.63 v2(140.13,13.53) ; v2(212.35,7.94) 212.37,7.94 212.97,7.34 CN4300.9 ; U400.B9 94.41,97.19 v1(94.06,96.85) ; JDIM2800.103 74.6,44.22 v2(74.23,43.85) ; U400.BT28 127.5,85.17 v1(127.87,84.8) ; JDIM2800.107 v2(75.6,43.95) ; v2(105.85,43.26) 105.1,44.01 JDIM2800.217 ; v2(199.15,75.42) 199.15,75.09 199.45,74.78 CN4200.45 ; U400.BY18 U400.BY19 130.14,90.81 v1(129.83,90.51) ; JDIM2801.206 179.32,38.06 179.53,38.28 179.53,38.69 v2(179.1,39.12) ; JDIM2801.238 187.32,38.77 v2(187.51,38.97) ; v2(55.18,42.27) 55.13,42.27 54.6,42.79 JDIM2800.23 ; v2(135.42,43.67) 135.4,43.68 135.4,43.94 135.57,44.1 JDIM2801.39 ; v2(147.81,39.67) 148.04,39.67 148.32,39.4 JDIM2801.90 ; JDIM2800.30 56.35,38.97 v2(56.59,39.2) ; v2(103.41,38.33) 103.35,38.28 JDIM2800.210 ; JDIM2800.188 97.85,38.61 v2(97.39,39.07) ; JDIM2800.19 53.6,44.3 53.8,44.1 53.8,43.44 v2(53.32,42.96) ; v1(97.95,96.77) 97.62,97.1 U400.G9 ; v2(61.37,39.84) 61.6,39.84 61.85,39.58 JDIM2800.52 ; v2(146.79,39.68) 147,39.68 147.32,39.36 JDIM2801.86 ; v2(179.33,42.7) 179.63,42.7 179.96,43.03 179.96,44.19 180.07,44.3 JDIM2801.209 ; v2(103.36,42.65) 103.56,42.65 104.1,43.19 JDIM2800.213 ; v2(70.87,39.09) 71.1,39.09 71.35,38.84 JDIM2800.90 ; U400.W10 104.76,96.64 v1(104.9,96.5) ; U400.BP25 126.24,86.81 v1(126.58,87.15) 126.89,86.84 U400.BR25 ; JDIM2801.171 170.57,44.28 170.75,44.09 170.75,43.13 170.32,42.7 v2(170.24,42.7) ; v2(142.46,39.7) 142.47,39.7 142.82,39.35 JDIM2801.68 ; JDIM2801.185 174.07,44.3 174.27,44.09 174.27,43.87 v2(173.57,43.16) ; U400.CM31 137.18,83.27 v1(136.72,83.27) ; v2(55.85,39.84) 55.51,39.84 55.35,39.68 JDIM2800.26 ; U400.C9 95.2,97.17 v1(95.58,96.79) 95.94,97.16 U400.D9 ; v1(135.33,81.29) 135.33,81.8 U400.CJ33 135.1,82.03 v1(134.73,82.03) 134.55,81.85 U400.CG33 134.02,81.89 133.61,81.89 v1(133.38,82.12) 133.11,81.85 U400.CE33 ; U400.B25 U400.C25 ; v2(139.3,85.76) 139.21,85.84 U400.CP27 ; R605.1 v2(95.18,106.43) ; v2(212.08,9.93) 212.11,9.96 212.56,9.96 212.93,10.34 CN4300.21 ; U400.BU24 128.19,87.63 v1(127.82,87.99) 128.19,88.36 U400.BU23 ; v2(145.78,39.68) 146.08,39.68 146.32,39.44 JDIM2801.82 ; JDIM2800.235 109.6,44.08 v2(109.73,43.95) ; U400.BP33 v1(126.86,82.19) 126.83,82.19 126.48,82.54 U400.BP32 ; JDIM2800.47 60.6,44.15 60.87,43.88 60.87,42.94 60.56,42.63 v2(60.37,42.63) ; U400.H21 98.03,89.81 v1(97.71,90.14) 97.38,89.81 U400.G21 ; JDIM2800.185 97.1,44.1 97.11,44.09 97.11,41.76 v2(96.66,41.31) 96.33,41.31 96.07,41.56 96.07,44.2 96.1,44.23 JDIM2800.181 ; v2(135.52,39) 135.52,38.33 135.82,38.04 JDIM2801.40 ; JDIM2801.18 130.32,39.53 130.48,39.7 v2(130.82,39.7) ; JDIM2800.89 71.1,44.3 71.07,44.27 71.07,42.62 70.69,42.24 v2(70.3,42.24) ; JDIM2800.99 73.6,44.21 73.29,43.89 73.29,43.42 72.86,42.99 v2(72.86,42.99) ; v1(131.77,90.56) 131.44,90.9 U400.CB19 U400.CB18 ; v2(123.55,96.2) 123.55,96.35 U400.BK10 ; U400.F12 97.06,95.59 v1(97.06,95.72) ; JDIM2800.1 49.1,43.92 48.77,43.59 48.77,43.05 49.14,42.68 v2(49.39,42.68) 50.1,43.4 JDIM2800.5 ; v1(119.66,98.56) 119.85,98.56 U400.BD6 ; JDIM2801.22 131.32,39.44 131.58,39.71 v2(131.86,39.71) ; JDIM2800.244 111.85,38.48 112.1,38.72 112.1,39.5 111.62,39.98 v2(111.62,39.98) ; U400.K9 99.24,97.1 v1(98.92,96.77) 98.59,97.1 U400.H9 ; v1(130.57,84.93) 130.4,84.93 130.16,85.17 U400.BY28 ; JDIM2800.98 73.35,38.9 73.16,39.09 v2(72.88,39.09) ; v2(168.42,81.6) 168.42,81.98 168.7,82.26 CN4100.33 ; JDIM2800.82 69.35,38.99 69.16,39.18 v2(68.87,39.18) ; U400.BG25 121.92,87.57 v1(121.98,87.64) ; CN4300.45 212.09,16.34 v2(212.09,16.34) ; JDIM2801.214 181.32,38.56 v2(181.77,39.02) ; JDIM2801.9 128.07,43.4 127.66,43 v2(127.49,43) 127.47,43 126.93,43.54 126.93,44.13 127.07,44.26 JDIM2801.5 ; v2(56.93,33.57) 56.52,33.17 C5014.1 ; U400.CA15 130.9,93.57 130.9,93.76 v1(131.05,93.91) ; U400.J18 99.01,91.83 v1(99.01,91.92) ; v2(93.12,40.85) 93.6,41.33 JDIM2800.171 ; v1(135.36,87.41) 135.36,87.84 U400.CJ23 ; U400.BT35 v1(127.78,81.23) U400.BT33 ; v2(50.86,39.85) 50.63,39.85 50.35,39.58 JDIM2800.6 ; JDIM2801.56 139.82,39.45 139.56,39.7 v2(139.35,39.7) ; v2(191.51,73) 191.07,73 190.95,72.88 CN4200.11 ; JDIM2801.107 152.57,42.52 152.61,42.47 v2(152.61,42.45) ; JDIM2800.172 93.85,38.9 93.43,39.32 v2(93.43,39.5) ; v2(152.54,20.63) 152.11,20.21 PQ8703.4 ; JDIM2801.167 169.57,44.25 169.49,44.18 v2(169.49,43.88) ; v2(186.69,43.9) 186.57,44.02 JDIM2801.235 ; U400.CG7 133.81,98.21 133.81,98.2 v1(133.51,97.9) 133.2,98.21 U400.CE7 ; v2(181.79,39.65) 182.07,39.65 182.32,39.41 JDIM2801.218 ; JDIM2801.175 v2(171.57,43.74) ; v2(65.84,42.29) 65.39,42.29 65.14,42.54 65.14,44.19 65.1,44.23 JDIM2800.65 ; U400.P7 101.34,98.21 v1(101.2,98.35) ; U400.AW4 116.87,100.02 116.87,99.28 U400.AV6 ; v2(140.19,42.31) 139.77,41.89 139.07,41.89 138.52,42.43 138.52,44.08 138.57,44.12 JDIM2801.51 ; v2(185.33,43.13) 185.54,43.13 185.78,43.37 185.78,44.05 185.57,44.26 JDIM2801.231 ; JDIM2800.231 108.6,44.24 108.81,44.03 108.81,43.86 109.05,43.63 109.05,42.26 107.97,41.18 v2(107.76,41.18) ; CN4200.3 188.95,73.5 189.26,73.81 189.58,73.81 v2(189.67,73.72) 189.45,73.5 CN4200.5 ; v1(119.18,87.64) U400.BC25 ; JDIM2801.184 173.81,38.69 172.85,39.65 v2(172.83,39.65) ; U400.BV3 v1(128.65,100.7) U400.BV4 128.54,100.21 128.13,99.8 127.83,99.8 U400.BT5 ; JDIM2801.36 134.82,38.81 v2(134.62,39) ; JDIM2801.223 183.57,44.23 183.85,43.94 183.85,42.91 184.29,42.47 v2(184.88,42.47) ; U400.CF28 133.87,85.17 v1(134.15,84.89) ; U400.CF19 133.5,91.04 v1(133.5,90.64) ; PR9310.2 155.96,20.2 155.96,19.2 v2(156.25,18.91) ; JDIM2800.69 66.1,43.85 v2(65.84,43.59) ; v2(128.8,39.66) 128.53,39.66 128.32,39.44 JDIM2801.10 ; JDIM2800.205 102.1,44.21 101.89,44 101.89,42.91 102.27,42.53 v2(102.39,42.53) 102.5,42.53 102.87,42.9 102.87,44.06 103.1,44.3 JDIM2800.209 ; v2(147.83,122.42) 147.63,122.22 PC9213.2 ; U400.AV8 116.13,97.56 v1(115.99,97.7) ; JDIM2800.40 58.85,38.19 58.56,38.48 v2(58.56,39.2) ; v2(210.72,20.26) 210.72,19.82 211.31,19.23 211.31,18.67 212.33,17.66 212.73,17.66 212.91,17.84 CN4300.51 ; CN4300.77 210.43,24.94 v2(210.27,25.1) ; v1(109.52,96.5) 109.66,96.64 U400.AG10 ; v2(175.65,42.59) 175.92,42.59 176.09,42.77 176.09,44.18 176.07,44.21 JDIM2801.193 ; JDIM2800.35 57.6,44.14 57.86,43.88 57.86,43.26 57.63,43.03 v2(57.36,43.03) ; U400.BC8 119.54,97.56 v1(119.68,97.7) 119.68,97.74 U400.BD7 ; v2(184.64,43.77) 184.57,43.84 JDIM2801.227 ; JDIM2800.78 68.35,38.97 v2(68.11,39.21) ; v2(200.64,75.98) 201.17,75.98 202.45,74.7 CN4200.57 ; v1(129.13,93.86) 129.13,93.83 129.49,93.48 U400.BW15 U400.BY15 ; U400.CE33 132.63,82.03 v1(132.07,82.03) 131.73,82.03 U400.CB33 ; U400.CE33 132.73,81.77 v1(132.73,81.22) 132.73,80.99 132.81,80.9 U400.CE35 ; U400.AV25 116.45,87.39 v1(116.72,87.66) ; v1(136.36,86.52) 136.81,86.98 U400.CM25 U400.CN25 ; v2(170.11,38.33) 169.82,38.03 JDIM2801.168 ; v1(136.3,82.07) 136.32,82.06 U400.CM33 ; U400.AC5 107.21,99.69 U400.AB4 v1(106.69,100.72) U400.AB3 ; v2(212.02,13.11) 212.25,13.34 CN4300.33 ; v2(189.54,38.31) 189.82,38.03 JDIM2801.248 ; U400.BY36 130.33,79.96 v2(130.33,79.09) ; JDIM2800.175 94.6,44.25 94.83,44.02 94.83,43.02 94.24,42.44 94.24,40.52 v2(94.34,40.42) ; JDIM2801.201 v2(178.07,43.95) ; v2(142.78,42.35) 142.22,42.9 142.22,44.13 142.06,44.28 JDIM2801.65 ; v2(165.18,81.56) 165.2,81.58 CN4100.19 ; U400.BE10 121.39,96.64 v1(121.53,96.5) ; v2(132.62,27.56) 132.62,28.03 132.46,28.18 PC8221.2 131.74,28.18 130.97,27.41 PC8220.2 ; v2(52.38,43.72) 52.6,43.95 JDIM2800.15 ; JDIM2800.36 57.85,39.03 v2(57.66,39.22) ; CN6300.B1 234.73,112.59 CN6300.A12 233.57,112.59 233.35,112.37 CN6300.4 233.35,111.15 CN6300.6 ; v2(142.78,43.03) 143.19,43.03 143.31,43.16 143.31,43.92 143.06,44.17 JDIM2801.69 ; PC8700.2 146.01,13.61 PC8701.1 146.01,12.99 v2(146.54,12.46) ; JDIM2800.57 63.1,43.72 v2(62.8,43.41) ; C401.2 149.96,72.66 v2(150.1,72.52) ; v2(58.86,43.49) 58.68,43.67 58.68,43.8 58.6,43.87 JDIM2800.39 ; U400.BT25 127.54,86.79 v1(127.9,87.15) 128.19,86.86 U400.BU25 ; v1(107.67,96.5) 107.53,96.64 U400.AC10 ; U400.CB7 131.31,98.21 131.62,97.89 v1(131.71,97.89) 131.84,97.89 U400.CC7 ; PC9221.2 138.87,116.52 v2(139,116.65) 138.82,116.83 PC9222.2 ; v2(145.47,115.23) 145.09,115.61 PU9202.3 ; v1(95.11,93.81) 95.11,93.71 U400.B15 ; v1(135.75,93.71) 135.75,93.98 135.51,94.22 U400.CJ14 ; JDIM2801.6 127.32,39.25 127.79,39.72 v2(127.87,39.72) ; PC8715.1 140.93,16.6 140.93,17.81 141.22,18.1 PR8702.1 141.73,18.1 v2(142.19,17.64) ; v2(149.81,39.65) 149.93,39.65 150.32,39.26 JDIM2801.98 ; U400.D6 96.24,99.02 v1(96.59,99.37) 96.28,99.67 U400.D5 ; C5015.1 54.82,34.05 ; JDIM2800.31 56.6,42.56 56.15,42.1 v2(56.14,42.1) ; U400.CC31 132.41,83.69 v1(132.41,84.03) ; v2(64.13,42.25) 64.37,42.25 64.57,42.45 64.57,43.82 64.1,44.29 JDIM2800.61 ; v2(133.07,42.32) 133.57,42.82 JDIM2801.31 ; v2(113.85,38.33) JDIM2800.252 ; v2(212.84,20.39) 212.98,20.25 212.98,19.55 213.19,19.34 CN4300.57 ; PC8609.2 v2(176.23,21.42) 175.98,21.42 175.73,21.66 PR8604.2 ; U400.BP7 126.41,98.21 126.28,98.33 v1(126.15,98.33) 126.04,98.33 125.92,98.21 U400.BN7 ; v1(131.53,85.53) 131.66,85.53 131.94,85.24 U400.CC28 ; CN4100.45 171.7,82.1 171.14,81.54 169.1,81.54 v2(169.07,81.57) 169.42,81.92 170.01,81.92 170.2,82.1 CN4100.39 ; U400.B12 95.11,95.59 v1(95.11,95.72) ; v2(65.34,39.88) 65.65,39.88 65.85,39.67 JDIM2800.68 ; U400.E9 v1(96.59,97.7) 96.4,97.89 U400.D8 ; v2(52.84,39.09) 52.35,38.6 JDIM2800.14 ; CN4100.69 177.7,83.97 177.88,84.15 179.03,84.15 179.2,83.98 CN4100.75 179.2,81.63 v2(178.97,81.4) 179.32,81.4 180.3,82.38 CN4100.77 ; v2(174.35,38.97) 174.81,38.5 JDIM2801.188 ; JDIM2800.251 113.6,44.3 114.03,43.88 114.03,43.34 113.65,42.96 v2(113.51,42.96) ; JDIM2801.85 147.07,43.74 v2(147.01,43.68) ; U400.CK7 136.13,97.93 v1(136.3,97.93) ; JDIM2801.19 130.57,44.23 130.92,43.87 130.92,42.91 130.56,42.55 v2(130.03,42.55) 129.57,43.02 JDIM2801.15 ; v2(180.6,38.56) 180.32,38.28 JDIM2801.210 ; JDIM2800.73 67.1,44.29 67.37,44.02 67.37,43.61 66.86,43.11 v2(66.84,43.11) ; v2(66.85,39.22) JDIM2800.72 ; v2(99.85,38.39) JDIM2800.196 ; JDIM2801.243 188.57,43.44 188.31,43.18 v2(188.02,43.18) 187.81,43.18 187.57,43.43 JDIM2801.239 ; U400.P10 101.99,96.64 v1(102.13,96.5) ; U400.AJ7 110.68,98.43 v2(110.45,98.43) ; v1(113.72,87.51) U400.AN25 ; JDIM2801.64 141.82,39.48 141.57,39.72 140.4,39.72 v2(140.39,39.72) 140.82,39.29 JDIM2801.60 ; v2(105.35,38.82) JDIM2800.218 ; CN4300.1 211.29,5.34 v2(210.4,6.23) ; U400.B21 94.59,89.61 v1(95.11,90.14) 95.2,90.04 U400.C21 ; JDIM2800.94 72.35,38.88 72.15,39.09 v2(71.86,39.09) ; v2(153.12,16.78) 153.12,17.07 153.41,17.37 PQ8703.1 ; v2(176.82,38.36) JDIM2801.196 ; JDIM2800.106 75.35,38.15 75.49,38.28 75.49,38.62 75.08,39.03 v2(74.89,39.03) ; U400.BG4 122.36,99.88 v1(122.39,99.88) 123.44,99.88 U400.BK4 ; v2(125.08,43.82) 125.08,44.73 125.57,45.23 JDIM2801.1 ; v2(142.86,84.1) 142.86,84.51 142.76,84.61 C467.1 ; U400.BM35 U400.BM36 ; U400.BP19 126.24,90.89 v1(126.6,90.53) 126.89,90.82 U400.BR19 ; v2(132.67,122.95) 132.43,123.19 PU9200.19 ; U400.J21 98.68,89.81 98.97,90.1 v1(99.01,90.14) 99.33,89.81 U400.K21 U400.K22 ; v2(73.9,39.08) 74.09,39.08 74.35,38.81 JDIM2800.102
  BOTTOM w0.305: R516.2 144.95,90.69 v2(145.43,90.69) 145.85,90.69 R513.2 ; U400.CC20 132.09,90.25 v1(131.77,90.56) 131.44,90.22 U400.CB20 131.4,90.07 131.4,89.88 U400.CA22 U400.BY22 ; CN4400.10 218.8,22.05 218.52,21.77 v2(217.1,21.77) ; U400.CC16 131.64,93.07 131.18,93.07 U400.CA15 ; C5010.1 54.03,28.5 53.55,28.02 v2(53.52,28.02) 53.37,28.18 53.07,28.47 53.07,28.47 C5007.1 ; U400.CN1 U400.CP1 U400.CR2 138.75,101.73 138.29,101.73 U400.CP2 138.07,101.64 U400.CN2 137.08,101.64 136.94,101.78 U400.CL2 ; v2(220.18,23.63) 220.3,23.5 CN4400.7 ; C5008.1 53.68,26.73 v2(53.58,26.62) 53.48,26.73 C5005.1 ; v2(221.35,21.77) 221.52,21.77 221.8,22.04 CN4400.4 ; v1(126.56,94.79) 126.24,95.12 U400.BP12 ; v2(43.79,31.14) 43.79,31.55 v2(44.05,31.81) ; v2(62.59,28.82) 62.51,28.73 CN6200.4 ; C5003.1 51.21,26.73 v2(51.08,26.6) ; v2(140.22,79.96) v2(139.58,79.96) ; U400.CN17 137.53,92.31 v1(137.26,92.31) 137.09,92.15 U400.CM17 ; v1(133.5,90.64) 133.5,90.61 132.99,90.1 U400.CD20 ; CN7702.6 171.45,10.97 v2(171.5,10.91)
  BOTTOM w0.381: v2(226.04,53.68) 226.04,53.84 v2(225.69,54.19) 225.67,54.21 C5713.3 ; R457.1 113.52,106.71 v2(113.6,106.79) ; C6204.2 67.38,30.65 v2(67.7,30.97) ; R575.2 142.49,79.39 v1(142.02,79.86) ; v2(194.18,19.87) 194.18,19.8 193.67,19.28 PC8639.1 ; v2(224.92,24.94) 224.42,24.94 224.12,25.25 C4402.2 C4401.2 C4400.2 ; v2(52.28,113.67) 51.98,113.98 PC8913.1 ; v2(65.11,29.09) 65.13,29.11 C6206.2 ; C430.2 132.09,71.81 v2(132.09,70.67) ; v2(131,70.69) 131,70.74 130.01,71.73 C471.2 ; v2(220.38,13.42) 220.38,12.98 220.16,12.76 R3618.2 ; C5001.1 136.41,14.68 v2(136.41,14.23) ; v2(150.31,102.5) 149.69,101.88 Y400.4 ; R588.1 154.59,98.8 155.08,98.8 v2(155.16,98.87) ; v2(113.32,111.97) 113.68,112.33 PR8833.2 ; v2(134.96,17.2) 135.06,17.1 PQ8206.1 ; v2(141.21,99.37) 141.26,99.32 C472.2 ; C546.1 106.61,111.13 v2(106.84,111.36) ; PR9210.2 127.03,128.13 v2(127.03,128.73) ; PC8714.2 148.66,19.82 v2(149.13,19.82) ; R518.2 147.37,91.93 v2(147.13,91.69) ; v2(229.93,81.16) 229.74,81.35 R4013.1 229.19,81.97 228.99,82.17 C4037.2 ; C4318.1 204.28,16.26 204.87,15.66 v2(204.92,15.66) ; PC8217.2 126.01,17.3 v2(126.04,17.3) 126.07,17.3 PC8219.2 ; R507.2 143.85,85.02 v2(143.84,85.03) ; v2(150.79,11.13) 150.79,12.07 PR8714.2 ; v2(134.44,70.66) 134.44,71.46 C426.2 ; v2(64.12,29.09) C6205.2 ; v2(69.58,126.42) 69.58,125.05 69.3,124.77 U7601.2 ; C4108.1 172.35,92.33 172.16,92.14 v2(172.16,91.69) ; v2(8.15,107.03) 8.15,107.05 8.14,107.07 PC8102.1 PR8116.2 ; PC8617.2 177.06,25.06 177.35,24.77 v2(177.35,24.72) ; v2(61.32,28.82) C6202.2 ; CN7701.31 166.69,74.73 165.59,73.63 164.3,73.63 v2(164.24,73.69) ; PC9030.2 PC9031.2 115.21,121.09 v2(114.64,121.66) ; U5600.4 173.29,72.91 173.97,73.59 v2(174.35,73.59) ; v2(133.18,70.69) 133.18,71.02 133.1,71.1 C427.2 ; v2(188.4,71.18) 188.17,71.18 187.35,72 CN4200.76 ; C4104.2 162.15,93.52 v2(161.51,93.52) 161.24,93.52 161.22,93.54 C4105.2 ; v2(226.66,113.88) 227.53,113.88 PCN8000.10 ; v2(205.27,86.19) 205.06,86.19 204.8,86.45 C4204.1 ; v2(131.09,20.78) 130.51,21.36 PR8224.1 ; v2(229.27,63) 228.92,63.34 C3518.2 ; C540.1 119.33,109.28 v2(119.64,109.59) ; Q5003.1 137.98,21.72 v2(138.18,21.92) ; C4236.1 202.44,82.59 203,83.15 v2(203.03,83.15) 203.59,82.59 C4237.1 ; v2(213.34,81.59) 213.09,81.59 212.71,81.21 212.71,79.43 212.22,78.94 C7851.1 211.53,78.94 211.3,78.71 C4202.1 C4203.2 ; v2(96.99,33.58) 97.32,33.58 97.37,33.53 PU8201.2 101.51,33.53 102.23,32.81 PC8222.1 ; v2(231.6,111.17) 231.12,110.7 U6301.8 U6301.3 229.49,110.7 229.1,110.31 v2(228.97,110.31) ; C5702.1 225.5,29.59 225.63,29.71 v2(225.91,29.71) ; v2(147.16,98.19) 146.9,97.93 C473.2 ; v2(138.68,13.59) 138.68,13.1 139.62,12.16 140.83,12.16 141.1,11.89 CN5001.9 ; C541.1 116.18,109.93 v2(116.24,109.99) ; R627.2 v2(143.34,104.31) ; C400.2 99.17,110.07 R401.1 99.87,109.51 100.33,109.05 v2(100.33,108.64) ; CN4201.10 200.04,57.05 199.02,57.05 v2(198.51,57.55) ; v2(170.16,10.95) 169.45,10.24 CN7702.10 ; v2(151.56,100.38) 150.82,100.38 Y400.2 ; C4207.1 C4200.2 188.32,84.27 v2(188.63,84.59) ; PC8100.2 v2(2.67,113.93) ; v2(150.56,98.92) 150.61,98.86 C423.1 ; R542.2 148.79,96.23 v2(149.44,96.23) ; C586.1 101.58,109.58 101.88,109.88 v2(101.88,110.15) ; v2(62.59,28.82) 63.1,29.32 C6203.2 ; v2(196.82,21.76) 196.38,21.76 PR8616.2 ; PCN8000.10 228.4,113.16 228.44,113.2 v2(229.32,113.2) ; PCN8000.10 227.67,113.16 v2(226.67,112.16) ; v2(73.29,127.08) 72.97,127.4 CN7602.13 ; PQ8503.1 135.11,20.81 v2(135.39,21.09) ; PC8908.1 v2(55.12,114.19) ; v2(103.14,105.06) 103.14,105.7 C592.1 ; PC8224.1 132.78,22.73 v2(132.78,22.95) ; v2(112,110.8) 112,110.32 C598.1 C599.1 ; v2(29.26,25.37) 29.92,24.7 C7628.2 ; v2(176.79,94.38) 177.96,93.2 C4101.2 C4102.1 ; C641.1 103.53,112.13 v2(103.31,112.35) ; CN5001.10 135.95,11.89 v2(135.84,11.99) ; PC8206.2 115.33,34.48 v2(115.2,34.35) ; R610.2 113.79,107.39 114.23,107.83 v2(114.26,107.83) ; v2(226.62,24.82) C4403.2 ; H7910.1 34,28.76 36.04,28.76 C7625.1
  BOTTOM w0.457: v2(226.07,51.11) 226.07,51.45 v2(225.83,51.68) 225.5,51.68 225.31,51.49 U5702.3 U5702.8
  BOTTOM w0.508: C7859.1 148.38,120.62 148.38,121.88 v2(147.83,122.42) ; PC9002.1 54.65,105.86 v2(54.97,106.18) ; PC8211.2 122.79,27.55 v2(122.79,28.45) ; JDIM2801.262 191.69,53.13 191.09,52.53 v2(191.08,52.53) ; PC9017.1 51.5,106.31 v2(51.64,106.18) ; v2(144.28,84) 145.11,84 R509.1 145.29,83.77 144.55,83.03 R629.1 ; v2(147.9,117.77) 147.9,117.72 148.44,117.19 C468.1 C469.1 ; v2(55.74,121.74) 55.74,122.08 55.35,122.46 54.69,122.46 PC8921.1 ; CN5201.10 177.45,10.04 ; PC9032.2 106.64,129.77 106.15,129.29 v4(106.15,128.43) ; v2(143.36,86.87) 143.36,86.87 142.77,86.87 C449.1 ; v2(45.73,111.21) 44.92,110.39 43.72,110.39 43.54,110.57 C5405.2 ; v2(215.54,108.59) 215.27,108.32 215.26,108.06 215.25,108.05 PC8000.2 ; PC8203.1 126.83,30.31 126.96,30.18 v2(128.13,30.18) ; v2(121.34,28.45) 121.34,29.37 123.27,31.3 PC8205.2 ; v2(137.63,113.67) 137.06,113.67 PC9219.2 ; v2(119.97,104.78) 119.97,104.97 C639.1 ; VC5701.2 220.93,42.38 221.78,41.53 221.78,39.67 222.2,39.25 U5701.2 ; C5700.2 VC5700.1 224.96,34.59 v2(225.09,34.72) ; C474.2 129.37,108.89 129.37,110.06 C476.2 129.37,110.28 v2(128.5,111.16) ; PC8926.1 49.95,119.48 v2(49.95,118.9) ; v2(196.4,24.82) 195.88,25.34 PR8625.2 ; PR8247.1 133.16,30.33 v2(133.54,30.71) ; v2(146.86,101.3) 146.37,101.3 146.06,101.61 C424.2 ; v2(38.58,34.86) 38.67,34.86 39.51,34.02 CN5000.43 ; v2(158.23,104.65) 157.91,104.32 C451.2 ; v2(148.05,100.31) 147.86,100.12 146.1,100.12 C425.2 ; CN5201.9 182.95,9.91 ; C7868.1 v2(162.8,21.39) ; v2(211.74,62.56) 211.17,61.98 CN4201.5
  vias: v1(79.66,40.34) v1(80.35,43.03) v1(80.91,38.99) v1(85.4,42.6) v1(88.27,81.97) v1(89.44,81.92) v1(89.87,89.85) v1(89.92,84.03) v1(89.98,88.64) v1(89.98,85.32) v1(90.56,89.9) v1(91.12,84.03) v1(91.5,76.61) v1(91.7,88.17) v1(92.01,85.32) v1(92.06,86.7) v1(92.29,84.03) v1(92.62,89.72) v1(92.79,72.22) v1(92.92,80.04) v1(93.4,102.32) v1(93.51,80.04) v1(93.71,74.73) v1(93.98,102.32) v1(94.55,102.32) v1(95.06,76.21) v1(95.88,84.58) v1(95.92,82.05) v1(95.89,80.98) v1(96.17,77.6) v1(96.41,87.33) v1(96.54,86.36) v1(96.67,81.31) v1(96.87,88.38) v1(97.16,71.84) v1(97.37,74.33) v1(97.77,84.97) v1(98.65,85.52) v1(99.07,76.94) v1(99.36,99.37) v1(99.58,85.58) v1(99.74,82.2) v1(100.25,99.32) v1(100.5,85.5) v1(100.53,84.78) v1(101.13,72.6) v1(101.41,85.63) v1(101.43,83.71) v1(102.28,89.61) v1(102.34,85.65) v1(102.32,85.05) v1(102.32,84.4) v1(102.32,83.75) v1(102.52,91.42) v1(102.57,81.23) v1(103.03,89.74) v1(103.18,95.33) v1(103.23,93.35) v1(103.16,91.42) v1(103.25,85.62) v1(103.25,83.71) v1(103.31,75.9) v1(103.31,74.68) v1(103.72,89.69) v1(103.82,93.34) v1(104.14,85.69) v1(104.14,83.73) v1(104.4,93.32) v1(104.35,89.69) v1(105.07,85.62) v1(105.13,81.31) v1(105.97,85.61) v1(105.98,84.26) v1(105.95,83.67) v1(106.08,77.04) v1(106.15,75.29) v1(106.15,74.12) v1(106.87,85.64) v1(107.32,74.91) v1(107.45,89.62) v1(107.62,81.2) v1(107.58,77.22) v1(107.77,85.63) v1(107.79,84.4) v1(107.8,83.73) v1(108.11,89.59) v1(108.77,89.59) v1(109.61,83.75) v1(109.71,87.97) v1(110.15,81.28) v1(110.27,87.66) v1(110.45,85.48) v1(110.5,84.23) v1(110.53,82.27) v1(110.57,76.21) v1(111.44,84.79) v1(111.45,82.33) v1(112.23,75.7) v1(112.35,84.84) v1(112.3,73.31) v1(112.68,81.27) v1(113.26,84.84) v1(113.26,84.19) v1(113.31,83.57) v1(114.13,100.74) v1(114.15,82.31) v1(114.51,76.59) v1(114.56,74.76) v1(115.07,84.92) v1(115.12,84.21) v1(115.17,100.06) v1(115.19,81.2) v1(115.55,93.4) v1(115.55,91.12) v1(115.55,88.88) v1(115.71,71.76) v1(116.04,99.83) v1(115.98,84.89) v1(116.14,75.65) v1(116.19,93.4) v1(116.19,91.12) v1(116.19,88.88) v1(116.42,100.72) v1(116.82,93.4) v1(116.82,91.12) v1(116.85,88.88) v1(116.9,84.89) v1(116.92,84.23) v1(116.96,83.54) v1(117.7,81.23) v1(117.74,77.32) v1(117.84,84.87) v1(117.84,84.18) v1(117.86,74.22) v1(118.75,84.82) v1(118.85,100.74) v1(120.1,100.03) v1(120.24,81.23) v1(120.46,76.46) v1(120.56,84.82) v1(120.76,93.78) v1(120.76,92.26) v1(120.76,90.73) v1(120.88,89.18) v1(121.14,100.74) v1(121.28,95.97) v1(121.32,87.66) v1(122.33,84.87) v1(122.29,82.89) v1(122.37,84.19) v1(123.33,84.87) v1(123.33,82.89) v1(125.11,81.35) v1(126.35,73) v1(126.27,72.22) v1(127.16,73.06) v1(129.14,95.63) v1(131.76,95.61) v1(133.74,93.76) v1(134.5,99.9) v1(139.84,82.23) v2(1.05,116.9) v2(1.05,113.85) v2(1.05,111.31) v2(1.05,108.77) v2(1.05,105.72) v2(1.13,102.06) v2(2.51,116.76) v2(2.51,116.12) v2(2.55,102.01) v2(3.51,106.63) v2(4.11,107.96) v2(4.45,118.19) v2(5.19,108.03) v2(5.85,110.34) v2(5.87,108.03) v2(7.5,118.19) v2(7.86,116.54) v2(8.62,116.52) v2(10.04,118.19) v2(11.49,112.1) v2(12.1,108.46) v2(12.25,110.5) v2(12.58,118.19) v2(14.97,93.86) v2(15.12,118.19) v2(17.64,91.93) v2(17.66,118.19) v2(20.48,118.98) v2(20.94,128.53) v2(20.94,123.81) v2(20.94,121.52) v2(20.96,88.88) v2(21.42,132.26) v2(22.33,125.25) v2(22.92,125.63) v2(23.53,86.11) v2(23.66,24.77) v2(24.7,133.76) v2(26.12,82.86) v2(26.2,95.69) v2(26.6,128.25) v2(27.42,27.23) v2(27.75,133.76) v2(28.13,79.53) v2(28.53,127.79) v2(28.71,21.39) v2(29.42,20.1) v2(29.7,127.31) v2(29.75,76.41) v2(29.95,126.68) v2(30.29,133.76) v2(30.34,127.31) v2(30.77,110.22) v2(30.99,123.09) v2(31.63,123.1) v2(31.63,72.6) v2(32.39,126.04) v2(33.46,20.15) v2(34.5,126.04) v2(34.93,128.3) v2(35.34,108.26) v2(35.31,72.42) v2(35.37,133.76) v2(35.49,108.88) v2(36,20.1) v2(36.48,129.27) v2(36.46,69.02) v2(36.46,65.97) v2(36.46,63.43) v2(36.46,60.89) v2(36.46,58.35) v2(36.46,55.81) v2(36.46,52.76) v2(36.46,50.22) v2(36.46,47.68) v2(36.46,45.14) v2(36.46,42.6) v2(36.46,39.55) v2(36.46,36.51) v2(36.46,33.46) v2(36.58,127.97) v2(37.78,128.1) v2(37.78,29.7) v2(37.91,133.76) v2(38.21,35.49) v2(39.05,20.1) v2(39.48,101.96) v2(39.48,100.26) v2(39.48,98.94) v2(40.9,56.97) v2(41.46,101.96) v2(41.46,100.43) v2(41.46,98.94) v2(41.82,115.91) v2(41.77,25.58) v2(42.1,114.84) v2(42.1,20.1) v2(43.13,31.14) v2(43.13,30.1) v2(43.13,29.13) v2(43.44,101.96) v2(43.44,100.44) v2(43.44,98.94) v2(43.49,133.76) v2(43.79,30.15) v2(43.82,29.16) v2(44.18,72.57) v2(44.15,71.94) v2(44.15,71.3) v2(44.46,31.12) v2(44.46,30.16) v2(44.46,29.16) v2(44.81,65.79) v2(44.94,71.3) v2(45.14,52.35) v2(45.14,20.1) v2(45.17,54.21) v2(45.93,132.26) v2(46.47,54.41) v2(46.51,52.31) v2(46.52,51.65) v2(47.35,51.87) v2(47.35,25.46) v2(48.04,130.76) v2(49.26,27.62) v2(51.09,130.76) v2(53.63,131.02) v2(53.63,110.62) v2(53.65,118.5) v2(53.68,102.26) v2(54.97,96.22) v2(55.23,95.05) v2(55.3,97.39) v2(55.94,97.39) v2(55.86,95.05) v2(56.17,131.02) v2(56.35,71.1) v2(56.75,26.09) v2(56.98,71.1) v2(57.62,71.07) v2(57.56,33.57) v2(58.2,33.57) v2(58.3,22.81) v2(58.71,130.76) v2(58.83,33.57) v2(58.98,79.97) v2(58.98,79.33) v2(59.62,79.97) v2(59.62,79.33) v2(60.25,79.97) v2(60.25,79.33) v2(60.59,22.81) v2(61.25,130.76) v2(62.87,22.81) v2(63.79,130.76) v2(65.9,22.61) v2(66.15,120.45) v2(66.15,119.18) v2(66.15,117.91) v2(66.23,111.26) v2(66.23,110.5) v2(66.23,109.73) v2(66.23,108.97) v2(66.23,108.21) v2(66.23,107.45) v2(66.53,119.82) v2(66.53,118.55) v2(66.84,130.76) v2(66.91,120.45) v2(66.91,119.18) v2(66.91,117.91) v2(66.99,110.88) v2(66.99,110.11) v2(66.99,109.35) v2(66.99,108.59) v2(66.99,107.7) v2(67.12,122) v2(67.29,119.82) v2(67.29,118.55) v2(67.52,74.94) v2(67.57,120.42) v2(67.67,119.18) v2(67.67,117.91) v2(67.75,111.26) v2(67.75,110.5) v2(67.75,109.61) v2(67.75,108.84) v2(67.83,77.49) v2(67.78,76.83) v2(67.83,72.6) v2(67.83,71.96) v2(67.8,20.15) v2(67.85,73.3) v2(68.06,119.82) v2(68.06,118.55) v2(68.09,81.5) v2(68.42,79.97) v2(68.78,82.19) v2(69.38,130.76) v2(69.54,82.94) v2(70.28,30.28) v2(70.6,80.45) v2(70.57,20.12) v2(70.93,30.28) v2(71,135.54) v2(71,132.75) v2(71.23,28.15) v2(71.48,108.39) v2(71.58,30.28) v2(71.62,26.4) v2(72.24,30.28) v2(72.26,26.45) v2(72.55,86.29) v2(72.87,30.28) v2(72.89,26.44) v2(73.14,21.29) v2(73.2,86.29) v2(73.36,23.81) v2(73.51,30.28) v2(73.57,26.44) v2(73.77,136.63) v2(73.95,30.74) v2(74.22,132.77) v2(74.2,132.14) v2(74.25,26.45) v2(74.84,132.62) v2(74.89,131.93) v2(74.89,131.3) v2(74.96,105.64) v2(75.07,86.04) v2(75.55,86.92) v2(75.6,26.32) v2(75.57,25) v2(75.75,105.08) v2(76.26,26.29) v2(76.36,105.54) v2(76.92,26.29) v2(77.07,105.65) v2(77.07,105.01) v2(77.63,26.32) v2(77.83,29.42) v2(77.86,25) v2(78.37,26.4) v2(80.53,136.73) v2(80.77,86.6) v2(81.25,87.07) v2(81.75,87.57) v2(82.41,25) v2(82.81,136.73) v2(83.35,102.01) v2(83.98,35.24) v2(84.11,87.74) v2(84.69,25) v2(85.1,136.73) v2(86.01,135.51) v2(86.72,93.02) v2(86.83,93.86) v2(86.81,88.42) v2(86.77,84.89) v2(86.98,25) v2(87.38,136.73) v2(87.45,88.42) v2(87.4,85.01) v2(87.49,135.95) v2(87.46,93.86) v2(88.1,93.86) v2(88.08,88.42) v2(88.5,84.89) v2(88.73,93.86) v2(88.96,128.45) v2(89.26,25) v2(89.37,93.86) v2(89.67,136.73) v2(90.03,93.86) v2(90.03,89.29) v2(91.55,25) v2(91.74,33.95) v2(91.96,136.73) v2(92.29,118.6) v2(92.43,33.98) v2(92.69,32.9) v2(93.11,33.95) v2(93.84,25) v2(94.24,136.73) v2(94.37,118.6) v2(95.28,116.06) v2(95.59,33.58) v2(95.92,106.3) v2(96.12,25) v2(96.27,33.58) v2(96.43,118.62) v2(96.53,136.73) v2(96.58,133.84) v2(96.63,107.5) v2(96.55,106.3) v2(96.68,130.92) v2(97.14,34.35) v2(97.21,106.3) v2(97.54,116.11) v2(98.41,25) v2(98.48,118.62) v2(98.97,130.92) v2(100.26,116.01) v2(101.25,130.92) v2(101.94,24.92) v2(102.32,116.01) v2(103.36,90.48) v2(103.54,130.92) v2(104.38,116.01) v2(105.29,73.72) v2(105.44,118.78) v2(105.42,24.85) v2(105.83,130.92) v2(106.08,118.78) v2(106.51,116.13) v2(108.11,130.92) v2(108.39,104.02) v2(109.1,104.88) v2(109.84,86.8) v2(110.4,130.92) v2(110.45,120.65) v2(110.78,114.71) v2(111.26,106.58) v2(111.26,105.92) v2(111.29,105.29) v2(111.41,114.71) v2(112.02,119.31) v2(112.5,119.69) v2(112.66,130.92) v2(113.14,86.8) v2(113.19,119.69) v2(114.61,114.99) v2(114.94,130.92) v2(115.17,114.33) v2(115.3,114.97) v2(115.3,41.04) v2(115.48,40.44) v2(115.81,36) v2(115.81,28.12) v2(115.91,42.12) v2(116.44,36.25) v2(116.62,29.24) v2(117.08,36.25) v2(117.23,130.92) v2(117.2,29.52) v2(117.18,28.86) v2(117.18,28.21) v2(117.71,36.25) v2(117.75,27.91) v2(117.76,29.22) v2(117.76,28.58) v2(117.94,40.37) v2(118.44,51.3) v2(118.93,50.81) v2(118.96,20.07) v2(119.52,130.92) v2(120.56,113.57) v2(121.09,114.33) v2(121.73,114.33) v2(121.8,130.92) v2(122.41,124.24) v2(122.64,19.79) v2(122.84,105.72) v2(123.05,124.24) v2(123.12,114.33) v2(123.4,13.8) v2(123.4,10.75) v2(123.45,121.42) v2(123.49,105.56) v2(123.68,124.24) v2(123.86,114.33) v2(123.99,114.94) v2(124.09,130.92) v2(124.34,124.24) v2(124.98,124.24) v2(125.47,106.63) v2(125.51,90.66) v2(125.67,124.15) v2(125.84,104.6) v2(125.89,114.26) v2(126.12,115.55) v2(126.37,130.92) v2(126.91,106.02) v2(127.03,126.19) v2(127.29,117.28) v2(127.74,114.43) v2(128.02,126.19) v2(128.66,130.92) v2(128.66,126.19) v2(128.73,51.84) v2(128.95,120.43) v2(129.19,117.18) v2(129.36,51.82) v2(129.63,114.66) v2(130.05,120.43) v2(130.13,128.78) v2(130.92,130.92) v2(131.05,105.77) v2(131.43,128.83) v2(131.71,107.19) v2(132.72,5.75) v2(133.05,32.11) v2(133.21,130.92) v2(133.69,32.11) v2(133.84,128.99) v2(134.7,8.03) v2(135.49,130.92) v2(136.79,9.99) v2(137.04,25.76) v2(137.63,120.2) v2(137.6,113.04) v2(137.68,25.76) v2(137.78,130.92) v2(138.31,25.76) v2(138.97,25.76) v2(139.28,32.82) v2(139.28,32.19) v2(139.56,10.01) v2(139.73,77.24) v2(139.91,32.19) v2(140.06,130.92) v2(140.09,111.23) v2(140.22,26.42) v2(140.41,78.12) v2(140.55,111.69) v2(140.55,32.19) v2(140.88,26.42) v2(140.98,84.49) v2(141.31,92) v2(141.39,77.12) v2(141.77,82.07) v2(142.32,9.89) v2(142.35,130.92) v2(142.71,77.31) v2(143.29,69.25) v2(143.42,39.65) v2(143.75,7.47) v2(144.51,17.33) v2(144.61,130.92) v2(144.58,16.38) v2(145.14,23.04) v2(145.18,16.87) v2(145.4,5.42) v2(145.58,22.15) v2(145.68,16.39) v2(145.8,21.54) v2(146.26,86.82) v2(146.44,21.29) v2(146.9,130.92) v2(147.05,22.43) v2(147.09,21.6) v2(147.69,22.44) v2(147.71,21.61) v2(147.89,5.06) v2(148.31,22.42) v2(148.34,21.59) v2(148.94,22.5) v2(148.93,21.82) v2(148.95,130.79) v2(149.16,16.59) v2(149.82,16.59) v2(150.07,106.86) v2(150.2,106.1) v2(150.43,5.06) v2(150.63,105.24) v2(150.83,106.86) v2(150.83,106.1) v2(151.32,130.41) v2(151.62,101.28) v2(151.74,30.01) v2(151.71,29.38) v2(152.46,102.69) v2(152.92,31.22) v2(152.97,5.06) v2(153.16,102.7) v2(153.75,130.92) v2(153.8,102.7) v2(153.81,82.28) v2(153.83,81.51) v2(154.64,22.26) v2(154.9,23.22) v2(155.13,81.74) v2(155.07,27.26) v2(155.23,11.59) v2(155.28,22.25) v2(155.71,34.09) v2(155.69,27.28) v2(155.94,12.63) v2(155.86,11.59) v2(156.04,130.92) v2(155.96,22.22) v2(156.02,5.06) v2(156.22,31.68) v2(156.22,31.05) v2(156.37,34.09) v2(156.61,76.14) v2(156.83,119.81) v2(156.85,31.88) v2(156.91,31.24) v2(157.72,117.1) v2(158.33,130.92) v2(158.43,117.1) v2(158.43,21.46) v2(158.56,5.06) v2(158.81,22.03) v2(158.86,31.55) v2(159.06,115.7) v2(159.06,21.44) v2(159.16,114.41) v2(159.32,118.34) v2(159.68,129.46) v2(159.7,21.44) v2(159.8,116.06) v2(160.33,123.22) v2(160.61,130.92) v2(160.83,122.72) v2(161.1,5.06) v2(162.29,129.34) v2(162.85,109.2) v2(163.53,130.36) v2(163.64,58.76) v2(163.64,5.06) v2(163.76,80.19) v2(163.97,100.11) v2(164.27,108.16) v2(164.27,58.76) v2(164.5,129.51) v2(164.47,22.99) v2(164.47,22.33) v2(165.03,22.69) v2(165.06,80.22) v2(165.41,128.61) v2(166.07,32.19) v2(166.18,5.06) v2(166.25,121.57) v2(166.43,80.12) v2(166.71,32.16) v2(167.27,119.28) v2(168.18,35.64) v2(168.49,31.93) v2(168.56,71.51) v2(168.56,70.11) v2(168.94,35.64) v2(169.22,5.06) v2(169.73,28.05) v2(169.88,73.03) v2(169.91,71.56) v2(169.88,70.11) v2(170.26,27.69) v2(170.39,32.24) v2(170.8,28.02) v2(170.84,10.91) v2(171.1,73.03) v2(171.1,71.51) v2(171.1,70.11) v2(171.99,5.8) v2(172.93,113.72) v2(173.19,31.29) v2(173.19,30.66) v2(173.46,114.15) v2(173.77,115.45) v2(173.85,31.27) v2(173.85,30.63) v2(174.2,7.8) v2(174.48,31.27) v2(174.48,30.63) v2(174.57,28.48) v2(174.57,27.84) v2(175.5,99.9) v2(176.08,9.76) v2(176.82,115.45) v2(177.12,114.15) v2(177.76,114.15) v2(178.34,23.07) v2(178.39,22.08) v2(179.13,9.76) v2(179.33,23.09) v2(179.36,22.08) v2(179.87,115.45) v2(180.3,20.06) v2(182.18,9.76) v2(182.54,32.47) v2(182.54,31.84) v2(182.91,115.45) v2(182.94,20.26) v2(183.57,20.26) v2(184.18,20.09) v2(184.18,9.43) v2(184.47,22.06) v2(184.84,30.84) v2(184.76,20.38) v2(185.1,6.36) v2(185.53,21.27) v2(185.61,22.5) v2(185.71,116.87) v2(185.71,21.86) v2(185.81,23.7) v2(186.13,62.84) v2(186.06,30.99) v2(186.17,24.81) v2(186.33,23.15) v2(186.27,22.5) v2(186.36,21.87) v2(186.59,63.32) v2(186.8,64.32) v2(187.21,19.56) v2(187.28,40.21) v2(187.26,28.07) v2(187.31,27.23) v2(187.38,115.58) v2(187.71,31.27) v2(188.02,109.45) v2(187.97,108.23) v2(188.05,110.77) v2(188.68,5.06) v2(188.76,116.87) v2(189.29,115.58) v2(189.37,31.27) v2(189.52,108.23) v2(189.6,110.77) v2(189.57,109.45) v2(190.94,108.23) v2(191.02,110.77) v2(190.99,109.45) v2(191.37,32.11) v2(191.37,31.48) v2(191.36,25.4) v2(191.37,24.76) v2(191.35,20.12) v2(191.52,24.11) v2(191.51,22.79) v2(191.53,21.48) v2(191.73,73.89) v2(191.73,5.06) v2(191.8,116.87) v2(191.79,79.09) v2(191.91,41.56) v2(191.99,25.75) v2(192.17,32.18) v2(192.25,78.6) v2(192.63,25.76) v2(192.66,26.39) v2(192.77,115.6) v2(193.2,109.28) v2(193.29,26.41) v2(193.27,25.76) v2(193.4,78.54) v2(193.45,115.6) v2(193.65,28.78) v2(193.91,68) v2(193.91,67.11) v2(193.91,66.22) v2(194.22,115.58) v2(194.2,28.37) v2(194.27,5.06) v2(194.67,68) v2(194.67,67.11) v2(194.67,66.22) v2(194.8,109.84) v2(194.84,28.37) v2(195.11,105.92) v2(195.44,68) v2(195.44,67.11) v2(195.44,66.22) v2(195.44,62.03) v2(195.74,10.22) v2(195.99,109.89) v2(196.07,62.03) v2(196.53,35.56) v2(196.96,69.2) v2(197.11,27.03) v2(197.16,35.56) v2(197.32,5.06) v2(197.59,10.83) v2(198.08,78.67) v2(198.1,28.38) v2(199.22,42.36) v2(199.33,66.1) v2(199.37,67.8) v2(199.98,78.67) v2(200.36,5.06) v2(200.48,67.57) v2(201.53,10.88) v2(201.51,10.24) v2(201.66,9.2) v2(202.04,11.36) v2(202.07,116.87) v2(202.65,11.18) v2(203.41,5.06) v2(205.11,116.87) v2(205.09,17.79) v2(205.07,14.06) v2(205.08,12.01) v2(205.34,111.08) v2(205.34,109.78) v2(205.34,108.26) v2(205.27,86.85) v2(205.82,110.42) v2(205.82,109.12) v2(205.85,24.64) v2(206.69,4.55) v2(206.82,110.75) v2(206.76,25.25) v2(207.27,79.58) v2(207.42,111.57) v2(207.42,110.43) v2(207.42,109.26) v2(207.42,108.12) v2(207.53,15.4) v2(207.49,13.25) v2(207.46,10.86) v2(207.67,9.51) v2(207.81,91.24) v2(207.77,90.46) v2(207.93,86.97) v2(207.91,79.58) v2(208.01,100.74) v2(207.95,66.97) v2(208.16,116.87) v2(208.24,91.8) v2(208.31,87.71) v2(208.34,66.46) v2(208.54,85.57) v2(208.56,10.33) v2(208.73,16.82) v2(208.97,11.45) v2(209.2,73.97) v2(209.23,13.47) v2(209.19,8.69) v2(209.36,17.99) v2(210.78,4.5) v2(211.21,116.87) v2(212.33,24.82) v2(213.57,110.04) v2(213.98,81.62) v2(215.03,34.67) v2(215.38,12.12) v2(215.49,15.31) v2(216.37,112.86) v2(216.38,110.61) v2(216.51,111.6) v2(216.47,5.03) v2(216.74,48.93) v2(217.05,52) v2(217.2,91.19) v2(217.53,32.27) v2(217.58,49.08) v2(217.62,34.32) v2(218.19,12.6) v2(218.17,11.66) v2(218.45,30.04) v2(218.78,31.91) v2(218.86,47.94) v2(218.93,46.64) v2(218.93,13.42) v2(218.93,11.66) v2(219.03,92.54) v2(219.03,91.47) v2(219.01,66.02) v2(218.96,46) v2(218.96,45.34) v2(218.98,12.6) v2(219.01,5.03) v2(219.46,65.53) v2(219.64,113.59) v2(219.59,105.71) v2(219.67,13.42) v2(220.2,106.48) v2(220.22,105.7) v2(220.2,92.26) v2(220.4,28.63) v2(220.87,105.7) v2(221,104.87) v2(220.96,21.23) v2(221.39,106.26) v2(221.47,90.78) v2(221.47,89.74) v2(221.55,5.03) v2(221.57,89.12) v2(221.72,113.59) v2(222.31,60.61) v2(222.31,59.97) v2(222.49,76.74) v2(222.49,74.66) v2(222.49,73.72) v2(222.49,71.66) v2(222.51,70.69) v2(222.54,68.66) v2(222.54,67.7) v2(222.46,49.64) v2(222.56,65.65) v2(222.58,49.01) v2(222.69,18.39) v2(223.5,97.24) v2(223.83,113.9) v2(223.83,110.37) v2(224.14,97.24) v2(224.09,5.03) v2(224.21,92.89) v2(224.32,94.21) v2(224.32,93.58) v2(224.85,93.15) v2(224.9,7.55) v2(225.18,74.43) v2(225.15,73.79) v2(225.71,7.07) v2(225.84,6.38) v2(225.94,63.89) v2(225.94,63.25) v2(225.99,67.14) v2(225.99,66.48) v2(225.97,65.82) v2(226.12,65) v2(226.13,27.77) v2(226.35,7.12) v2(226.6,6.43) v2(226.68,100.77) v2(226.96,59.37) v2(226.98,7.32) v2(227.08,117.87) v2(227.14,5.03) v2(227.54,107.37) v2(227.77,24.9) v2(228.18,37.17) v2(228.43,107.04) v2(228.38,24.72) v2(228.56,60.1) v2(228.58,24.06) v2(228.68,90.99) v2(228.84,108.23) v2(229.32,4.97) v2(229.68,89.49) v2(229.8,61.75) v2(229.8,61.12) v2(229.9,59.19) v2(229.9,24.72) v2(229.98,40.16) v2(230.13,43.8) v2(230.23,109.15) v2(230.23,42.53) v2(230.18,8.51) v2(230.41,107.27) v2(230.87,41.97) v2(231.25,81.72) v2(231.45,77.58) v2(231.5,65.72) v2(231.45,6.66) v2(231.71,63.15) v2(231.94,80.17) v2(232.09,61.09) v2(232.27,7.17) v2(232.55,24.44) v2(232.6,82.86) v2(232.93,59.72) v2(232.98,43.36) v2(232.95,8.51) v2(233.1,83.39) v2(233.1,40.62) v2(234.96,60.69) v2(235.42,120.07) v2(235.39,24.44) v2(235.54,43.36) v2(235.57,62.85) v2(235.67,59.72) v2(235.67,40.62) v2(236.23,82.15) v2(236.23,80.37) v2(238.03,60.89) v2(238.34,23.12) v2(238.41,122.71) v2(238.36,121.04) v2(238.84,43.59) v2(238.9,40.54) v4(54.27,106.89) v4(55.03,106.89) v4(55.35,104.6) v4(55.48,103.87) v4(55.63,107.46) v4(55.7,105.39) v4(55.8,106.74) v4(56.07,106.04) v4(56.28,104.88) v4(56.26,104.11) v4(56.59,106.76) v4(56.82,107.47) v4(57.39,106.7) v4(57.61,107.52) v4(58.17,106.7) v4(58.28,110.83) v4(58.27,110.09) v4(58.25,108.15) v4(58.37,107.41) v4(58.99,107.8) v4(64.88,114.94) v4(65.03,115.73) v4(65.64,114.94) v4(65.77,115.73) v4(66.23,106.76) v4(66.4,114.94) v4(66.53,115.75) v4(66.99,106.76) v4(67.17,114.94) v4(67.29,115.75) v4(67.75,106.76) v4(67.93,115.02) v4(68.05,115.75) v4(68.82,115.75) v4(82.48,100.39) v4(82.81,101.3) v4(83.19,100.67) v4(83.68,101.22) v4(86.2,123.8) v4(86.9,124.34) v4(88.98,126.58) v4(89.74,126.58) v4(90.41,128.86) v4(90.41,128.1) v4(95.49,128.22) v4(95.49,127.46) v4(96.25,128.22) v4(96.25,127.46) v4(99.73,126.29) v4(100.19,128.45) v4(100.19,127.69) v4(100.19,126.93) v4(100.54,126.19) v4(100.95,128.45) v4(100.95,127.69) v4(100.95,126.93) v4(101.3,126.24) v4(101.3,125.48) v4(105.06,125.23) v4(105.8,125.25) v4(106.33,125.94) v4(106.38,127.59) v4(106.36,126.73) v4(106.54,125.2) v4(107.09,125.76) v4(107.2,127.39) v4(107.2,126.62) v4(132.8,128.1) v4(133.54,128.05) v4(133.54,127.31) v4(134.2,126.52) v4(134.3,128) v4(134.3,127.26) v4(135.14,128.3) v4(135.8,121.87) v4(135.92,128.3) v4(136.52,121.87) v4(137.24,121.87) v4(137.97,121.87) v4(138.69,121.87) v4(139.42,121.87) v4(140.15,121.87)
