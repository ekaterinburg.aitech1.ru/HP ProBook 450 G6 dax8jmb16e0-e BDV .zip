# Allegro board dax8jmb16e0-e-www.DeviceDB.xyz_.brd (continued)
## Nets (continued)
GND: C400.2 C401.2 C402.2 C403.1 C404.1 C405.1 C420.1 C421.2 C422.2 C423.1 C424.2 C425.2 C426.2 C427.2 C428.2 C429.2 C430.2 C431.1 C432.1 C433.1 C434.1 C435.1 C436.1 C437.1 C438.1 C439.1 C440.1 C441.2 C442.1 C443.1 C444.1 C445.1 C446.1 C447.1 C448.1 C449.1 C450.1 C451.2 C452.1 C453.1 C454.1 C455.1 C456.1 C457.1 C458.1 C459.1 C460.1 C461.1 C462.1 C463.1 C464.1 C465.1 C466.1 C467.1 C468.1 C469.1 C470.1 C471.2 C472.2 C473.2 C474.2 C475.2 C476.2 C477.2 C478.2 C481.2 C482.1 C483.2 C485.2 C486.2 C490.1 C491.1 C492.1 C493.1 C494.2 C495.2 C496.2 C497.2 C508.1 C509.1 C510.1 C518.1 C519.1 C520.1 C521.1 C522.1 C523.1 C524.1 C525.2 C526.2 C527.2 C528.2 C529.2 C530.2 C531.2 C532.2 C533.2 C534.2 C535.2 C536.2 C537.2 C538.1 C539.1 C540.1 C541.1 C546.1 C547.2 C548.2 C549.1 C550.1 C551.2 C552.2 C553.2 C554.1 C555.2 C556.2 C557.1 C558.2 C559.1 C560.2 C561.2 C562.2 C563.2 C564.1 C565.1 C566.1 C567.1 C568.1 C569.1 C570.1 C571.1 C572.1 C573.1 C574.1 C575.1 C576.1 C577.1 C578.1 C579.1 C580.1 C581.1 C582.1 C583.1 C584.1 C585.1 C586.1 C587.1 C588.1 C589.1 C590.1 C591.1 C592.1 C593.1 C594.1 C595.1 C596.1 C597.1 C598.1 C599.1 C600.1 C601.1 C602.1 C603.1 C604.1 C605.1 C606.1 C607.1 C608.1 C609.1 C610.1 C611.1 C612.1 C613.1 C614.1 C615.1 C616.1 C617.1 C618.1 C619.1 C620.1 C621.1 C622.1 C623.1 C624.1 C625.1 C626.1 C627.1 C628.1 C629.1 C630.1 C631.2 C632.1 C633.1 C634.1 C635.1 C636.1 C637.1 C638.2 C639.1 C640.1 C641.1 C2800.1 C2801.2 C2802.2 C2803.2 C2804.2 C2805.2 C2806.2 C2807.2 C2808.2 C2809.2 C2810.2 C2811.2 C2812.2 C2813.2 C2814.2 C2815.2 C2816.2 C2817.2 C2818.2 C2819.2 C2820.2 C2821.2 C2822.2 C2823.2 C2824.2 C2825.2 C2826.2 C2827.2 C2829.1 C2830.2 C2831.2 C2832.2 C2833.2 C2834.2 C2835.2 C2836.2 C2837.2 C2838.2 C2839.2 C2840.2 C2841.2 C2842.2 C2843.2 C2844.2 C2845.2 C2846.2 C2847.2 C2848.2 C2849.2 C2850.2 C2851.2 C2852.2 C2853.2 C2854.2 C2855.2 C2856.2 C3300.1 C3301.2 C3401.1 C3402.2 C3403.2 C3404.2 C3405.2 C3406.2 C3407.2 C3408.2 C3409.1 C3410.1 C3411.2 C3412.2 C3413.2 C3420.2 C3421.2 C3422.2 C3423.2 C3424.1 C3500.2 C3501.2 C3502.2 C3503.2 C3504.2 C3505.2 C3506.2 C3507.2 C3508.2 C3517.2 C3518.2 C3519.2 C3520.2 C3608.1 C3609.2 C3611.2 C3613.1 C3617.1 C3619.1 C3622.1 C3623.1 C3624.1 C3625.2 C3626.1 C3627.2 C3630.1 C3631.2 C3632.1 C3633.2 C3635.1 C3636.1 C3637.1 C3638.1 C3639.1 C4000.1 C4001.1 C4004.2 C4005.2 C4006.2 C4007.2 C4008.2 C4009.2 C4010.2 C4011.2 C4012.2 C4013.1 C4014.1 C4015.2 C4016.2 C4017.2 C4018.2 C4019.2 C4020.2 C4021.2 C4022.2 C4023.2 C4024.1 C4035.2 C4036.2 C4037.2 C4100.2 C4101.2 C4102.1 C4104.2 C4105.2 C4106.1 C4107.2 C4108.1 C4109.1 C4200.2 C4201.2 C4202.1 C4203.2 C4204.1 C4205.2 C4207.1 C4208.2 C4209.2 C4210.2 C4211.1 C4222.2 C4236.1 C4237.1 C4238.2 C4302.1 C4303.1 C4304.1 C4305.1 C4312.1 C4313.1 C4318.1 C4400.2 C4401.2 C4402.2 C4403.2 C4700.2 C4701.2 C4702.2 C4703.2 C4704.1 C4705.2 C4706.1 C4708.1 C4712.2 C4713.1 C4714.1 C4715.1 C4716.1 C4717.2 C4720.2 C4721.2 C4722.1 C4723.1 C4724.1 C4725.1 C4728.1 C4729.2 C5000.2 C5001.1 C5003.1 C5004.1 C5005.1 C5006.1 C5007.1 C5008.1 C5009.1 C5010.1 C5011.1 C5012.1 C5013.1 C5014.1 C5015.1 C5016.1 C5017.1 C5018.1 C5019.1 C5020.1 C5021.1 C5022.1 C5023.1 C5024.1 C5025.1 C5100.1 C5101.1 C5102.1 C5103.1 C5104.2 C5205.2 C5206.2 C5207.3 C5208.3 C5300.2 C5301.2 C5302.2 C5303.2 C5304.1 C5305.2 C5400.2 C5401.1 C5402.2 C5403.2 C5404.2 C5405.2 C5600.2 C5601.1 C5700.2 C5701.2 C5702.1 C5705.3 C5706.2 C5707.2 C5708.2 C5709.2 C5710.1 C5713.3 C5810.1 C5811.2 C5812.1 C5821.2 C5822.1 C5823.2 C5824.1 C5825.1 C5826.2 C6100.1 C6101.1 C6102.2 C6103.2 C6104.1 C6105.1 C6106.1 C6107.1 C6108.2 C6202.2 C6203.2 C6204.2 C6205.2 C6206.2 C6300.2 C6301.2 C6302.1 C6303.1 C6304.2 C6305.2 C7500.2 C7600.1 C7601.2 C7602.2 C7603.1 C7604.2 C7605.2 C7606.2 C7607.2 C7608.2 C7609.1 C7610.2 C7611.2 C7612.2 C7613.2 C7614.1 C7615.2 C7616.2 C7617.2 C7618.1 C7619.2 C7620.2 C7621.2 C7622.1 C7623.1 C7624.1 C7625.1 C7626.1 C7627.2 C7628.2 C7629.2 C7700.1 C7701.1 C7702.1 C7800.1 C7801.1 C7802.1 C7803.1 C7804.1 C7805.1 C7806.1 C7807.1 C7808.1 C7809.1 C7810.1 C7811.1 C7812.1 C7813.1 C7814.1 C7815.1 C7816.1 C7817.1 C7818.1 C7819.1 C7820.1 C7821.1 C7822.1 C7823.1 C7824.1 C7825.1 C7826.1 C7827.1 C7828.1 C7829.1 C7830.1 C7831.1 C7832.1 C7833.1 C7834.1 C7835.1 C7836.1 C7837.1 C7838.1 C7839.1 C7840.1 C7841.1 C7842.1 C7843.1 C7844.1 C7845.1 C7846.1 C7847.1 C7848.1 C7849.1 C7850.1 C7851.1 C7852.1 C7853.1 C7854.1 C7855.1 C7856.1 C7857.1 C7858.1 C7859.1 C7860.1 C7861.1 C7862.1 C7863.1 C7864.1 C7865.1 C7866.1 C7867.1 C7868.1 C7869.1 C7870.1 C7871.1 C7872.1 C7873.1 C7874.1 CN3400.12 CN3400.15 CN3400.18 CN3400.31 CN3400.34 CN3400.37 CN3400.41 CN3400.42 CN3500.2(GND_1) CN3500.5(GND_2) CN3500.8(GND_3) CN3500.11(GND_4) CN3500.17(GND_DPAUX) CN3500.20(X_DP(PWR)) CN3500.21(HD_DP_OPTION) CN3500.22(SHELL2) CN3500.23(SHELL1) CN3600.5(6) CN3600.6(5) CN4100.1(GND_3) CN4100.7(GND_4) CN4100.13(SDIO DAT0(IO)) CN4100.18(GND_13) CN4100.19(SDIO DAT3(IO)) CN4100.33(GND_5) CN4100.39(GND_6) CN4100.45(GND_7) CN4100.51(GND_8) CN4100.57(GND_9) CN4100.63(GND_10) CN4100.69(GND_11) CN4100.75(GND_12) CN4100.76(GND_1) CN4100.77(GND_2) CN4200.3(GND#1) CN4200.5(GND#2) CN4200.11(GND#3) CN4200.27(GND#4) CN4200.33(GND#5) CN4200.39(GND#6) CN4200.45(GND#7) CN4200.51(GND#8) CN4200.57(GND#9) CN4200.71(GND#10) CN4200.73(GND#11) CN4200.76 CN4200.77 CN4201.5(GND) CN4201.10(SHIELD_1) CN4201.11(SHIELD_2) CN4300.1(GND_1) CN4300.3(GND_3) CN4300.9(GND_9) CN4300.15(GND_15) CN4300.21(GND_21) CN4300.27(GND_27) CN4300.33(GND_33) CN4300.39(GND_39) CN4300.45(GND_45) CN4300.51(GND_51) CN4300.57(GND_57) CN4300.71(GND_71) CN4300.73(GND_73) CN4300.76(GND_76) CN4300.77(GND_77) CN4400.4 CN4400.7 CN4400.10 CN5000.43(G1) CN5000.44(G2) CN5001.1 CN5001.2 CN5001.9 CN5001.10 CN5201.5 CN5201.9 CN5201.10 CN5400.1 CN5400.5 CN5400.6 CN5700.4 CN5700.7 CN5700.10 CN5700.11 CN5700.12 CN5700.13 CN5701.4 CN5701.7 CN5701.10 CN5701.11 CN5701.12 CN5701.13 CN6200.4 CN6200.11 CN6200.12 CN6300.1(GND_5) CN6300.2(GND_6) CN6300.3(GND_7) CN6300.4(GND_8) CN6300.5(GND_9) CN6300.6(GND_10) CN6300.7(GND_11) CN6300.8(GND_12) CN6300.9(GND_13) CN6300.10(GND_14) CN6300.A1(GND_1) CN6300.A12(GND_2) CN6300.B1(GND_3) CN6300.B12(GND_4) CN7600.9 CN7600.10 CN7600.11 CN7600.12 CN7600.15 CN7600.21 CN7600.22 CN7601.7 CN7601.9 CN7601.11 CN7601.13 CN7601.15 CN7601.17 CN7601.19 CN7601.23 CN7601.24 CN7602.3 CN7602.10 CN7602.13 CN7602.14 CN7603.3 CN7603.8 CN7700.2(GND1) CN7700.7(GND2) CN7700.8(GND3) CN7700.13(GND4) CN7700.14(GND5) CN7700.19(GND6) CN7700.20(GND7) CN7700.25(GND8) CN7700.26(GND9) CN7700.31(GND10) CN7700.32(GND11) CN7700.37(GND12) CN7700.38(GND13) CN7700.49(GND14) CN7700.50(GND15) CN7700.59(GND16) CN7701.28 CN7701.31 CN7701.32 CN7702.6 CN7702.9 CN7702.10 D3600.2 D3601.1 D3603.2 D3605.2 D6300.2 D6301.2 D6302.2 D6303.2 D6304.2 EC2800.2 EC2801.2 EC2802.2 EC2803.2 EC2804.2 EC2805.2 EC2806.2 EC2807.1 EC2808.1 EC2809.2 EC2810.1 EC2811.2 EC2812.2 EC2813.1 EC2814.2 EC2815.2 EC2816.2 EC2817.2 EC2818.2 EC2819.2 EC2820.2 EC2821.2 EC2822.2 EC2823.2 EC3400.1 EC3600.2 EC3601.2 EC3602.2 EC3603.2 EC3605.2 EC3606.2 EC3607.2 EC3608.2 EC3609.1 EC3610.2 EC3611.1 EC3612.1 EC3613.2 EC4300.1 EC9700.2 EC9701.2 EC9702.2 EC9703.2 EC9704.2 H7900.1(GND) H7901.1(GND) H7902.1(GND) H7903.1(GND) H7904.1(GND) H7905.1(GND) H7906.1(GND) H7908.1(GND) H7909.1(GND) H7910.1(GND) H7911.1(GND) H7912.1(GND) H7913.1(GND) H7914.1(GND) H7916.1(GND) H7917.1(GND) H7918.1(GND) H7919.1(GND) H7920.1(GND) H7921.1(GND) H7923.1(GND) H7924.1(GND) H7925.1(GND) H7928.1(GND) JDIM2800.1(VSS1) JDIM2800.2(VSS48) JDIM2800.5(VSS2) JDIM2800.6(VSS49) JDIM2800.9(VSS3) JDIM2800.10(VSS50) JDIM2800.14(VSS51) JDIM2800.15(VSS4) JDIM2800.18(VSS52) JDIM2800.19(VSS5) JDIM2800.22(VSS53) JDIM2800.23(VSS6) JDIM2800.26(VSS54) JDIM2800.27(VSS7) JDIM2800.30(VSS55) JDIM2800.31(VSS8) JDIM2800.35(VSS9) JDIM2800.36(VSS56) JDIM2800.39(VSS10) JDIM2800.40(VSS57) JDIM2800.43(VSS11) JDIM2800.44(VSS58) JDIM2800.47(VSS12) JDIM2800.48(VSS59) JDIM2800.51(VSS13) JDIM2800.52(VSS60) JDIM2800.56(VSS61) JDIM2800.57(VSS14) JDIM2800.60(VSS62) JDIM2800.61(VSS15) JDIM2800.64(VSS63) JDIM2800.65(VSS16) JDIM2800.68(VSS64) JDIM2800.69(VSS17) JDIM2800.72(VSS65) JDIM2800.73(VSS18) JDIM2800.77(VSS19) JDIM2800.78(VSS66) JDIM2800.81(VSS20) JDIM2800.82(VSS67) JDIM2800.85(VSS21) JDIM2800.86(VSS68) JDIM2800.89(VSS22) JDIM2800.90(VSS69) JDIM2800.93(VSS23) JDIM2800.94(VSS70) JDIM2800.98(VSS71) JDIM2800.99(VSS24) JDIM2800.102(VSS72) JDIM2800.103(VSS25) JDIM2800.106(VSS73) JDIM2800.107(VSS26) JDIM2800.167(VSS27) JDIM2800.168(VSS74) JDIM2800.171(VSS28) JDIM2800.172(VSS75) JDIM2800.175(VSS29) JDIM2800.176(VSS76) JDIM2800.180(VSS77) JDIM2800.181(VSS30) JDIM2800.184(VSS78) JDIM2800.185(VSS31) JDIM2800.188(VSS79) JDIM2800.189(VSS32) JDIM2800.192(VSS80) JDIM2800.193(VSS33) JDIM2800.196(VSS81) JDIM2800.197(VSS34) JDIM2800.201(VSS35) JDIM2800.202(VSS82) JDIM2800.205(VSS36) JDIM2800.206(VSS83) JDIM2800.209(VSS37) JDIM2800.210(VSS84) JDIM2800.213(VSS38) JDIM2800.214(VSS85) JDIM2800.217(VSS39) JDIM2800.218(VSS86) JDIM2800.222(VSS87) JDIM2800.223(VSS40) JDIM2800.226(VSS88) JDIM2800.227(VSS41) JDIM2800.230(VSS89) JDIM2800.231(VSS42) JDIM2800.234(VSS90) JDIM2800.235(VSS43) JDIM2800.238(VSS91) JDIM2800.239(VSS44) JDIM2800.243(VSS45) JDIM2800.244(VSS92) JDIM2800.247(VSS46) JDIM2800.248(VSS93) JDIM2800.251(VSS47) JDIM2800.252(VSS94) JDIM2800.261(GND#1) JDIM2800.262(GND#2) JDIM2801.1(VSS1) JDIM2801.2(VSS48) JDIM2801.5(VSS2) JDIM2801.6(VSS49) JDIM2801.9(VSS3) JDIM2801.10(VSS50) JDIM2801.14(VSS51) JDIM2801.15(VSS4) JDIM2801.18(VSS52) JDIM2801.19(VSS5) JDIM2801.22(VSS53) JDIM2801.23(VSS6) JDIM2801.26(VSS54) JDIM2801.27(VSS7) JDIM2801.30(VSS55) JDIM2801.31(VSS8) JDIM2801.35(VSS9) JDIM2801.36(VSS56) JDIM2801.39(VSS10) JDIM2801.40(VSS57) JDIM2801.43(VSS11) JDIM2801.44(VSS58) JDIM2801.47(VSS12) JDIM2801.48(VSS59) JDIM2801.51(VSS13) JDIM2801.52(VSS60) JDIM2801.56(VSS61) JDIM2801.57(VSS14) JDIM2801.60(VSS62) JDIM2801.61(VSS15) JDIM2801.64(VSS63) JDIM2801.65(VSS16) JDIM2801.68(VSS64) JDIM2801.69(VSS17) JDIM2801.72(VSS65) JDIM2801.73(VSS18) JDIM2801.77(VSS19) JDIM2801.78(VSS66) JDIM2801.81(VSS20) JDIM2801.82(VSS67) JDIM2801.85(VSS21) JDIM2801.86(VSS68) JDIM2801.89(VSS22) JDIM2801.90(VSS69) JDIM2801.93(VSS23) JDIM2801.94(VSS70) JDIM2801.98(VSS71) JDIM2801.99(VSS24) JDIM2801.102(VSS72) JDIM2801.103(VSS25) JDIM2801.106(VSS73) JDIM2801.107(VSS26) JDIM2801.167(VSS27) JDIM2801.168(VSS74) JDIM2801.171(VSS28) JDIM2801.172(VSS75) JDIM2801.175(VSS29) JDIM2801.176(VSS76) JDIM2801.180(VSS77) JDIM2801.181(VSS30) JDIM2801.184(VSS78) JDIM2801.185(VSS31) JDIM2801.188(VSS79) JDIM2801.189(VSS32) JDIM2801.192(VSS80) JDIM2801.193(VSS33) JDIM2801.196(VSS81) JDIM2801.197(VSS34) JDIM2801.201(VSS35) JDIM2801.202(VSS82) JDIM2801.205(VSS36) JDIM2801.206(VSS83) JDIM2801.209(VSS37) JDIM2801.210(VSS84) JDIM2801.213(VSS38) JDIM2801.214(VSS85) JDIM2801.217(VSS39) JDIM2801.218(VSS86) JDIM2801.222(VSS87) JDIM2801.223(VSS40) JDIM2801.226(VSS88) JDIM2801.227(VSS41) JDIM2801.230(VSS89) JDIM2801.231(VSS42) JDIM2801.234(VSS90) JDIM2801.235(VSS43) JDIM2801.238(VSS91) JDIM2801.239(VSS44) JDIM2801.243(VSS45) JDIM2801.244(VSS92) JDIM2801.247(VSS46) JDIM2801.248(VSS93) JDIM2801.251(VSS47) JDIM2801.252(VSS94) JDIM2801.261(GND#1) JDIM2801.262(GND#2) PC8000.2 PC8001.2 PC8100.2 PC8101.1 PC8102.1 PC8103.1 PC8104.1 PC8105.2 PC8201.1 PC8203.1 PC8205.2 PC8206.2 PC8207.2 PC8208.2 PC8209.1 PC8210.2 PC8211.2 PC8213.2 PC8214.2 PC8215.2 PC8216.2 PC8217.2 PC8219.2 PC8220.2 PC8221.2 PC8222.1 PC8223.2 PC8224.1 PC8225.2 PC8226.2 PC8227.2 PC8228.2 PC8500.1 PC8501.1 PC8502.1 PC8503.1 PC8504.2 PC8505.2 PC8506.1 PC8507.1 PC8508.1 PC8509.1 PC8600.1 PC8601.1 PC8602.1 PC8603.1 PC8604.1 PC8605.1 PC8606.1 PC8607.2 PC8609.2 PC8610.2 PC8611.2 PC8612.2 PC8613.2 PC8614.2 PC8615.2 PC8616.2 PC8617.2 PC8621.1 PC8622.1 PC8623.1 PC8624.1 PC8625.1 PC8626.1 PC8627.1 PC8628.2 PC8630.2 PC8631.2 PC8632.2 PC8633.2 PC8634.2 PC8635.2 PC8636.1 PC8637.2 PC8638.2 PC8639.1 PC8642.2 PC8700.2 PC8701.1 PC8702.1 PC8703.2 PC8704.2 PC8705.2 PC8706.2 PC8707.2 PC8708.2 PC8709.2 PC8710.2 PC8712.2 PC8713.2 PC8714.2 PC8715.1 PC8716.2 PC8717.2 PC8718.2 PC8719.2 PC8720.2 PC8721.2 PC8722.1 PC8723.2 PC8724.2 PC8725.1 PC8726.2 PC8727.2 PC8800.2 PC8801.2 PC8802.2 PC8803.1 PC8804.1 PC8805.2 PC8806.2 PC8807.2 PC8808.2 PC8809.2 PC8810.2 PC8811.2 PC8812.2 PC8813.1 PC8814.1 PC8900.1 PC8901.2 PC8902.2 PC8903.2 PC8904.2 PC8905.2 PC8906.2 PC8907.2 PC8908.1 PC8910.2 PC8911.2 PC8913.1 PC8914.1 PC8915.2 PC8916.2 PC8917.2 PC8918.2 PC8919.2 PC8920.2 PC8921.1 PC8923.2 PC8924.2 PC8926.1 PC8927.2 PC8928.2 PC9000.2 PC9001.2 PC9002.1 PC9003.1 PC9004.2 PC9005.2 PC9006.2 PC9007.2 PC9009.2 PC9010.2 PC9015.2 PC9017.1 PC9018.1 PC9019.2 PC9020.2 PC9021.2 PC9022.2 PC9023.2 PC9025.1 PC9027.2 PC9028.2 PC9029.2 PC9030.2 PC9031.2 PC9032.2 PC9034.1 PC9035.2 PC9036.2 PC9200.2 PC9201.2 PC9202.2 PC9203.2 PC9204.2 PC9206.1 PC9207.1 PC9208.1 PC9210.1 PC9211.1 PC9212.1 PC9213.2 PC9214.1 PC9216.2 PC9217.2 PC9218.2 PC9219.2 PC9220.2 PC9221.2 PC9222.2 PC9223.1 PC9224.1 PC9300.1 PC9302.2 PC9303.2 PC9304.2 PC9305.2 PC9306.1 PC9307.2 PC9308.2 PC9310.2 PC9311.2 PC9312.2 PC9313.2 PC9314.1 PC9315.2 PC9316.2 PC9500.2 PC9501.2 PC9502.2 PC9503.2 PC9504.2 PC9505.2 PC9506.2 PC9507.2 PC9508.2 PC9509.2 PC9510.2 PC9511.2 PC9512.2 PC9513.2 PC9514.2 PC9515.2 PC9516.2 PC9517.2 PC9518.2 PC9519.2 PC9520.2 PC9521.2 PC9522.2 PC9523.2 PC9524.2 PC9525.2 PC9526.2 PC9527.2 PC9528.2 PC9529.2 PC9530.2 PC9531.2 PC9532.2 PC9533.2 PC9534.2 PC9535.2 PC9600.2 PC9601.2 PC9602.2 PC9603.2 PC9604.2 PC9605.2 PC9606.2 PC9607.2 PC9608.2 PCN8000.3(GND#1) PCN8000.4(GND#2) PCN8000.9(GND#3) PCN8000.10(GND#4) PCN8500.1(GND#1) PCN8500.2(GND#2) PCN8500.9(GND#3) PCN8500.10(GND#4) PD8000.2 PD8200.2 PD8203.2 PD8205.2(ANODE) PD8500.2 PD8501.2 PQ8005.1(S) PQ8005.4(S) PQ8100.1(S) PQ8100.4(S) PQ8204.1(S1) PQ8204.2(S2) PQ8204.3(S3) PQ8206.1(S) PQ8500.3(COLLECTOR) PQ8502.1(S) PQ8503.1(S) PQ8701.1(S1) PQ8701.2(S2) PQ8701.3(S3) PQ8702.1(S) PQ8703.1(S) PQ8703.4(S) PQ8900.10(S2) PQ8901.10(S2) PQ9000.5(S2#1) PQ9000.6(S2#2) PQ9000.7(S2#3) PQ9002.1 PQ9002.2 PQ9002.3 PQ9601.1(S) PQ9601.4(S) PQ9603.1(S) PQ9603.4(S) PQ9605.1(S) PQ9605.4(S) PR8009.2 PR8010.1 PR8012.2 PR8013.1 PR8016.2 PR8017.2 PR8018.1 PR8019.2 PR8021.2 PR8022.2 PR8023.1 PR8024.1 PR8025.2 PR8026.2 PR8109.1 PR8115.2 PR8116.2 PR8129.2 PR8203.1 PR8204.2 PR8207.2 PR8208.2 PR8215.2 PR8224.1 PR8237.2 PR8244.2 PR8247.1 PR8507.2 PR8508.2 PR8509.1 PR8513.1 PR8514.1 PR8518.1 PR8604.2 PR8609.2 PR8616.2 PR8625.2 PR8702.1 PR8709.2 PR8714.2 PR8724.1 PR8808.1 PR8830.2 PR8831.1 PR8833.2 PR8841.2 PR8845.2 PR8850.1 PR8851.2 PR8855.2 PR8856.2 PR8857.2 PR8859.1 PR8861.1 PR8862.2 PR8863.1 PR8864.1 PR8866.2 PR9205.2 PR9208.2 PR9210.2 PR9302.1 PR9304.2 PR9310.2 PR9311.1 PR9313.1 PR9603.2 PR9607.2 PR9616.2 PU8100.4(GND) PU8102.3(GND) PU8200.22(GND#1) PU8200.29(GND#2) PU8200.30(GND#3) PU8200.31(GND#4) PU8200.32(GND#5) PU8200.33(GND#6) PU8200.34(GND#7) PU8200.35(GND#8) PU8200.36(GND#9) PU8200.37(GND#10) PU8200.38(GND#11) PU8201.2(GND) PU8600.7(GND#1) PU8600.8(GND#2) PU8600.18(GND#3) PU8600.21(GND#4) PU8601.3(GND1) PU8601.11(GND2) PU8700.1(VTTGND) PU8700.14(PGND) PU8700.21(PAD) PU8701.2(GND) PU8800.45(AGND) PU8900.10(GND) PU8900.13(EPAD) PU8901.10(GND) PU8901.13(EPAD) PU9000.10(GND) PU9000.13(EPAD) PU9001.10(GND) PU9001.13(EPAD) PU9200.4(AGND) PU9200.12(PGND#1) PU9200.13(PGND#2) PU9200.14(PGND#3) PU9200.15(PGND#4) PU9200.19(PGND#5) PU9201.5(GND) PU9202.3(GND) PU9300.2(PGND) PU9500.11(GND#1) PU9500.15(GND#2) PU9501.11(GND#1) PU9501.15(GND#2) PU9502.11(GND#1) PU9502.15(GND#2) PU9600.3(GND) PU9601.3(GND) PU9602.3(GND) Q402.1(S) Q402.4(S) Q403.1(S) Q404.1(EMITTER) Q3400.1(S) Q3401.1(S) Q4102.1(S) Q4102.4(S) Q4103.1(EMITTER) Q4105.1(EMITTER) Q4109.4(S) Q4110.1 Q4202.4(S) Q4300.1(S) Q5000.1(S) Q5001.1(S) Q5003.1(S) Q5004.1(S) Q5005.1(S) Q5100.1(S) Q5100.4(S) Q5300.1(S) Q5301.1(S) Q5400.1(S) Q6301.1(S) Q7600.1(S) Q7600.4(S) Q7601.1(S) Q7601.4(S) Q7702.1(S) R401.1 R411.2 R412.1 R445.2 R446.2 R451.2 R457.1 R464.1 R467.1 R491.2 R501.2 R505.2 R507.2 R509.1 R511.1 R513.2 R514.1 R516.2 R518.2 R522.2 R534.2 R539.2 R540.2 R542.2 R545.2 R546.2 R547.2 R550.2 R552.2 R559.2 R561.1 R563.2 R564.1 R566.2 R575.2 R576.2 R577.2 R588.1 R603.2 R605.1 R610.2 R627.2 R629.1 R632.1 R633.1 R634.1 R635.1 R637.1 R638.1 R639.1 R640.1 R641.1 R642.1 R643.1 R644.1 R645.1 R646.1 R647.1 R649.2 R651.2 R652.2 R654.1 R2817.1 R2818.1 R2819.1 R2820.1 R2821.1 R2826.2 R2827.2 R2828.2 R2840.1 R2842.2 R3404.1 R3410.1 R3413.1 R3428.1 R3505.2 R3508.2 R3509.1 R3617.2 R3618.2 R4000.1 R4004.1 R4012.1 R4013.1 R4111.2 R4138.1 R4147.2 R4235.1 R4240.1 R4246.1 R4307.1 R4716.1 R4730.1 R4746.1 R4747.2 R4748.2 R4749.1 R4750.2 R4751.1 R4763.2 R4768.1 R5009.2 R5010.2 R5015.1 R5107.2 R5207.2 R5301.1 R5305.2 R5406.2 R5605.2 R5800.1 R5805.2 R5811.1 R6104.2 R6105.2 R6107.2 R6113.2 R6300.1 R6301.1 R6320.2 R6322.2 R6324.2 R6325.2 R6326.2 R6327.2 R6328.2 R6329.2 R6330.2 R6331.2 R6332.2 R6832.2 R7600.1 R7618.2 R7621.2 R7722.1 R7729.1 R7735.1 R9649.2 TP6101.1 U400.A3(VSS_32) U400.A4(VSS_13) U400.A32(VSS_30) U400.A36(VSS_35) U400.AB3(VSS_41) U400.AB4(VSS_52) U400.AB7(VSS_55) U400.AB27(VSS_38) U400.AB30(VSS_43) U400.AB33(VSS_46) U400.AB36(VSS_49) U400.AC5(VSS_431) U400.AC10(VSS_58) U400.AC27(VSS_61) U400.AC30(VSS_64) U400.AD33(VSS_69) U400.AD35(VSS_72) U400.AE7(VSS_83) U400.AE24(VSS_14) U400.AE25(VSS_74) U400.AE26(VSS_15) U400.AE27(VSS_77) U400.AE30(VSS_80) U400.AF3(VSS_89) U400.AF4(VSS_97) U400.AF7(VSS_99) U400.AF25(VSS_16) U400.AF27(VSS_86) U400.AF30(VSS_92) U400.AF33(VSS_94) U400.AF36(VSS_96) U400.AG5(VSS_432) U400.AG10(VSS_102) U400.AG24(VSS_17) U400.AG26(VSS_18) U400.AH24(VSS_19) U400.AH25(VSS_20) U400.AH27(VSS_107) U400.AH28(VSS_110) U400.AH29(VSS_113) U400.AH30(VSS_116) U400.AH31(VSS_118) U400.AH33(VSS_121) U400.AH35(VSS_123) U400.AJ7(VSS_130) U400.AJ25(VSS_125) U400.AJ28(VSS_127) U400.AK3(VSS_132) U400.AK4(VSS_139) U400.AK33(VSS_134) U400.AK36(VSS_136) U400.AL7(VSS_150) U400.AL28(VSS_141) U400.AL29(VSS_144) U400.AL32(VSS_147) U400.AM5(VSS_429) U400.AM10(VSS_152) U400.AM28(VSS_155) U400.AM33(VSS_157) U400.AM35(VSS_160) U400.AN7(VSS_178) U400.AN8(VSS_181) U400.AN25(VSS_165) U400.AN28(VSS_168) U400.AN29(VSS_171) U400.AN30(VSS_173) U400.AN31(VSS_175) U400.AP3(VSS_186) U400.AP4(VSS_194) U400.AP33(VSS_189) U400.AP36(VSS_192) U400.AR4(VSS_417) U400.AR28(VSS_196) U400.AT4(VSS_207) U400.AT33(VSS_199) U400.AT35(VSS_202) U400.AT36(VSS_204) U400.AU4(VSS_418) U400.AU10(VSS_209) U400.AU28(VSS_212) U400.AU29(VSS_215) U400.AU32(VSS_219) U400.AV3(VSS_228) U400.AV4(VSS_236) U400.AV6(VSS_239) U400.AV8(VSS_242) U400.AV25(VSS_222) U400.AV28(VSS_225) U400.AV33(VSS_231) U400.AV36(VSS_233) U400.AW1(VSS_7) U400.AW3(VSS_251) U400.AW4(VSS_419) U400.AW28(VSS_245) U400.AW29(VSS_248) U400.AW30(VSS_254) U400.AW31(VSS_257) U400.AY4(VSS_10) U400.AY33(VSS_260) U400.AY35(VSS_263) U400.B2(VSS_21) U400.B5(VSS_294) U400.B7(VSS_297) U400.B9(VSS_300) U400.B12(VSS_265) U400.B15(VSS_267) U400.B18(VSS_270) U400.B21(VSS_273) U400.B23(VSS_275) U400.B25(VSS_277) U400.B27(VSS_280) U400.B29(VSS_283) U400.B31(VSS_286) U400.B34(VSS_11) U400.B36(VSS_22) U400.B37(VSS_291) U400.BA3(VSS_308) U400.BA4(VSS_424) U400.BA6(VSS_420) U400.BA10(VSS_303) U400.BA28(VSS_306) U400.BB3(VSS_311) U400.BB4(VSS_320) U400.BB33(VSS_314) U400.BB36(VSS_317) U400.BC4(VSS_421) U400.BC8(VSS_337) U400.BC25(VSS_323) U400.BC29(VSS_328) U400.BC32(VSS_332) U400.BD4(VSS_425) U400.BD6(VSS_9) U400.BD7(VSS_416) U400.BD28(VSS_340) U400.BD33(VSS_343) U400.BD35(VSS_346) U400.BD36(VSS_349) U400.BE3(VSS_361) U400.BE4(VSS_422) U400.BE8(VSS_423) U400.BE10(VSS_352) U400.BE28(VSS_355) U400.BE29(VSS_358) U400.BE30(VSS_364) U400.BE31(VSS_367) U400.BF3(VSS_372) U400.BF4(VSS_379) U400.BF33(VSS_375) U400.BF36(VSS_377) U400.BG4(VSS_426) U400.BG25(VSS_382) U400.BG28(VSS_384) U400.BH28(VSS_389) U400.BH29(VSS_392) U400.BH32(VSS_394) U400.BH33(VSS_396) U400.BH35(VSS_398) U400.BJ7(VSS_33) U400.BK2(VSS_39) U400.BK3(VSS_44) U400.BK4(VSS_50) U400.BK7(VSS_53) U400.BK10(VSS_36) U400.BK28(VSS_42) U400.BK33(VSS_47) U400.BL7(VSS_73) U400.BL25(VSS_56) U400.BL28(VSS_59) U400.BL29(VSS_62) U400.BL30(VSS_65) U400.BL31(VSS_67) U400.BL32(VSS_70) U400.BM9(VSS_84) U400.BM33(VSS_75) U400.BM35(VSS_78) U400.BM36(VSS_81) U400.BN7(VSS_90) U400.BN30(VSS_87) U400.BP3(VSS_103) U400.BP4(VSS_111) U400.BP7(VSS_114) U400.BP12(VSS_411) U400.BP15(VSS_95) U400.BP19(VSS_400) U400.BP25(VSS_100) U400.BP32(VSS_105) U400.BP33(VSS_108) U400.BP36(TP2#BP36) U400.BR16(VSS_401) U400.BR19(VSS_119) U400.BR22(VSS_407) U400.BR25(VSS_122) U400.BT5(VSS_2) U400.BT14(VSS_410) U400.BT15(VSS_126) U400.BT16(VSS_128) U400.BT25(VSS_137) U400.BT28(VSS_140) U400.BT33(VSS_142) U400.BT35(VSS_145) U400.BT36(VSS_148) U400.BU7(VSS_166) U400.BU11(VSS_153) U400.BU16(VSS_405) U400.BU20(VSS_408) U400.BU23(VSS_158) U400.BU24(VSS_161) U400.BU25(VSS_163) U400.BV3(VSS_176) U400.BV4(VSS_184) U400.BV11(VSS_169) U400.BV31(VSS_179) U400.BV33(VSS_182) U400.BW7(VSS_205) U400.BW11(VSS_187) U400.BW15(VSS_190) U400.BW24(VSS_200) U400.BY5(VSS_3) U400.BY11(VSS_208) U400.BY15(VSS_210) U400.BY18(VSS_402) U400.BY19(VSS_403) U400.BY22(VSS_213) U400.BY25(VSS_217) U400.BY28(VSS_220) U400.BY33(VSS_223) U400.BY35(VSS_226) U400.BY36(VSS_229) U400.C1(VSS_234) U400.C4(VSS_249) U400.C9(VSS_252) U400.C21(VSS_237) U400.C25(VSS_240) U400.C29(VSS_243) U400.C33(VSS_246) U400.C36(VSS_23) U400.C37(VSS_24) U400.CA11(VSS_255) U400.CA15(VSS_258) U400.CA22(VSS_261) U400.CA25(VSS_268) U400.CB2(VSS_284) U400.CB3(VSS_292) U400.CB4(VSS_298) U400.CB7(VSS_301) U400.CB11(VSS_271) U400.CB18(VSS_278) U400.CB19(VSS_281) U400.CB20(VSS_287) U400.CB24(VSS_412) U400.CB25(VSS_289) U400.CB33(VSS_295) U400.CC7(VSS_321) U400.CC11(VSS_304) U400.CC14(VSS_406) U400.CC16(VSS_404) U400.CC20(VSS_309) U400.CC24(VSS_413) U400.CC25(VSS_312) U400.CC28(VSS_315) U400.CC31(VSS_318) U400.CD11(VSS_324) U400.CD12(VSS_326) U400.CD14(VSS_329) U400.CD20(VSS_409) U400.CD24(VSS_333) U400.CD25(VSS_335) U400.CE7(VSS_347) U400.CE33(VSS_338) U400.CE35(VSS_341) U400.CE36(VSS_344) U400.CF2(VSS_359) U400.CF3(VSS_368) U400.CF4(VSS_370) U400.CF11(VSS_350) U400.CF14(VSS_353) U400.CF19(VSS_356) U400.CF23(VSS_362) U400.CF28(VSS_365) U400.CG7(VSS_376) U400.CG33(VSS_373) U400.CH31(VSS_380) U400.CJ2(VSS_427) U400.CJ3(VSS_428) U400.CJ4(VSS_37) U400.CJ11(VSS_385) U400.CJ14(VSS_387) U400.CJ19(VSS_390) U400.CJ23(VSS_393) U400.CJ28(VSS_395) U400.CJ33(VSS_397) U400.CJ35(VSS_399) U400.CJ36(VSS_34) U400.CK1(VSS_40) U400.CK4(VSS_45) U400.CK7(VSS_48) U400.CK37(VSS_6) U400.CL2(VSS_51) U400.CM1(VSS_8) U400.CM4(VSS_430) U400.CM5(VSS_76) U400.CM9(VSS_79) U400.CM13(VSS_54) U400.CM17(VSS_57) U400.CM21(VSS_60) U400.CM25(VSS_63) U400.CM29(VSS_66) U400.CM31(VSS_68) U400.CM33(VSS_71) U400.CM37(VSS_5) U400.CN1(VSS_25) U400.CN2(VSS_26) U400.CN5(VSS_98) U400.CN9(VSS_101) U400.CN13(VSS_82) U400.CN17(VSS_85) U400.CN21(VSS_88) U400.CN25(VSS_91) U400.CN29(VSS_93) U400.CN37(VSS_27) U400.CP1(VSS_104) U400.CP2(VSS_28) U400.CP9(VSS_129) U400.CP11(VSS_106) U400.CP13(VSS_109) U400.CP15(VSS_112) U400.CP19(VSS_115) U400.CP21(VSS_117) U400.CP27(VSS_120) U400.CP35(VSS_4) U400.CP37(VSS_124) U400.CR2(VSS_131) U400.CR6(VSS_433) U400.CR34(VSS_1) U400.CR36(VSS_133) U400.D1(VSS_29) U400.D5(VSS_143) U400.D6(VSS_146) U400.D8(VSS_149) U400.D9(VSS_151) U400.D21(VSS_135) U400.D25(VSS_138) U400.E9(VSS_167) U400.E23(VSS_154) U400.E27(VSS_156) U400.E29(VSS_159) U400.E31(VSS_162) U400.E33(VSS_164) U400.E35(VSS_12) U400.F2(VSS_177) U400.F3(VSS_185) U400.F4(VSS_188) U400.F12(VSS_170) U400.F15(VSS_172) U400.F18(VSS_174) U400.F21(VSS_180) U400.F24(VSS_183) U400.F33(VSS_31) U400.G9(VSS_201) U400.G21(VSS_191) U400.G27(VSS_193) U400.G33(VSS_195) U400.G35(VSS_197) U400.G36(VSS_198) U400.H9(VSS_211) U400.H21(VSS_203) U400.H27(VSS_206) U400.J5(VSS_414) U400.J6(VSS_232) U400.J12(VSS_214) U400.J15(VSS_216) U400.J18(VSS_218) U400.J21(VSS_221) U400.J24(VSS_224) U400.J33(VSS_227) U400.J36(VSS_230) U400.K3(VSS_256) U400.K4(VSS_266) U400.K9(VSS_269) U400.K21(VSS_235) U400.K22(VSS_238) U400.K24(VSS_241) U400.K25(VSS_244) U400.K27(VSS_247) U400.K28(VSS_250) U400.K29(VSS_253) U400.K30(VSS_259) U400.K31(VSS_262) U400.K32(VSS_264) U400.L6(VSS_282) U400.L27(VSS_272) U400.L33(VSS_274) U400.L35(VSS_276) U400.L36(VSS_279) U400.N6(VSS_290) U400.N25(VSS_285) U400.N27(VSS_288) U400.P3(VSS_296) U400.P4(VSS_305) U400.P7(VSS_307) U400.P10(VSS_293) U400.P33(VSS_299) U400.P36(VSS_302) U400.R27(VSS_310) U400.R28(VSS_313) U400.R29(VSS_316) U400.R30(VSS_319) U400.R31(VSS_322) U400.T7(VSS_336) U400.T27(VSS_325) U400.T30(VSS_327) U400.T33(VSS_330) U400.T35(VSS_331) U400.T36(VSS_334) U400.U7(VSS_342) U400.U24(VSS_415) U400.U26(VSS_339) U400.V3(VSS_351) U400.V4(VSS_363) U400.V26(VSS_345) U400.V27(VSS_348) U400.V30(VSS_354) U400.V33(VSS_357) U400.V36(VSS_360) U400.W7(VSS_374) U400.W10(VSS_366) U400.W27(VSS_369) U400.W30(VSS_371) U400.Y7(VSS_391) U400.Y26(VSS_378) U400.Y27(VSS_381) U400.Y30(VSS_383) U400.Y33(VSS_386) U400.Y35(VSS_388) U401.3(GND) U402.3(GND) U3400.2(GND) U3500.2(GND) U3501.14(GND) U3501.33(EPAD9) U3501.34(EPAD8) U3501.35(EPAD7) U3501.36(EPAD1) U3501.37(EPAD2) U3501.38(EPAD3) U3501.39(EPAD4) U3501.40(EPAD5) U3501.41(EPAD6) U3600.41(GND) U4000.33(GND) U4001.25(GND) U4100.2(GND) U4201.2(GND) U4201.3(A) U4202.3(GND) U4700.2(GND) U4701.A1(VSS#2) U4701.A5(VSS#3) U4701.A8(VSS#1) U4701.E12(VSS#8) U4701.G1(VSS#4) U4701.J12(VSS#7) U4701.M3(VSS#5) U4701.M9(VSS#6) U5100.2(GND#1) U5100.9(GND#2) U5100.23(GND#3) U5100.32(GND#4) U5100.33(THERMAL PAD) U5300.5(RESERVED) U5300.6(GND_1) U5300.7(GND_2) U5300.8(GND_3) U5301.5(RES) U5301.6(GND#1) U5301.7(GND#2) U5301.8(GND#3) U5400.5(GND) U5401.2(GND) U5401.4(HYST) U5600.4(VSS) U5700.3(GND_1) U5700.8(GND_2) U5701.2(GND) U5702.3(GND_1) U5702.8(GND_2) U5800.41(EPAD) U5801.2(GND) U6100.41(EPAD) U6300.3(GND_1) U6300.8(GND_2) U6301.3(GND_1) U6301.8(GND_2) U6302.B3(GND #1) U6302.C3(GND #2) U6302.D3(GND #3) U6303.3(GND_1) U6303.8(GND_2) U7500.5(GND) U7600.29(EPAD) U7601.2(GND) VC3500.2 VC5700.1 VC5701.2 VC5702.1 Y400.2 Y400.4 Y4000.2 Y4000.4
GND0: CN7700.1(GND0) R7722.2 R7726.2
VCC1_RST#: CN7701.3 R4743.1 R4748.1 U4701.K6(V\C\C\1\_\R\S\T\/GPO77)
VCCGT_CS1: PR8817.2 PR9002.1 PU8800.1(CS4)
VCCGT_CS_SUM: PR8817.1 PR8853.2 PR8856.1 PU8800.18(CS_SUMB)
VCCGT_PWM1: PR9000.1 PU8800.36(PWM4)
VCCGT_VDIFF: PC8816.2 PR8832.1 PU8800.9(VDIFFB)
VCCGT_VFB: PC8816.1 PR8832.2 PR8834.1 PR8860.2 PR8861.2 PU8800.10(VFBB)
VCCGT_VORTN: PR8839.1 PU8800.12(VORTNB)
VCCGT_VOSEN: PR8837.1 PU8800.11(VOSENB)
VCCIO_EN: PC9222.1 PR9211.1 PU9201.4(ON)
VCCIO_PG: PR8100.1 R449.2 R452.2 U401.2(INA)
VCCIO_VCCSENSE: TP421.1 U400.BP28(VCCIO_SENSE)
VCCIO_VSSSENSE: TP422.1 U400.BP29(VSSIO_SENSE)
VCCSA_CS: PR8819.2 PR9017.1 PU8800.44(CS5)
VCCSA_CS_SUM: PR8819.1 PR8854.2 PR8857.1 PU8800.19(CS_SUMC)
VCCSA_PWM: PR9016.1 PU8800.35(PWM5)
VCCSA_VCCSENSE: PR8842.1 PR8843.2 U400.BG7(VCCSA_SENSE)
VCCSA_VDIFF: PC8817.2 PR8848.1 PU8800.13(VDIFFC)
VCCSA_VFB: PC8817.1 PR8848.2 PR8849.1 PR8866.1 PR8867.2 PU8800.14(VFBC)
VCCSA_VORTN: PR8844.1 PU8800.16(VORTNC)
VCCSA_VOSEN: PR8843.1 PU8800.15(VOSENC)
VCCSA_VSSSENSE: PR8844.2 PR8845.1 U400.BE7(VSSSA_SENSE)
VCCSENSE: PR8826.1 PR8828.2 R609.1 U400.AN6(VCC_SENSE)
VDDD_SUPPLY_R: CN7701.19 R7701.1 R7711.1
VSSSENSE: PR8829.2 PR8833.1 R610.1 U400.AN5(VSS_SENSE)
681_3V3_1.8V: PC9301.1 PR9300.2 PU9300.10(3V3)
681_AGND_1.8V: PC9301.2 PR9302.2 PU9300.11(AGND)
681_BST_1.8V: PR9303.2 PU9300.9(BST)
681_C0_1.8V: PR9310.1 PU9300.4(C0)
681_C1_1.8V: PR9309.1 PU9300.3(C1)
681_EN_1.8V: PC9310.1 PR9304.1 PR9305.2 PU9300.5(EN)
681_LP#_1.8V: PR9306.1 PU9300.6(LP#)
681_MODE_1.8V: PR9311.2 PU9300.7(MODE)
681_SW_1.8V: PC9309.2 PL9300.1 PR9307.2 PU9300.8(SW)
681_VOUT_1.8V: PR9312.1 PR9313.2 PU9300.12(VOUT)
681_VOUT_1.8V_S: PR9308.1 PR9312.2
2260_BST_1.0V: PR9202.2 PU9200.20(BST)
2260_EN_1.0V: PC9214.2 PR9207.1 PR9208.1 PU9200.2(EN)
2260_FB_1.0V: PR9209.1 PR9210.1 PU9200.5(FB)
2260_FB_1.0V_S: PR9206.1 PR9209.2
2260_LX_1.0V: PC9209.2 PL9201.1 PR9204.2 PU9200.10(LX#1) PU9200.16(LX#3) PU9200.17(LX#4) PU9200.18(LX#5)
2260_PFM_1.0V: PR9205.1 PU9200.3(P\F\M\)
2260_PG_1.0V: PR9203.1 PU9200.1(PGOOD)
2260_SS_1.0V: PC9216.1 PU9200.23(SS)
2260_TON_1.0V: PR9200.2 PU9200.6(TON)
2260_VCC_1.0V: PC9206.2 PR9201.2 PU9200.21(VCC)
8051_RX_CAPS_LED#: CN7701.21 R4733.1 R4737.1 U4700.3(2A) U4701.J7(GPIOB7/PWM5_LED1)
8051_TX_LED_PWRSTBY#: CN7701.22 R4732.1 R4738.1 U4700.1(1A) U4701.H8(GPIOC0/PWM6_LED2)
8097_EN_2.5V: PC8725.2 PR8719.1 PR8721.2 PU8701.1(EN)
8097_LX_2.5V: PL8702.1 PU8701.3(LX)
8097_PG_2.5V: PR8716.2 PU8701.5(PG)
8097_VFB_2.5V: PC8728.2 PR8723.2 PR8724.2 PU8701.6(FB)
8097_VFB_2.5V_S: PC8728.1 PR8722.1 PR8723.1
8097_VIN_2.5V: PC8723.1 PR8715.2 PU8701.4(VIN)
8231_BT: PR8705.2 PU8700.18(BOOT)
8231_BT_S: PC8711.1 PR8705.1
8231_CS: PR8702.2 PU8700.13(CS)
8231_LG: PQ8701.4(G) PU8700.15(LGATE)
8231_PG: PR8700.2 PU8700.10(PGOOD)
8231_PH: PC8711.2 PL8701.1 PQ8700.1(S1) PQ8700.2(S2) PQ8700.3(S3) PQ8701.5(D) PR8707.2 PU8700.16(PHASE)
8231_S3: PC8701.2 PR8703.2 PU8700.7(S3)
8231_S5: PC8700.1 PR8701.2 PU8700.8(S5)
8231_TON: PR8704.1 PU8700.9(TON)
8231_UG: PQ8700.4(G) PU8700.17(UGATE)
8231_VDDQ: PR8710.1 PR8713.2 PU8700.5(VDDQ)
8231_VID: PR8711.1 PU8700.11(VID)
8231_VLDOIN: PC8714.1 PR8708.2 PU8700.19(VLDOIN)
8231_VTTREF: PC8713.1 PR8706.2 PU8700.4(VTTREF)
8693_VCCGT_BST1: PC9008.1 PU9000.1(BST)
8693_VCCGT_CS1: PR9002.2 PU9000.5(CS)
8693_VCCGT_HG1: PR9001.1 PU9000.12(HGATE)
8693_VCCGT_HG1_R: PQ9000.1(G1) PR9001.2
8693_VCCGT_ISENN1: PR9014.1 PU9000.6(ISENN)
8693_VCCGT_ISENP1: PR9011.1 PU9000.7(ISENP)
8693_VCCGT_LG1: PQ9000.8(G2) PU9000.9(LGATE)
8693_VCCGT_PWM1: PR9000.2 PU9000.3(PWM)
8693_VCCGT_SW1: PC9008.2 PL9000.1 PQ9000.9(S1/D2) PR9004.1 PR9005.2 PU9000.11(SW)
8693_VCCGT_SYNC1: PR9007.2 PU9000.4(SYNC)
8693_VCCGT_VTEMP1: PR9003.2 PU9000.2(TEMP)
8693_VCCSA_BST1: PC9026.1 PU9001.1(BST)
8693_VCCSA_CS1: PR9017.2 PU9001.5(CS)
8693_VCCSA_HG1: PR9015.1 PU9001.12(HGATE)
8693_VCCSA_HG1_R: PQ9001.4 PR9015.2
8693_VCCSA_ISENN1: PR9029.1 PU9001.6(ISENN)
8693_VCCSA_ISENP1: PR9026.1 PU9001.7(ISENP)
8693_VCCSA_PWM1: PR9016.2 PU9001.3(PWM)
8693_VCCSA_SW1: PC9026.2 PL9001.1 PQ9001.1 PQ9001.2 PQ9001.3 PQ9002.5 PQ9002.6 PQ9002.7 PQ9002.8 PR9019.1 PR9020.2 PU9001.11(SW)
8693_VCCSA_SYNC1: PR9022.2 PU9001.4(SYNC)
8693_VCCSA_VTEMP1: PR9018.2 PU9001.2(TEMP)
8693_VCORE_BST1: PC8909.1 PU8900.1(BST)
8693_VCORE_BST2: PC8922.1 PU8901.1(BST)
8693_VCORE_CS1: PR8903.2 PU8900.5(CS)
8693_VCORE_CS2: PR8920.2 PU8901.5(CS)
8693_VCORE_HG1: PR8900.1 PU8900.12(HGATE)
8693_VCORE_HG1_R: PQ8900.1(G1) PR8900.2
8693_VCORE_HG2: PR8915.1 PU8901.12(HGATE)
8693_VCORE_HG2_R: PQ8901.1(G1) PR8915.2
8693_VCORE_ISENN1: PR8914.1 PU8900.6(ISENN)
8693_VCORE_ISENN2: PR8929.1 PU8901.6(ISENN)
8693_VCORE_ISENP1: PR8911.1 PU8900.7(ISENP)
8693_VCORE_ISENP2: PR8926.1 PU8901.7(ISENP)
8693_VCORE_LG1: PQ8900.8(G2) PU8900.9(LGATE)
8693_VCORE_LG2: PQ8901.8(G2) PU8901.9(LGATE)
8693_VCORE_PWM1: PR8901.2 PU8900.3(PWM)
8693_VCORE_PWM2: PR8916.2 PU8901.3(PWM)
8693_VCORE_SW1: PC8909.2 PL8902.1 PQ8900.5(D2/S1#1) PQ8900.6(D2/S1#2) PQ8900.7(D2/S1#3) PR8902.2 PR8904.1 PU8900.11(SW)
8693_VCORE_SW2: PC8922.2 PL8903.1 PQ8901.5(D2/S1#1) PQ8901.6(D2/S1#2) PQ8901.7(D2/S1#3) PR8917.1 PR8918.2 PU8901.11(SW)
8693_VCORE_SYNC1: PR8907.2 PU8900.4(SYNC)
8693_VCORE_SYNC2: PR8922.2 PU8901.4(SYNC)
8693_VCORE_VTEMP1: PR8906.2 PU8900.2(TEMP)
8693_VCORE_VTEMP2: PR8921.2 PU8901.2(TEMP)
8693_VCSA_LG1: PQ9002.4 PU9001.9(LGATE)
+BAT_DIS: PL8202.2 PQ8200.5(D) PQ8201.3(D) PR8214.1 PR8217.2 PR8223.2
+BATCHG: PC8214.1 PC8215.1 PC8226.1 PC8227.1 PC8228.1 PC8505.1 PC8506.2 PD8204.2(ANODE) PD8205.1(CATHODE) PL8500.2 PL8501.2 PR8214.2 PR8218.2
+G_SEN_PW: C5300.1 C5301.1 R5300.2 R5302.2 U5300.2(CS) U5300.9(VDD) U5300.10(VDD_IO)
+G_SEN_PW_S: C5305.1 R5303.1 R5304.1 U5301.2(CS) U5301.9(VDD) U5301.10(VDD_IO)
+SMDDR_VREF_DIMM: C2822.1 C2823.1 R2801.2 R2812.1 R2813.2 R2817.2
+SMDDR_VREF_DQ0: JDIM2800.164(VREF_CA) R2801.1
+SMDDR_VREF_DQ1: JDIM2801.164(VREF_CA) R2822.1
+SPI_VCC: C5101.2 C5102.2 C5103.2 C5600.1 C5601.2 R5100.1 R5101.1 R5104.2 R5105.2 R5106.1 R5600.1 R5601.1 R5602.2 R5603.1 R5604.2 U5100.1(VDD#3) U5100.8(VDD#1) U5100.22(VDD#2) U5600.8(VDD)
+UIM_PWR: C4209.1 C4210.1 C4211.2 CN4200.36(SIM_PWR) CN4201.1(VCC) R4222.2 R4225.2
+VAC: PC8000.1 PCN8000.1(VDD#1) PCN8000.2(VDD#2) PL8000.1 PL8001.1
+VAC_IN: PC8001.1 PC8002.1 PD8000.1 PL8000.2 PL8001.2 PQ8000.1(S1) PQ8000.2(S2) PQ8000.3(S3) PQ8002.1(S) PR8000.1 PR8001.1 PR8014.1
+VHIF: C4700.1 C4703.1 R4719.2 U4701.F1(VHIF)
+VSPI: C4705.1 C4706.2 R4723.2 U4701.H12(VSPI)
A_3S_ICHSPKR: R3616.1 U400.CF35(GPP_B14/SPKR)
A_SD#: D3604.1(CATHODE) R3621.2 U4701.L8(GPIO92/I2C2_SCL0)
ACCEL_INT: C5304.2 Q7601.3(D) Q7601.6(D) R486.2 U400.CN12(GPP_C22/UART2_RTS#) U5300.12(INT1)
ACCEL_PANEL_INT1#: CN7602.4 Q7601.5(G)
ACCEL_PANEL_INT2#: CN7602.5 Q7601.2(G)
ACCEL_SLATE_INT1#: Q5300.2(G) U5301.12(INT1)
ACCEL_SLATE_INT2#: Q5301.2(G) U5301.11(INT2)
ACCEL_SLATE_INT#: Q5300.3(D) Q5301.3(D) R4769.1
ACZ_BCLK: R570.2 U400.BN37(HDA_BCLK/I2S0_SCLK)
ACZ_RST#: R572.2 U400.BL35(HDA_RST#/I2S1_SCLK/SNDW1_CLK)
ACZ_RST#_AUDIO: R572.1 R3622.2
ACZ_SDIN0: EC3609.2 R3611.1 U400.BN35(HDA_SDI0/I2S0_RXD)
ACZ_SDO: Q406.3(D) Q408.3(D) U400.BN36(HDA_SDO/I2S0_TXD)
ACZ_SDOUT: Q406.1(S) R583.2
ACZ_SDOUT_AUDIO: EC3611.2 R583.1 U3600.4(SDATA-OUT)
ACZ_SDOUT_G: Q406.2(G) R580.1
ACZ_SYNC: R569.2 U400.BN34(HDA_SYNC/I2S0_SFRM)
ACZ_SYNC_AUDIO: EC3612.2 R569.1 U3600.9(SYNC)
ADDR: R5804.1 R5805.1 U5800.3(ADDR)
ADP_DET: PR8226.1 PR8228.1 PU8200.5(ACOK) U4701.M5(GPIO71/PS2_DAT3/TB2)
ADP_ID_ADC_R: C4710.2 R4710.1 U4701.E2(GPIO43/ADC2)
ADP_PRES_OUT: R454.1 U400.BU35(GPD1/ACPRESENT) U4701.H3(GPOD6/J\E\N\1\)
AMBER_BATLED#: C4725.2 PR8002.1 R4744.2 U4701.L9(GPIOB6/PWM4_LED0)
AMD_VBIOS_SEL#: R532.1 R534.1 U400.CP20(GPP_F0/CNV_PA_BLANKING)
AMP_BEEP: C3634.2 U3600.11(PCBEEP)
AMP_BEEP_L: C3634.1 C3639.2 R3616.2 R3617.1
ANT_TUNE0: C7874.2 CN3400.30 CN4200.59(ANT_TUNE0)
ANT_TUNE1: C7873.2 CN3400.29 CN4200.61(ANT_TUNE1)
B/I: PCN8500.3(B/I) PR8512.1 PR8515.2
BARREL_ADP_DET: C4720.1 PQ8011.3(COLLECTOR) PR8020.1 PR8022.1 U4701.H5(GPIO74)
BARREL_ADP_EN: PQ8004.1(S) PR8011.2 U4701.F4(GPIOE0)
BAT_GRNLED#: C4724.2 PR8004.2 U4701.F7(GPIO02)
BATLOW#: Q4701.3(D) R453.1 U400.BV36(GPD0/BATLOW#) U4701.A9(GPIOD4/JTAG_TDO1_SWO1)
BATT+: PC8504.1 PCN8500.7(BATT+#1) PCN8500.8(BATT+#2) PL8500.1 PL8501.1
BIT_CLK_AUDIO: C420.2 R570.1 R3615.1
BIT_CLK_AUDIO_L: C3622.2 R3615.2 U3600.5(BIT-CLK)
BLON_CON: CN3400.5 Q3401.3(D) R3423.1
BOOT_SPI#: R501.1 U400.CA30(GPP_B22/GSPI1_MOSI)
BQACDET: PC8213.1 PD8206.1(CATHODE) PR8213.2 PR8215.1 PR8228.2 PU8200.6(ACDET)
BQACDRV: PU8200.4(ACDRV) TP8200.1
BQACN: PR8206.2 PR8211.1 PU8200.1(ACN)
BQACP: PR8205.2 PU8200.2(ACP)
BQBATDRV: PU8200.18(BATDRV) TP8202.1
BQBATPRES: PR8222.2 PR8224.2 PU8200.15(B\A\T\P\R\E\S\)
BQBATSRC: PR8223.1 PU8200.17(BATSRC)
BQBTST: PR8212.2 PU8200.25(BTST)
BQCMPIN: PC8224.2 PR8240.2 PR8241.1 PR8243.1 PU8200.13(CMPIN)
BQCMPOUT: PR8238.1 PR8241.2 PR8242.1 PU8200.14(CMPOUT)
BQCMSRC: PR8209.1 PU8200.3(CMSRC)
BQHIDRV: PQ8203.4(G) PU8200.26(HIDRV)
BQIADP: PC8220.1 PR8229.2 PU8200.7(IADP)
BQIDCHG: PC8221.1 PR8230.2 PU8200.8(IDCHG)
BQILIM: PQ8206.3(D) PR8233.1 PU8200.21(ILIM)
BQLODRV: PQ8204.4(G) PU8200.23(LODRV)
BQPHASE: PC8212.2 PL8202.1 PQ8203.1(S1) PQ8203.2(S2) PQ8203.3(S3) PQ8204.5(D) PR8216.2 PU8200.27(PHASE)
BQPMON: PR8235.1 PR8237.1 PU8200.9(PMON)
BQPROCHOT: PR8221.2 PU8200.10(P\R\O\C\H\O\T\)
BQSCL: PR8220.1 PU8200.12(SCL)
BQSDA: PR8219.1 PU8200.11(SDA)
BQSRN: PR8227.1 PU8200.19(SRN)
BQSRP: PR8225.1 PU8200.20(SRP)
BQTB_STAT: PU8200.16(T\B\_\S\T\A\T\) TP8201.1
BQVCC: PC8211.1 PR8210.2 PU8200.28(VCC)
BRD_ID1: R504.1 R505.1 U400.CR28(GPP_H12/M2_SKT2/CFG_0)
BRD_ID2: R506.1 R507.1 U400.CP28(GPP_H13/M2_SKT2/CFG_1)
BRD_ID3: R508.1 R509.2 U400.CN28(GPP_H14/M2_SKT2/CFG_2)
BRD_ID4: R510.1 R511.2 U400.CM28(GPP_H15/M2_SKT2/CFG_3)
BT_OFF: Q4102.5(G) R473.1 R4147.1 U400.CM24(GPP_D13/ISH_UART0_RXD/SML0BDATA)
C_TX0_HDMI+: C3513.1 U3501.6(IN_D0P)
C_TX0_HDMI-: C3514.1 U3501.7(IN_D0N)
C_TX1_HDMI+: C3511.1 U3501.4(IN_D1P)
C_TX1_HDMI-: C3512.1 U3501.5(IN_D1N)
C_TX2_HDMI+: C3509.1 U3501.1(IN_D2P)
C_TX2_HDMI-: C3510.1 U3501.2(IN_D2N)
C_TXC_HDMI+: C3515.1 U3501.9(IN_CKP)
C_TXC_HDMI-: C3516.1 U3501.10(IN_CKN)
CABLE_SIZE_DET: CN3400.11 R517.2 R518.1 U400.CK17(GPP_F10)
CABLE_SIZE_DET_2: CN3400.4 R3425.1
CAMERA_ON: CN3400.9 R483.1 R7636.2 U400.CA31(GPP_B19/GSPI1_CS0#)
CAMERA_WP#: CN3400.25 R4768.2 U4701.E8(GPIOF5/I2C5_SCL1)
CAPS_LED#: C5023.2 R4735.1 R4737.2 R5004.1 U4700.4(2Y)
CATERR#: R400.1 TP401.1 U400.AA4(CATERR#)
CCG5_HOTPLUG_DET_P1_C: Q6100.3(D) R6100.1 R6112.2 R6113.1 U6100.18(HPD/GPIO_P3.0)
CCG5_I2C_SCL_MUX: Q5800.6(D) R5807.2 R7734.1 U6100.13(SCL_4/UV_OCP_TRIP/GPIO_P2.3)
CCG5_I2C_SCL_MUX_C: CN7702.4 R7734.2
CCG5_I2C_SDA_MUX: Q5800.3(D) R5808.2 R7733.1 U6100.14(SDA_4/OVP_TRIP/GPIO_2.4)
CCG5_I2C_SDA_MUX_C: CN7702.3 R7733.2
CCG5_SWD_CLK: R6106.2 R6107.1 R7708.1 TP6103.1 U6100.2(SWD_CLK/I2C_CFG_EC/GPIO_P1.0)
CCG5_SWD_CLK_R: CN7701.14 R7702.2 R7708.2
CCG5_SWD_IO: R7710.1 TP6104.1 U6100.6(SWD_IO/TBT_RST#/GPIO_P1.6)
CCG5_SWD_IO_R: CN7701.12 R7700.2 R7710.2
CCG5_VBUS: R6111.1 U6100.22(VBUS)
CCG5_VBUS_C_CTRL_P1: PQ8005.5(G) PR8007.2 PR8012.1 U6100.12(VBUS_C_CTRL)
CCG5_XRES: C6106.2 R6108.2 R7706.1 TP6102.1 U6100.10(XRES)
CCG5_XRES_R: CN7701.15 R7704.2 R7706.2
CD_WP_POL#: R7613.2 U7600.27(CD_WP_POL#)
CFG0: CN7700.9(OBSDATA_A0) R632.2 R7718.2 U400.T4(CFG_0)
CFG1: CN7700.11(OBSDATA_A1) R633.2 U400.R4(CFG_1)
CFG2: CN7700.15(OBSDATA_A2) R634.2 U400.T3(CFG_2)
CFG3: CN7700.17(OBSDATA_A3) R635.2 R7726.1 U400.R3(CFG_3)
CFG4: CN7700.27(OBSDATA_B0) R605.2 U400.J4(CFG_4)
CFG5: CN7700.29(OBSDATA_B1) R637.2 U400.M4(CFG_5)
CFG6: CN7700.33(OBSDATA_B2) R638.2 U400.J3(CFG_6)
CFG7: CN7700.35(OBSDATA_B3) R639.2 U400.M3(CFG_7)
CFG8: CN7700.10(OBSDATA_C0) R640.2 TP7700.1 U400.R2(CFG_8)
CFG9: CN7700.12(OBSDATA_C1) R641.2 U400.N2(CFG_9)
CFG10: CN7700.16(OBSDATA_C2) R642.2 U400.R1(CFG_10)
CFG11: CN7700.18(OBSDATA_C3) R643.2 U400.N1(CFG_11)
CFG12: CN7700.28(OBSDATA_D0) R644.2 U400.J2(CFG_12)
CFG13: CN7700.30(OBSDATA_D1) R645.2 U400.L2(CFG_13)
CFG14: CN7700.34(OBSDATA_D2) R646.2 U400.J1(CFG_14)
CFG15: CN7700.36(OBSDATA_D3) R647.2 U400.L1(CFG_15)
CFG16: CN7700.6(OBSFN_C1) U400.L3(CFG_16)
CFG17: CN7700.4(OBSFN_C0) U400.L4(CFG_17)
CFG18: CN7700.24(OBSFN_D1) U400.N3(CFG_18)
CFG19: CN7700.22(OBSFN_D0) U400.N4(CFG_19)
CFG_RCOMP: R603.1 U400.AB5(CFG_RCOMP)
CHA_SA0: JDIM2800.256(SA0) R2814.1 R2819.2
CHA_SA1: JDIM2800.260(SA1) R2815.1 R2820.2
CHA_SA2: JDIM2800.166(SA2) R2816.1 R2821.2
CHB_SA0: JDIM2801.256(SA0) R2823.2 R2826.1
CHB_SA1: JDIM2801.260(SA1) R2824.2 R2827.1
CHB_SA2: JDIM2801.166(SA2) R2825.2 R2828.1
CK_XDP_N: CN7700.42(ITPCLK#/HOOK5) R585.3(R3)
CK_XDP_N_R: R585.4(R4) U400.AU1(C\L\K\O\U\T\_\I\T\P\X\D\P\)
CK_XDP_P: CN7700.40(ITPCLK/HOOK4) R585.1(R1)
CK_XDP_P_R: R585.2(R2) U400.AU2(CLKOUT_ITPXDP_P)
CL_CLK: C4108.2 R4115.1 U400.CH7(CL_CLK)
CL_DATA: R4114.1 U400.CH8(CL_DATA)
CL_RST: R4113.1 U400.CH9(CL_RST#)
CLICKPAD_INT#: CN6200.7 R9647.2 U400.CR22(GPP_D10/ISH_SPI_CLK/GSPI2_CLK)
CLK_PCI_EC_R: R442.1 U400.BV32(GPP_A9/CLKOUT_LPC0/ESPI_CLK)
CLK_PCIE_LANN: U400.BD3(CLKOUT_PCIE_N_2) U4000.16(REFCLK_N)
CLK_PCIE_LANP: U400.BC3(CLKOUT_PCIE_P_2) U4000.15(REFCLK_P)
CLK_PCIE_SSDN: CN4300.53(REFCLKN) U400.AW2(CLKOUT_PCIE_N_0)
CLK_PCIE_SSDP: CN4300.55(REFCLKP) U400.AY3(CLKOUT_PCIE_P_0)
CLK_PCIE_WLANN: CN4100.49(REFCLKN0) U400.BH3(CLKOUT_PCIE_N_3)
CLK_PCIE_WLANP: CN4100.47(REFCLKP0) U400.BH4(CLKOUT_PCIE_P_3)
CLK_PCIE_WWANN: CN4200.53(NC#9) U400.BE1(CLKOUT_PCIE_N_5)
CLK_PCIE_WWANP: CN4200.55(NC#10) U400.BE2(CLKOUT_PCIE_P_5)
CLKIN_XTAL_LCP: C423.2 L400.2 R588.2 U400.CM3(CLKIN_XTAL)
CLKIN_XTAL_LCP_R: CN4100.64(RESERVED) L400.1
CLKRUN#: R630.2 U400.BY30(GPP_A8/CLKRUN#)
CNV_BRI_DT: CN4100.36(UART RTS) R471.1 R4144.2
CNV_BRI_RSP: R497.2 R4119.1 U400.CK20(GPP_F5/CNV_BRI_RSP)
CNV_BRI_RSP_R: CN4100.22(UART RX) R4119.2
CNV_RF_RESET#: R576.1 R4123.2 U400.CJ32(GPP_H1/I2S2_SFRM/CNV_BT_I2S_BCL)
CNV_RF_RESET#_L: CN4100.10(PCM_SYNC) R4123.1
CNV_RGI_DT: CN4100.32(UART TX) R470.1 R4143.1
CNV_RGI_RSP: R500.1 R4118.1 U400.CH19(GPP_F7/CNV_RGI_RSP)
CNV_RGI_RSP_R: CN4100.34(UART CTS) R4118.2
CNVI_EN#: R4140.2 U400.CH32(GPP_H0/I2S2_SCLK/CNV_BT_I2S_SCL)
CNVI_EN#_R: Q4109.2(G) R4137.1 R4138.2 R4140.1
CORE_VID_0: TP423.1 U400.CB36(GPP_B0/CORE_VID0)
CORE_VID_1: TP424.1 U400.CB35(GPP_B1/CORE_VID1)
CPU_C10_GATE#: PR9217.2 PR9609.2 PR9618.2 R4706.1 TP427.1 U400.CN27(GPP_H18/CPU_C10_GATE#)
CPU_PROCHOT#: C400.1 PR8519.1 PR8804.2 PR8810.1 R403.1 R404.1
CPU_PROCHOT#_R: R404.2 U400.Y4(PROCHOT#)
CPU_THERM#: Q5400.2(G) R5405.1 U5400.4(OVERT#)
CSP_C: R6110.1 U6100.1(CSP)
CSP_GND: R6114.1 U6100.40(CSN)
CYPRE_INT: R4715.2 R6103.2 R7732.1 U6100.15(I2C_INT_EC/GPIO_P2.5)
CYPRE_INT_C: CN7702.7 R7732.2
DCICLK: TP5801.1 U5800.14(DCI_CLK)
DCIDATA: TP5800.1 U5800.11(DCI_DATA)
DCIN_EN: R3506.1 U3501.8(DCIN_EN)
DCPRTC: C439.2 U400.BP24(DCPRTC)
DDI2_AUX_DN: C5809.1 U400.AD4(D\D\I\2\_\A\U\X\)
DDI2_AUX_DN_C: C5809.2 R5810.1 U5800.25(AUXN)
DDI2_AUX_DP: C5808.1 U400.AD3(DDI2_AUX_P)
DDI2_AUX_DP_C: C5808.2 R5811.2 U5800.24(AUXP)
DDI2_TX0_DN: C5800.1 U400.AC4(DDI2_TXN_0)
DDI2_TX0_DN_C: C5800.2 U5800.10(ML0N)
DDI2_TX0_DP: C5801.1 U400.AC3(DDI2_TXP_0)
DDI2_TX0_DP_C: C5801.2 U5800.9(ML0P)
DDI2_TX1_DN: C5803.1 U400.AC1(DDI2_TXN_1)
DDI2_TX1_DN_C: C5803.2 U5800.13(ML1N)
DDI2_TX1_DP: C5802.1 U400.AC2(DDI2_TXP_1)
DDI2_TX1_DP_C: C5802.2 U5800.12(ML1P)
DDI2_TX2_DN: C5805.1 U400.AE4(DDI2_TXN_2)
DDI2_TX2_DN_C: C5805.2 U5800.16(ML2N)
DDI2_TX2_DP: C5804.1 U400.AE3(DDI2_TXP_2)
DDI2_TX2_DP_C: C5804.2 U5800.15(ML2P)
DDI2_TX3_DN: C5807.1 U400.AE1(DDI2_TXN_3)
DDI2_TX3_DN_C: C5807.2 U5800.19(ML3N)
DDI2_TX3_DP: C5806.1 U400.AE2(DDI2_TXP_3)
DDI2_TX3_DP_C: C5806.2 U5800.18(ML3P)
DDR3_DRAMRST#: C2800.2 C2829.2 JDIM2800.108(RESET#) JDIM2801.108(RESET#) R544.1 U400.BU31(DRAM_RESET#)
DDR_PG_CNTL: R551.1 U400.C35(DDR_VTT_CNTL)
DDR_VTT: C2817.1 C2818.1 C2819.1 C2820.1 C2821.1 C2831.1 C2833.1 C2835.1 C2837.1 C2839.1 EC2816.1 EC2817.1 EC2818.1 EC2819.1 EC2820.1 EC2822.1 JDIM2800.258(VTT) JDIM2801.258(VTT) PC8710.1 PR8720.1 PU8700.2(VTTSNS) PU8700.20(VTT)
DDR_VTT_PG_CTRL: PQ8702.2(G) Q403.3(D) R548.2 R550.1 R3306.1
DDR_VTTREF: PC8712.1 PR8706.1
DDSP_1_HPD1: C405.2 Q6100.1(S) R540.1 R6112.1 U400.CM6(GPP_E14/DDPC_HPD1/DISP_MISC1) U5800.32(IN_HPD)
DEV_MODE_DET: TP4700.1 U4701.M2(GPIO56/C\L\K\R\U\N\)
DEVSLP0: R555.1 U400.CP8(GPP_E4/DEVSLP0)
DEVSLP1: R4303.1 U400.CR8(GPP_E5/DEVSLP1)
DEVSLP2: R4301.1 U400.CM8(GPP_E6/DEVSLP2)
DEVSLP2_R: CN4300.38(DEVSLP) R4301.2 R4303.2
DGPU_HOLD_RST#: R558.2 R559.1 U400.CK6(GPP_E9/USB2_OC0#/GP_BSSB_CLK)
DGPU_PRSNT#: R560.2 R561.2 U400.CK5(GPP_E10/USB2_OC1#/GP_BSSB_DI)
DGPU_PWR_EN: R556.2 U400.CK8(GPP_E11/USB2_OC2#)
DIGITAL_CLK: C3613.2 L3401.1 R3607.2
DIGITAL_CLK_L: C3412.1 CN3400.8 L3401.2
DIGITAL_D1: L3402.1 R3606.2
DIGITAL_D1_L: C3411.1 CN3400.7 L3402.2
DPB_DDCCLK: R3512.2 U400.CC8(GPP_E18/DPPB_CTRLCLK/CNV_BT_HOS) U3501.31(SCL_SRC)
DPB_DDCDATA: R3513.2 U400.CC9(GPP_E19/DPPB_CTRLDATA) U3501.32(SDA_SRC)
DPC_DDCCLK: R526.1 U400.CH4(GPP_E20/DPPC_CTRLCLK)
DPC_DDCDATA: R528.1 U400.CH3(GPP_E21/DPPC_CTRLDATA)
DPWROK: PR8122.1 PU8102.4(OUTY) R464.2 U400.BP30(DSW_PWROK) U4701.E7(GPIO00)
DSR: R7501.2 U7500.4(DSR)
EC_PECI: R4714.1 U400.AR1(PECI)
EC_PECI_R: C4723.2 R4714.2 U4701.M7(PECI_DATA/GPIO81)
EC_SLP_LAN#: R4767.2 U4701.D10(GPIOC6/S\M\I\)
EDIDCLK_R: C3419.1 CN3400.20 R3413.2
EDIDDATA_R: C3418.1 CN3400.19 R3412.2
EDP_DISP_UTIL: TP417.1 U400.AM7(DISP_UTILS)
EDP_RCOMP: R543.2 U400.AM6(DISP_RCOMP)
EDRAM_OPIO_RCOMP: TP400.1 U400.L5(OPCE_RCOMP)
EMU_LID: R3402.2 U4701.G2(GPIO66)
EN_1V0A: C3301.1 PR9207.2 R3309.2 R3310.2
EN_1V8: PR9305.1 R3307.2
EN_3V: PR8602.1 R3305.2
EN_5V: PR8628.1 R3304.2
EN_5V_3V: R3300.2 R3304.1 R3305.1 R3307.1 R5404.2 R7500.2 R7508.1 U5401.3(O\T\)
EN_VRPVDDQ: D3300.2 PR8701.1 R3303.1
EN_VRPVTT: PR8703.1 R3306.2
EOPIO_RCOMP: TP402.1 U400.N5(OPC_RCOMP)
EQ: R3507.1 R3508.1 U3501.13(EQ)
ESDIO_RCOMP: R575.1 U400.CK33(SD_1P8_RCOMP) U400.CM34(SD_3P3_RCOMP)
ESPI_ALERT#: CN7701.4 R4721.2 TP4710.1 U4701.L3(SER_IRQ/E\S\P\I\_\A\L\E\R\T\/GP)
ESPI_LPC#: R443.2 R445.1 U400.CG15(GPP_C5/SML0ALERT#)
EXT_PWR_GATE#: R660.1 R3310.1 U400.CC37(GPP_B11/EXT_PWR_GATE#)
EXT_SMI#: R536.1 U400.CP6(GPP_E16/DPPE_HPD3/DISP_MISC3) U4701.J4(GPIO70/PS2_DAT0)
FAN1_PWM: Q5400.5(G) U4701.G8(GPIOC4/PWM2_TACH2PWM_OUT)
FAN1_PWM_Y: C5402.1 CN5400.4 R5401.2
FBVDD_PWROK: R557.2 U400.CK9(GPP_E12/USB2_OC3#)
FN_KEY_LED#: C5025.2 R4760.1 R5003.1 U4701.A10(GPIOD5/JTAG_TCK1_SWCLK1)
FPR_LOCK#: C5207.1 CN5201.6 R5207.1 U400.CN14(GPP_C10/UART0_RTS#)
FPR_OFF: C5207.2 CN5201.7 R463.1 U400.CC36(GPP_B2/VRALERT#)
G_SDO: R5303.2 R5305.1 U5301.3(SDO/SA0)
GC6_FB_EN_Q: R649.1 U400.CN3(GPP_E7/CPU_GP1)
GPD7: R653.1 R654.2 U400.BV35(GPD7)
GPIO40: R4765.1 U4701.E5(GPIO40/TA1_TACH1)
GPP_A11: R495.1 U400.CA32(GPP_A11/PME#/GSPI1_CS1#/SD_VDD2)
GPP_B23: R429.1 U400.CC34(GPP_B23/SML1ALERT#/PCHHOT#)
GPP_D12: TP410.1 U400.CP22(GPP_D12/ISH_SPI_MOSI/GSPI2_MOSI)
GPP_D15: R485.1 U400.CM23(GPP_D15/ISH_UART0_RTS#/GSPI2_CS)
GPP_D19: TP425.1 U400.CP24(GPP_D19/DMIC_CLK0/SNDW4_CLK)
GPP_F1: R519.1 U400.CK19(GPP_F1)
GPP_F2: R520.1 U400.CG17(GPP_F2)
GPP_F4: R471.2 U400.CJ20(GPP_F4/CNV_BRI_DT)
GPP_F6: R470.2 U400.CG19(GPP_F6/CNV_RGI_DT)
GPS_XMIT_OFF#: CN4200.26(GPIO_10) R416.1 U400.CC35(GPP_B4/CPU_GP3)
GPU_EVENT#: R533.2 U400.CR26(GPP_H16/DDPF_CTRLCLK)
H_CPU_SVIDALRT#: R612.1 U400.AA3(VIDALERT#)
H_PRDY#: CN7700.5(OBSFN_A1) U400.W1(PROC_PRDY#)
H_PREQ#: CN7700.3(OBSFN_A0) R7716.2 U400.W2(PROC_PREQ#)
H_PWRGD: R457.2 U400.AR2(PROCPWRGD)
H_TCK: CN7700.57(TCK0) R401.2 R402.1 U400.T6(PROC_TCK)
H_TDI: Q7700.4(S) U400.U6(PROC_TDI)
H_TDO: Q7701.4(S) U400.Y5(PROC_TDO)
H_TMS: Q7700.1(S) U400.T5(PROC_TMS)
H_TRST#: Q7701.1(S) R7729.2 U400.AB6(PROC_TRST#) U400.Y6(PCH_TRST#)
H_VCCST_PWRGD: Q402.3(D) R458.1 R465.2
HD_SDIN0: R3611.2 U3600.7(SDATA-IN)
HDD_HALTLED: C7627.1 CN7601.22 R472.2 R487.1
HDMI_HPD: C3520.1 CN3500.19(HP DET) U3501.25(HPD_SNK) VC3500.1
HDMI_HPD_CON: R539.1 U400.CN6(GPP_E13/DDPB_HPD0/DISP_MISC0) U3501.3(HPD_SRC)
HDMI_UP_CLK: C3518.1 CN3500.15(DDC CLK) R3510.2 U3501.28(SCL_SNK)
HDMI_UP_DATA: C3517.1 CN3500.16(DDC DATA) R3511.2 U3501.29(SDA_SNK)
HOOK2: CN7700.45(HOOK2) R7718.1 R7725.2
HOOK3: C7701.2 CN7700.47(HOOK3) R7727.2 R7728.2
HPOUT_JD: CN3601.6 D3600.1 R3614.2
HPOUT_L: R3602.2 R3609.1
HPOUT_L_C: C3601.2 CN3601.1 D3601.2 R3602.1
HPOUT_L_L: R3609.2 U3600.25(HP-OUT-L)
HPOUT_R: R3601.2 R3608.1
HPOUT_R_C: C3603.2 CN3601.2 D3603.1 R3601.1
HPOUT_R_R: R3608.2 U3600.26(HP-OUT-R)
I2C_C1_CLK: R488.1 R6214.2 U400.CJ12(GPP_C19/I2C1_SCL)
I2C_C1_DATA: R489.1 R6215.2 U400.CK12(GPP_C18/I2C1_SDA)
I2C_CLICK_SCL: C6205.1 CN6200.3 R6214.1
I2C_CLICK_SDA: C6206.1 CN6200.2 R6215.1
I2C_TS_SCL: CN3400.21 R3422.2 U400.CN11(GPP_C17/I2C0_SCL)
I2C_TS_SDA: CN3400.22 R3421.2 U400.CM11(GPP_C16/I2C0_SDA)
I_ADP_ADC0: PR8229.1 R4766.2
I_ADP_ADC0_R: C4726.2 R4766.1 U4701.F2(GPIO45/ADC0)
I_DCHG_ADC1: PR8230.1 R4708.2
I_DCHG_ADC1_R: C4727.2 R4708.1 U4701.E3(GPIO44/ADC1)
I_SET: PQ8501.3(COLLECTOR) PR8211.2
IM_5S_CLK: R4718.2 R6211.1 U4701.C1(GPIO37/PS2_CLK2/ADC5)
IM_5S_DAT: R4717.2 R6212.1 U4701.B2(GPIO34/PS2_DAT2/ADC6)
IMVP_PSYS: PC8223.1 PC8813.2 PR8235.2 PR8846.1 PR8850.2 PU8800.42(PSYS)
IMVP_PSYS_EC: PR8846.2 R4707.1
IN_CLK: C3515.2 U400.AE6(DDI1_TXP_3)
IN_CLK#: C3516.2 U400.AE5(DDI1_TXN_3)
IN_D0: C3513.2 U400.AF5(DDI1_TXP_2)
IN_D0#: C3514.2 U400.AF6(DDI1_TXN_2)
IN_D1: C3511.2 U400.AJ6(DDI1_TXP_1)
IN_D1#: C3512.2 U400.AJ5(DDI1_TXN_1)
IN_D2: C3509.2 U400.AL6(DDI1_TXP_0)
IN_D2#: C3510.2 U400.AL5(DDI1_TXN_0)
INPUT3VSEL: R651.1 U400.BT27(INPUT3VSEL)
INT_BT_OFF#: CN4100.54(W_DISABLE2#) Q4102.3(D) Q4102.6(D) R4104.2
INT_EDP_AUXN: C3418.2 U400.AH4(E\D\P\_\A\U\X\)
INT_EDP_AUXP: C3419.2 U400.AH3(EDP_AUX_P)
INT_EDP_TXN0: C3417.2 U400.AG4(EDP_TXN_0)
INT_EDP_TXN1: C3415.2 U400.AG2(EDP_TXN_1)
INT_EDP_TXP0: C3416.2 U400.AG3(EDP_TXP_0)
INT_EDP_TXP1: C3414.2 U400.AG1(EDP_TXP_1)
INT_RF_OFF#: CN4100.56(W_DISABLE1#) Q4103.3(COLLECTOR) R4107.2
INTLWAKE#: R455.1 U400.BU32(GPD2/LAN_WAKE#)
IOT_I2C_EN_EC: Q4202.3(D) R4249.2 U4202.2(INA)
IOT_I2C_EN_WWAN: Q4201.2(G) Q4201.5(G) Q4202.2(G) U4202.4(OUT Y)
ISH_ACCEL_INT1#: Q7602.6(D) R492.1 U400.BW35(GPP_A18/ISH_GP0)
ISH_ACCEL_INT1#_S: CN7602.8 Q7602.1(S) R7629.2
ISH_ACCEL_INT2#: Q7602.3(D) R493.1 U400.BW34(GPP_A19/ISH_GP1)
ISH_ACCEL_INT2#_S: CN7602.9 Q7602.4(S) R7630.2
ISH_GP6: Q4200.1(S) R494.1 R4242.2 U400.BW37(GPP_A12/ISH_GP6/BM_BUSY#/SX_EXI)
ISH_I2C1_SCL: CN7602.11 R626.1 U400.CJ22(GPP_D8/ISH_I2C1_SCL)
ISH_I2C1_SDA: CN7602.12 R625.1 U400.CH22(GPP_D7/ISH_I2C1_SDA)
ISOLATEB: R4001.2 R4004.2 U4000.20(ISOLATEB)
ITP_PMODE: R604.1 R7723.1 U400.W4(ITP_PMODE)
JTAGX_PCH: R402.2 U400.P6(PCH_JTAGX)
KBC_PWR_ON: PR9513.2 PR9515.2 PR9613.2 R3309.1 R4728.1 U4701.G7(GPIOD2)
KBC_PWR_ON_3: PC9530.1 PR9504.1 PR9513.1
KBL_DET#: CN5001.3 R415.1 U400.CB34(GPP_B3/CPU_GP2)
KSI0: C5015.2 D5000.6 R5016.1(R2) U4701.A2(KSI0/GPIO31/TRACEDATA3)
KSI1: C5016.2 D5000.3 R5016.2(R4) U4701.A3(KSI1/GPIO30/TRACEDATA2)
KSI2: C5017.2 D5001.6 R5016.3(R6) U4701.A4(KSI2/GPIO27/TRACEDATA1)
KSI3: C5018.2 D5001.3 R5016.4(R8) U4701.B3(KSI3/GPIO26/TRACEDATA0)
KSI4: C5019.2 D5002.6 R5016.8(R5) U4701.B4(KSI4/GPIO25/TRACECLK)
KSI5: C5020.2 D5002.3 R5016.7(R7) U4701.C3(KSI5/GPIO24)
KSI6: C5021.2 D5003.6 R5016.6(R9) U4701.C4(KSI6/GPIO23/S_SBUB)
KSI7: C5022.2 CN5000.23 R5016.9(R3) U4701.C5(KSI7/GPIO22/S_SBUA)
KSI_D_0: CN5000.9 D5000.1
KSI_D_1: CN5000.12 D5000.5
KSI_D_2: CN5000.11 D5001.1
KSI_D_3: CN5000.13 D5001.5
KSI_D_4: CN5000.10 D5002.1
KSI_D_5: CN5000.21 D5002.5
KSI_D_6: CN5000.22 D5003.1
KSI_D_8: CN5000.6 D5000.2
KSI_D_9: CN5000.26 D5000.4
KSI_D_10: CN5000.8 D5001.2
KSI_D_11: CN5000.25 D5001.4
KSI_D_12: CN5000.7 D5002.2
KSI_D_13: CN5000.24 D5002.4
KSI_D_14: CN5000.5 D5003.2
KSO0: C5003.2 CN5000.2 CN7701.27 U4701.B5(KSO00/GPIO21/JTAG_TCK0_SWCLK0)
KSO1: C5004.2 CN5000.20 CN7701.26 U4701.B6(KSO01/GPIO20/JTAG_TMS0_SWIO0)
KSO2: C5005.2 CN5000.3 CN7701.24 U4701.B7(KSO02/GPIO17/JTAG_TDI0)
KSO3: C5006.2 CN5000.14 CN7701.25 U4701.B8(KSO03/GPIO16/JTAG_TDO0_SWO0)
KSO4: C5007.2 CN5000.16 U4701.C7(KSO04/GPIO15/XNOR)
KSO5: C5008.2 CN5000.4 U4701.C6(KSO05/GPIO14)
KSO6: C5009.2 CN5000.18 U4701.C8(KSO06/GPIO13)
KSO7: C5010.2 CN5000.17 CN7701.23 R4751.2 U4701.B9(KSO07/GPO12/J\E\N\0\)
KSO8: C5011.2 CN5000.15 U4701.C9(KSO08/GPIO11/CR_SOUT)
