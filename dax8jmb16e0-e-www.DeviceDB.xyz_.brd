# Allegro board dax8jmb16e0-e-www.DeviceDB.xyz_.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_SPI_CS0#_E2: length 4.4
  TOP w0.102: U4701.G11 204.58,55.88 204.58,56.95 204.1,57.43 204.1,58.09 R4757.1
PCH_SPI_CS0#_R1: length 34.4
  TOP w0.102: R5611.2 176.45,77.31 v2(176.16,77.6)
  IN1 w0.127: v2(148.88,70.49) 148.88,70.9 149.27,71.29 150.07,71.29 151.48,72.7 151.49,72.7 151.62,72.83 155.94,72.83 156.45,73.34 160.06,73.34 161.85,75.13 163.9,75.13 164.52,74.5 164.58,74.5 164.96,74.12 167.23,74.12 169.15,76.04 171.05,76.04 171.45,76.43 171.98,76.43 172.81,77.26 175.82,77.26 v2(176.16,77.6)
  BOTTOM w0.102: R433.2 147.97,71.1 148.27,71.1 v2(148.88,70.49)
PCH_SPI_CS0#_R2: length 16.7
  BOTTOM w0.079: 143.09,74.72 v2(142.76,75.05) 142.59,75.22 141.35,75.22 140.99,75.58 140.65,75.58 139.72,76.51 139.61,76.51 138.67,77.45 135.56,77.45 134.07,78.94 U400.CG36
  BOTTOM w0.102: R433.1 146.75,73.11 145.27,73.11 143.69,74.69 143.12,74.69 143.09,74.72
PCH_SPI_IO2: length 9.9
  TOP w0.102: R5612.2 169.62,76.3 R5604.1 R5609.2 R5605.1 171.98,76.38 R7724.2 172.73,76.16 172.55,75.98 v2(172.55,75.32)
  BOTTOM w0.102: U5600.3 175.09,73.03 175.09,73.26 174.91,73.44 174.91,73.85 174.06,74.7 173.62,75.14 173.51,75.14 173.44,75.21 172.65,75.21 v2(172.55,75.32)
PCH_SPI_IO2_R1: length 37
  TOP w0.102: R5609.1 v2(170.72,74.84)
  IN1 w0.127: v2(170.72,74.84) 170.72,74.48 170.37,74.12 169.76,74.12 169.28,73.64 168.56,73.64 167.37,72.45 160.89,72.45 160.64,72.19 157.21,72.19 156.6,71.58 152.15,71.58 151.09,70.52 151.09,69.88 v2(150.83,69.62)
  BOTTOM w0.102: R430.2 139.68,73.96 140.57,73.08 140.83,73.08 141.08,72.83 141.08,72.45 141.58,71.95 v2(141.58,71.66) 141.58,71.53 142.6,70.52 143.42,70.52 144.53,69.4 147.71,69.4 147.82,69.3 149.61,69.3 149.94,69.62 v2(150.83,69.62)
PCH_SPI_IO2_R2: length 11.2
  BOTTOM w0.079: v2(138.87,75.44) 138.56,75.75 138.54,75.75 137.72,76.54 135.13,76.54 133.22,78.46 133.22,79.09 133.14,79.21 133.08,79.27 133.07,79.29 132.99,79.41 132.99,79.66 133.03,79.78 133.07,79.86 133.09,79.88 133.13,80.14 133.13,81.06 U400.CF34
  BOTTOM w0.102: v2(138.87,75.44) 139.57,74.74 R430.1
PCH_SPI_IO3: length 5
  TOP w0.102: R5613.2 176,79.88 177,79.88 R5603.2 ; R5613.2 175.67,79.32 v2(176.15,78.84) ; R5613.2 175.38,79.84 R5610.2
  BOTTOM w0.102: U5600.7 175.83,79.16 v2(176.15,78.84)
PCH_SPI_IO3_R1: length 35.5
  TOP w0.102: v2(171.1,76.81) 171.22,76.93 171.22,77.19 171.56,77.53 171.56,78.17 171.36,78.37 171.36,79 171.45,79.09 172.55,80.19 173.54,80.19 R5610.1
  IN1 w0.127: v2(171.1,76.81) 171.04,76.81 170.65,76.42 168.99,76.42 167.08,74.5 165.8,74.5 164.61,75.69 160.55,75.69 160.23,75.37 160.23,74.83 159.11,73.72 156.19,73.72 155.69,73.21 151.45,73.21 150.33,72.08 149.16,72.08 148.25,71.18 v2(148.25,70.49)
  BOTTOM w0.102: R432.2 146.58,71.83 147.65,70.75 147.99,70.75 v2(148.25,70.49)
PCH_SPI_IO3_R2: length 17.3
  BOTTOM w0.079: 142.5,74.71 142.15,75.06 141.24,75.06 140.91,75.38 140.58,75.38 139.96,76 139.81,76 138.53,77.28 135.5,77.28 133.9,78.87 133.9,79.59 133.81,79.81 133.81,80.02 133.84,80.08 133.84,80.39 133.81,80.45 133.81,80.94 U400.CG34
  BOTTOM w0.102: 142.5,74.71 143.3,73.91 v2(143.35,73.91) 143.97,73.91 145.27,72.61 R432.1
PCH_TCK: length 129.8
  TOP w0.102: CN7700.55 27.26,117.19 24.6,114.53 22.76,114.53 22.03,113.8 22.03,112.34 21.45,111.77 R7735.2 22.03,110.79 22.03,92.27 25.79,88.5 39.49,88.5 42.2,85.79 42.2,82.4 v2(42.33,82.28)
  IN2 w0.114: v1(104.88,99.04) 104.45,98.61 104.45,97.48 103.86,96.89 100.31,96.89 99.78,97.41 99.78,97.82 99.52,98.08 95.09,98.08 95.05,98.04 91.43,98.04 90.79,97.4 80.96,97.4 72.83,89.27 71.08,89.27 68.4,86.59 63.55,86.59 59.22,82.25 57.16,82.25 56.04,81.13 49.87,81.13 49.32,81.69 47.45,81.69 46.9,81.13 44.99,81.13 43.85,82.28 v2(42.33,82.28)
  BOTTOM w0.079: v1(104.88,99.04) 104.7,98.86 U400.W6
PCH_TDI: length 119.4
  TOP w0.102: CN7700.56 27.26,111.72 27.08,111.54 27.08,109.35 26.67,108.94 Q7700.3 26.67,106.75 24.32,104.41 24.32,93.22 26.74,90.8 40.68,90.8 v2(41.61,89.88)
  IN2 w0.114: v2(102.24,108.46) 101.57,108.46 100.73,109.3 95.45,109.3 94.96,109.78 84.64,109.78 78.65,103.8 78.3,103.8 70.18,95.67 68.43,95.67 65.75,92.99 60.9,92.99 57.91,90 57.59,89.68 41.8,89.68 v2(41.61,89.88)
  BOTTOM w0.079: U400.U5 103.52,99.7 103.87,100.06 103.87,100.67 103.89,100.69 103.89,100.87 103.97,100.95 103.97,101.32 104.02,101.37 104.02,101.7 103.99,101.73 103.99,102.01 104.02,102.04 104.02,102.78 104.28,103.04 104.28,103.43 103.92,103.79 103.92,105.13 103.69,105.36
  BOTTOM w0.102: v2(102.24,108.46) 102.63,108.07 R7737.2 103.26,107.62 103.26,107.12 103.49,106.89 103.49,105.56 103.69,105.36
PCH_TDO: length 121.4
  TOP w0.102: v2(29.3,106.92) 29.3,106.91 29.3,107.09 29.5,107.29 29.5,108.45 28.95,108.99 27.88,108.99 27.65,109.21 Q7701.3 27.65,111.27 27.92,111.53 28.13,111.53 28.26,111.67 CN7700.52
  IN2 w0.079: 103.43,98.75 103.43,98.77
  IN2 w0.114: 103.43,98.75 103.43,98.34 103.2,98.11 101.82,98.11 101.71,98.23 101.71,98.43 100.32,99.81 96.21,99.81 95.53,99.14 91.91,99.14 90.63,97.85 80.77,97.85 72.64,89.72 70.89,89.72 68.21,87.04 63.37,87.04 59.03,82.71 56.97,82.71 55.85,81.59 50.06,81.59 49.48,82.17 46.79,82.17 46.4,81.77 45.52,81.77 44.36,82.94 35.61,82.94 28.33,90.21 28.33,95.02 29.24,95.92 29.24,106.85 v2(29.3,106.92) ; 103.43,98.77 103.56,98.9 103.56,99.34 103.86,99.65 v1(103.98,99.65)
  BOTTOM w0.079: R7738.2 104.3,105.54 104.3,103.94 104.78,103.46 104.78,102.5 104.62,102.34 104.62,100.19 104.3,99.87 104.21,99.87 v1(103.98,99.65)
  BOTTOM w0.102: v1(103.98,99.65) 104.12,99.51 U400.W5
PCH_TMS: length 120.6
  TOP w0.102: v2(45.44,82.71) 44.99,83.16 44.06,84.09 44.06,86.56 40.25,90.37 26.56,90.37 23.89,93.04 23.89,107.93 25.37,109.4 Q7700.6 25.37,111.22 25.63,111.48 26.64,111.48 26.76,111.61 CN7700.58
  IN2 w0.114: v2(102.46,105.38) 102.46,102.07 102.3,101.91 102.3,99.99 v1(102.14,99.84) 101.11,99.84 100.69,100.26 98.61,100.26 98.17,100.7 95.8,100.7 95.42,100.32 91.69,100.32 90.87,99.5 85.73,99.5 84.55,98.31 80.58,98.31 72.45,90.18 70.7,90.18 68.02,87.5 63.18,87.5 58.84,83.16 56.78,83.16 56.16,82.54 52.75,82.54 52.59,82.71 v2(45.44,82.71)
  BOTTOM w0.079: 102.06,99.75 101.81,99.51 U400.P5
  BOTTOM w0.102: 102.06,99.75 v1(102.14,99.84) ; R7736.2 102.42,105.38 v2(102.46,105.38)
PCH_WAKE#: length 109.7
  TOP w0.102: R462.2 132.57,73.5 132.57,72.4 132.42,72.24 131.52,72.24 R456.2 132.52,71.01 132.52,70.11 132.24,69.84 132.24,68.74 134.46,66.52 134.94,66.52 135.89,65.58 145.79,65.58 146.65,66.43 148.33,66.43 149.25,67.36 152.84,67.36 154.14,66.06 159.63,66.06 160.02,66.45 161.29,66.45 v2(161.7,66.85) ; v2(175.86,88.36) 175.39,88.36 R4105.2 175.18,89.1 174.95,89.33 174.95,90.49 175.42,90.96 Q4104.3 ; R4212.2 R4006.1 189.06,73.85 188.77,74.14 v2(188.46,74.14) 187.92,74.14 187.76,74.3 Q4001.3
  IN2 w0.114: v2(188.46,74.14) 188.17,74.43 188.17,75.93 188.84,76.61 188.84,80.73 188.38,81.19 188.38,82.19 186.47,84.1 186.47,84.58 184.86,86.19 184.86,86.68 184.12,87.42 182.69,87.42 180.62,89.49 179.26,89.49 178.13,88.36 v2(175.86,88.36) ; v2(161.7,66.85) 161.91,67.06 168.66,67.06 168.95,66.76 171.57,66.76 172.61,65.72 177.05,65.72 v2(177.1,65.67)
  BOTTOM w0.102: v2(188.46,74.14) 188.14,74.45 188.14,74.53 188.01,74.66 186.69,74.66 186.13,74.1 186.13,73.79 185.69,73.35 185.69,71.93 v2(185.67,71.91) 185.33,71.56 185.33,66.88 182.69,64.24 177.74,64.24 177.1,64.88 v2(177.1,65.67)
PCH_WAKE#_C: length 5.4
  TOP w0.102: v2(192.27,72.44) 192.04,72.21 R4212.1
  BOTTOM w0.102: CN4200.23 193.95,71.62 193.76,71.43 193.23,71.43 193.18,71.49 192.91,71.49 192.27,72.13 v2(192.27,72.44)
PCH_WAKE#_R: length 12.4
  TOP w0.079: 130.56,81.34 130.56,81.55 130.32,81.79 130.32,82.37 130.07,82.62 130.07,83.02 v1(129.62,83.47)
  TOP w0.102: 130.56,81.34 130.56,80.85 129.57,79.86 129.57,78.79 132.32,76.05 v2(132.32,75.65) R462.1
  BOTTOM w0.079: U400.BU30 128.67,83.87 128.99,83.55 129.55,83.55 v1(129.62,83.47)
PCH_WLAN_RST#: length 18.1
  TOP w0.079: v1(135.17,94.77) 135.59,95.19 136.04,95.19 136.14,95.29 136.57,95.29 136.77,95.5
  TOP w0.102: R478.2 149.76,97.64 149.21,97.64 148.99,97.86 v2(148.51,97.86) 148.11,97.86 147.9,97.64 146.23,97.64 145.85,98.03 141.9,98.03 141.45,98.48 138.8,98.48 138.29,97.97 138.29,97.02 136.77,95.5
  BOTTOM w0.079: U400.CH12 135.05,95.07 135.17,94.95 v1(135.17,94.77)
PCI_PLTRST#: length 255.4
  TOP w0.102: U4201.1 195.69,77.64 195.56,77.77 R4215.1 194.79,77.77 194.37,77.35 192.74,77.35 v2(192.39,77.7) ; Q4701.2 185.86,55.76 185.33,55.76 185,55.43 184.01,55.43 183.62,55.81 182.61,55.81 182.18,55.38 v2(182.18,54.35) ; U4000.19 192.36,67.71 191.88,68.19 191.88,68.61 v2(191.61,68.88) ; U402.4 128.34,60.12 R467.2 127.39,61.16 R469.2 126.32,62.23 126.32,63.08 126.82,63.58 127.62,63.58 127.99,63.95 128.04,63.95 128.25,64.17 133.2,64.17 134.11,63.25 148.86,63.25 149.74,64.13 155.88,64.13 156.17,64.42 168.13,64.42 168.35,64.63 169.19,64.63 169.58,64.24 170.01,64.24 170.34,64.57 173.12,64.57 v2(173.27,64.72) 173.16,64.72 172.07,65.81 172.07,66.23 R5103.2 171.75,66.41 171.43,66.1 170.54,66.1 170.42,66.22 170.42,66.6 170.04,66.99 Q5100.2
  IN1 w0.114: v2(186.32,19.63) 186.16,19.47 186.16,19.11 186.79,18.48 192.05,18.48 195.56,22 195.56,22.28 196.83,23.55 196.83,24.95 197.59,25.7 197.59,35.76 196.48,36.86 196.48,38.2 197.06,38.78 197.06,40.54 196.81,40.78 196.81,43.26 195.51,44.56 193.16,46.91 192.56,47.52 191.76,48.32 189.55,48.32 188.43,49.43 188.28,49.43 187.2,50.51 186.32,50.51 182.48,54.35 v2(182.18,54.35) 182.18,54.71 179.27,57.62 178.09,57.62 172.76,62.95 172.76,64.07 173.27,64.58 v2(173.27,64.72) 173.27,64.9 175.88,67.51 175.88,69.81 175.6,70.09 175.6,71.66 176.13,72.19 177.15,72.19 177.86,72.9 177.86,77.13 178.37,77.64 178.37,78.69 176.76,80.3 173.89,80.3 172.23,81.96 172.23,85.2 171.13,86.3 170.76,86.3 v2(170.34,86.72)
  IN2 w0.114: v2(191.61,68.88) 191.61,69.15 191.01,69.75 191.01,70.5 191.27,70.76 191.95,70.76 192.89,71.71 192.89,77.2 v2(192.39,77.7) 191.22,78.87 191.22,83.67 190.5,84.4 190.5,85.58 189.06,87.03 189.06,88.75 184,93.81 178.17,93.81 176.52,92.16 173.47,92.16 v2(173.07,91.76)
  BOTTOM w0.102: v2(170.34,86.72) 170.36,86.74 170.36,88.42 171.5,89.55 173.3,89.55 173.45,89.7 CN4100.52 173.45,91.37 v2(173.07,91.76) 173.07,91.86 173.28,92.07 174.02,92.07 C4106.2 ; CN4300.50 207.18,17.59 207.29,17.7 207.29,19.77 207.17,19.89 205.31,19.89 205.21,19.79 205.21,19.45 202.14,16.38 202.14,14.91 200.58,13.35 198.72,13.35 198.14,13.93 194.96,13.93 192.05,16.84 189.26,16.84 188.71,16.29 187.52,16.29 186.04,17.77 186.04,19.23 186.32,19.51 v2(186.32,19.63)
PCI_PLTRST#_R: length 8.3
  TOP w0.102: v2(200.08,81.09) 200.08,80.65 199.02,79.59 R4240.2 197.75,79.59 197.48,79.32 U4201.4 197.48,78.68 197.35,78.55 R4215.2
  BOTTOM w0.102: v2(200.08,81.09) 200.38,81.09 200.7,80.77 CN4200.50
PCIE_CLKREQ5#: length 88.1
  TOP w0.079: v1(134.22,83.34) 134.63,83.74 134.63,83.76 134.98,84.11 135.34,84.11 135.64,83.81 137.05,83.81 137.3,83.55
  TOP w0.102: v2(157.24,76.21) 157.21,76.24 157.21,79.43 156.95,79.69 155.46,79.69 R593.1 155.39,79.67 153.21,79.67 153.07,79.53 150.93,79.53 149.66,80.8 148.96,81.5 147.23,81.5 147.03,81.3 144.11,81.3 143.52,80.71 139.84,80.71 139.59,80.96 139.16,80.96 138.91,81.21 138.63,81.21 137.46,82.38 137.46,83.4 137.3,83.55 ; v2(194.19,76.7) C4238.1
  IN2 w0.127: v2(157.24,76.21) 157.3,76.27 165.39,76.27 165.88,75.77 166.33,75.77 166.59,76.04 166.59,76.21 167.13,76.74 170.42,76.74 171.24,77.56 171.24,78.09 171.1,78.24 171.1,78.99 171.93,79.83 173.42,79.83 173.55,79.7 174.14,79.7 174.51,80.06 178.11,80.06 178.68,79.49 179.54,79.49 179.62,79.57 180.45,79.57 181.76,78.26 181.76,74.13 183.52,72.37 v2(183.52,72.34)
  BOTTOM w0.102: v2(183.52,72.34) 183.52,72.65 186.88,76.01 188.38,76.01 189.06,76.69 194.18,76.69 v2(194.19,76.7) 195.76,78.26 200.16,78.26 200.69,78.8 201.02,78.8 201.2,78.97 CN4200.52 ; v1(134.22,83.34) 133.88,83.34 U400.CF31
PCIE_CLKREQ_LAN#: length 89
  TOP w0.079: 137.24,83.9 137.11,84.03 135.77,84.03 135.39,84.41 134.5,84.41 v1(134.22,84.13)
  TOP w0.102: C4035.1 195.28,70.99 v2(195.28,70.19) 195.13,70.03 U4000.12 ; R595.1 152.84,80.14 v2(152.71,80.02) 151.8,80.02 150.34,81.48 150.18,81.63 149.81,81.63 149.45,81.99 146.76,81.99 146.56,81.79 143.91,81.79 143.32,81.2 140.04,81.2 139.79,81.44 139.36,81.44 139.21,81.59 138.76,81.59 137.71,82.65 137.71,83.43 137.24,83.9
  IN1 w0.127: v2(166.43,80.98) 165.72,80.98 165.57,81.13 163.23,81.13 162.52,80.42 161.5,80.42 161.18,80.74 159.28,80.74 158.45,81.56 156.56,81.56 155.5,80.51 153.66,80.51 153.17,80.02 v2(152.71,80.02)
  BOTTOM w0.079: U400.CF30 134.03,84.13 v1(134.22,84.13)
  BOTTOM w0.102: v2(195.28,70.19) 195.28,69.81 194.78,69.3 193.36,69.3 192.62,70.04 192.17,70.04 191.75,69.63 191.47,69.63 190.79,68.94 190.79,68.46 190.41,68.08 188.35,68.08 187.79,67.52 186.62,67.52 182.94,63.84 177.57,63.84 176.7,64.71 176.7,66.59 176.73,66.63 176.73,70.13 178.02,71.41 178.02,73.45 176.49,74.98 176.49,75.69 176.69,75.89 176.69,76.4 176.33,76.76 175,76.76 174.58,77.17 174.08,77.17 173.72,76.81 173.1,76.81 170.32,79.59 169.99,79.59 169.25,80.33 167.78,80.33 167.45,80.66 166.75,80.66 v2(166.43,80.98)
PCIE_CLKREQ_SSD#: length 172
  TOP w0.079: 137.2,83.04 137.2,83.39 136.97,83.63 135.84,83.63 v1(135.19,82.98)
  TOP w0.102: 137.2,83.04 137.2,82.29 138.54,80.96 138.89,80.96 139.08,80.76 139.46,80.76 139.7,80.52 143.6,80.52 144.09,81.01 148.77,81.01 150.73,79.05 153.35,79.05 v2(153.48,79.17) 153.6,79.05 R597.1
  IN1 w0.127: v2(185.7,19.75) 186.06,20.12 186.55,20.12 186.77,19.89 186.77,19.26 187.05,18.99 191.64,18.99 192.51,19.85 192.71,19.85 195.05,22.2 195.05,24.11 196.98,26.03 196.98,30.58 196.1,31.47 196.1,36.19 195.98,36.31 195.98,38.41 196.55,38.99 196.55,40.33 196.31,40.57 196.31,43.06 191.55,47.82 189.34,47.82 188.22,48.93 188.07,48.93 186.99,50.01 186.11,50.01 182.87,53.25 182.5,53.25 181.59,54.16 181.59,54.54 179.01,57.12 177.88,57.12 172.26,62.74 172.26,64.94 172.17,65.03 172.17,66.55 173.08,67.47 174.14,67.47 175.09,68.41 175.09,69.57 174.12,70.55 174.12,71.75 174.69,72.32 175.17,72.32 175.93,73.08 176.69,73.08 176.95,73.34 176.95,74.49 176.38,75.06 176.38,75.62 176.67,75.91 176.67,79.04 176.41,79.29 173.45,79.29 171.24,81.51 171.24,84.78 170.72,85.3 170.12,85.3 169.09,84.27 168.27,84.27 167.04,83.04 167.04,80.94 166.65,80.55 165.54,80.55 165.39,80.7 163.41,80.7 162.7,79.99 161.27,79.99 160.97,80.29 157.68,80.29 157.11,79.72 155.52,79.72 155.44,79.65 153.95,79.65 v2(153.48,79.17)
  BOTTOM w0.079: v1(135.19,82.98) 135.09,82.88 134.08,82.88 U400.CF32
  BOTTOM w0.102: v2(185.7,19.75) 185.4,19.46 185.4,17.55 187.27,15.68 188.96,15.68 189.51,16.23 191.8,16.23 194.71,13.32 197.89,13.32 198.47,12.74 200.84,12.74 202.78,14.68 202.78,16.16 203.86,17.23 C4318.2 204.28,17.62 204.95,18.29 205.32,18.29 205.53,18.09 CN4300.52
PCIE_CLKREQ_WLAN#: length 72.1
  TOP w0.079: v1(133.3,82.88) 133.3,82.87 133.79,82.38 133.79,81.46 135.52,79.74 135.52,78.96 137.02,77.46
  TOP w0.102: R4103.2 182.29,86.67 181.34,86.67 181.19,86.52 181.19,86.16 180.42,85.4 180.42,84.93 179.79,84.3 175.23,84.3 174.64,83.71 172.05,83.71 Q4101.1 171.15,82.81 171.15,82.5 167.04,78.39 161.96,78.39 159.09,75.52 159.09,75.24 155.68,71.84 146.08,71.84 145.4,71.16 145.4,69.05 144.94,68.59 142.67,68.59 v2(141.96,67.88) 140.08,67.88 139.78,68.18 139.78,68.66 140.85,69.72 R594.1 140.98,70.57 139.54,72.01 139.54,74.94 137.02,77.46
  BOTTOM w0.079: v1(133.3,82.88) 133.2,82.88 U400.CE31
PCIE_RCOMPN: length 21.5
  TOP w0.254: 134.34,100.42 134.26,100.35 133.99,100.08 133.99,99.5 133.61,99.12 v1(133.56,99.12)
  TOP w0.305: 134.34,100.42 134.45,100.54 136.96,100.54 138.94,102.51 140.72,102.51 141.92,103.71 141.92,104.21 142.75,105.04 142.75,107.41 142.75,107.54 145.28,110.08 R567.2 v2(146.09,111.82)
  BOTTOM w0.254: U400.CE6 133.29,98.86 133.56,99.12 v1(133.56,99.12)
PCIE_RCOMPP: length 21.5
  TOP w0.305: v1(133.54,99.71) 133.56,99.73 133.56,100.72 134.04,101.2 135.31,101.2 135.74,101.63 136.14,101.63 136.27,101.49 136.27,101.31 136.38,101.2 136.76,101.2 138.69,103.12 140.47,103.12 141.3,103.96 141.3,104.46 142.14,105.3 142.14,107.16 142.14,107.16 142.14,107.8 144.67,110.33 144.67,111.65 R567.1 v2(144.5,112.64)
  BOTTOM w0.254: v1(133.54,99.71) 133.47,99.71 133.35,99.83 133.21,99.83 133.08,99.7 U400.CE5
PCIE_RXN5_LAN: length 91.4
  TOP w0.097: v2(189.06,71.16) 189.21,71 189.21,70.8 C4002.2
  IN2 w0.102: v1(127.12,99.8) 127.3,99.62 127.58,99.62 129.7,97.5 129.7,96.98 130.41,96.27 132.21,96.27 133.42,95.06 133.98,95.06 134.28,95.36 138.17,95.36 138.87,94.65 138.87,93.38 139.47,92.78 139.49,92.78
  IN2 w0.114: v2(189.06,71.16) 189.23,70.98 189.23,70.68 189.54,70.36 190.17,70.36 190.53,70.73 190.53,72.19 189.24,73.47 189.24,75.99 189.57,76.31 189.57,81.03 189.11,81.49 189.11,82.49 187.19,84.4 187.19,84.89 185.61,86.47 185.61,87.04 183.66,88.99 182.21,88.99 180.82,90.38 180.61,90.38 179.93,91.06 179.34,91.06 178.49,90.2 177.96,90.2 177.6,89.84 174.65,89.84 174.4,89.59 171.28,89.59 170.55,88.85 167.99,88.85 167.79,89.06 166.15,89.06 165.37,88.28 163.17,88.28 163.06,88.39 161.58,88.39 160.37,87.18 159.52,87.18 158.62,88.08 158.39,88.08 156.47,90 154.97,90 154.06,90.91 150.56,90.91 149.74,91.72 148.21,91.72 147.17,92.77 145.86,92.77 145.08,91.99 142.26,91.99 141.58,92.66 139.61,92.66 139.49,92.78
  BOTTOM w0.079: U400.BP5 126.83,99.51 v1(127.12,99.8)
PCIE_RXN5_LAN_L: length 5.2
  TOP w0.097: U4000.18 192.32,68.11 192.08,68.35 192.08,68.99 191.7,69.38 190.92,69.38 190.7,69.16 189.35,69.16 189.14,69.37 189.14,69.54 C4002.1
PCIE_RXN6_WLAN: length 57.5
  IN2 w0.102: v1(126.15,98.96) 126.44,98.96 127.1,98.3 127.61,98.3 128.76,97.15 128.76,96.75 130.63,94.87 132.66,94.87 133.29,94.24 134.07,94.24 134.16,94.16 136.97,94.16 138.64,92.49 138.64,91.8 139.15,91.29 139.64,91.29
  IN2 w0.114: 139.64,91.29 139.77,91.17 140.95,91.17 141.13,91.34 141.66,91.34 141.9,91.11 145.66,91.11 145.97,90.8 147.26,90.8 147.65,90.41 149.81,90.41 150.62,89.6 153.05,89.6 153.35,89.9 153.76,89.9 154.65,89.01 156.2,89.01 158.03,87.18 158.28,87.18 159.17,86.29 160.73,86.29 161.42,86.97 162.07,86.97 162.26,87.17 163.65,87.17 164.12,86.7 164.78,86.7 165.27,87.19 165.68,87.19 166.44,87.95 167.28,87.95 167.41,87.83 v2(167.41,87.6)
  BOTTOM w0.079: v1(126.15,98.96) 126.15,99.14 126.04,99.24 125.79,99.24 125.69,99.14 U400.BN6
  BOTTOM w0.097: v2(167.41,87.6) 167.23,87.6 167.14,87.51 167.14,86.71 167.64,86.21 167.64,86.02 168.18,85.48 169.2,85.48 169.6,85.07 169.6,84.64 170.14,84.1 170.56,84.1 170.78,83.88 171.03,83.88 171.2,83.7 CN4100.43
PCIE_RXN8_SSD: length 171.4
  TOP w0.097: C4301.2 210.75,16.85 210.87,16.74 211,16.74 211.37,17.11 v2(211.37,17.28)
  IN2 w0.102: v1(125.26,98.51) 125.48,98.51 125.56,98.42 125.56,98.1 125.33,97.87 125.33,96.75 127.16,94.92 127.16,93.78 127.69,93.25 132.31,93.25 133.5,92.05 136.25,92.05 136.6,91.7 137.01,91.7 138.89,89.82 139.39,89.82 139.85,89.36 140.34,89.36 140.79,88.91 140.94,88.91 140.94,88.9 141,88.9 141.02,88.88 141.03,88.88
  IN2 w0.114: 141.03,88.88 146.98,88.88 147.51,88.35 149.72,88.35 149.95,88.12 152.01,88.12 153.05,87.08 156.05,87.08 157.05,86.08 157.05,85.8 158.03,84.82 162.09,84.82 162.51,85.24 168.03,85.24 168.22,85.43 168.98,85.43 169.57,86.02 170.64,86.02 171.21,86.59 171.78,86.59 172.49,87.31 173.31,87.31 173.56,87.56 174.35,87.56 175.07,86.85 177.49,86.85 178.01,86.32 178.01,85.89 179.09,84.82 180.68,84.82 182.96,82.53 183.37,82.53 185.17,80.73 185.17,76.97 186.7,75.44 186.7,69.29 187.81,68.18 189.82,68.18 191.01,66.99 192.28,66.99 193.72,68.43 195.62,68.43 196.58,67.48 196.58,67.11 198.69,65 201,65 201.94,64.06 202.46,64.06 203.06,63.46 203.06,62.95 204.31,61.7 207.47,61.7 209.15,60.02 209.15,59.65 210.34,58.46 210.71,58.46 211.56,57.61 212.79,57.61 213.2,57.21 213.86,57.21 215.86,55.21 215.86,54.69 215.3,54.13 215.3,47.86 217.39,45.76 217.39,37.79 220.02,35.16 220.02,30.23 219.52,29.72 219.52,28.89 219.18,28.56 219.18,27 216.37,24.18 216.37,23.22 215.15,22 211.44,22 210.07,20.63 210.07,19.65 211.82,17.89 211.82,16.99 211.75,16.92 211.51,16.92 211.37,17.07 v2(211.37,17.28)
  BOTTOM w0.079: U400.BL6 124.91,98.86 v1(125.26,98.51)
PCIE_RXN9_SSD: length 182.8
  IN2 w0.102: v1(124.29,98.99) 124.52,98.99 124.67,98.84 124.67,98.04 124.8,97.91 124.8,96.57 125.92,95.45 125.92,93.62 126.67,92.87 127.23,92.87 127.48,92.61 131.53,92.61 131.71,92.43 131.71,92.02 132.08,91.65 132.56,91.65 133.14,91.06 136.53,91.06 137.13,90.47 137.38,90.47 138.78,89.07 138.98,89.07 139.41,88.64 140.12,88.64 140.51,88.24 140.94,88.24 140.94,88.24 141,88.24 141.02,88.22 141.03,88.22
  IN2 w0.114: 141.03,88.22 146.67,88.22 147.25,87.64 149.47,87.64 149.65,87.46 151.75,87.46 152,87.2 152,87.16 152.75,86.42 155.63,86.42 156.4,85.65 156.4,84.92 157.16,84.16 159.76,84.16 160.17,83.74 162.01,83.74 162.3,84.02 164.35,84.02 164.9,84.57 167.42,84.57 167.78,84.21 168.99,84.21 169.93,85.15 171.51,85.15 172.26,85.89 173.61,85.89 174.16,85.35 177.33,85.35 178.51,84.17 180.39,84.17 182.23,82.33 182.23,82.01 182.83,81.41 183.28,81.41 184.49,80.2 184.49,76.51 186.01,74.99 186.01,68.41 186.95,67.47 189.61,67.47 190.98,66.1 192.55,66.1 193.25,65.4 197.35,65.4 198.43,64.32 200.67,64.32 202.35,62.64 202.44,62.64 204.03,61.05 207.2,61.05 208.5,59.75 208.5,59.38 210.07,57.81 210.44,57.81 211.29,56.96 212.52,56.96 213.78,55.71 213.78,55.51 213.98,55.31 213.98,54.51 214.59,53.9 214.59,46.72 216.75,44.56 216.75,37.38 219.36,34.76 219.36,30.48 218.87,29.99 218.87,29.29 218.46,28.88 218.46,27.19 215.72,24.45 215.72,23.58 215.13,22.99 213.74,22.99 213.39,23.35 211.87,23.35 208.07,19.55 208.07,15.67 207.98,15.58 207.98,12.97 207.79,12.79 207.79,11.82 v2(207.49,11.52)
  BOTTOM w0.079: v1(124.29,98.99) 124.29,99.06 124.14,99.22 123.96,99.22 123.84,99.1 U400.BK6
  BOTTOM w0.097: CN4300.5 212.87,6.34 212.8,6.41 212.2,6.41 211.87,6.73 211.72,6.73 209.29,9.16 208.71,9.16 207.88,9.99 207.88,11.14 207.62,11.39 v2(207.49,11.52)
PCIE_RXN10_SSD: length 178.6
  IN2 w0.102: 141.03,87.57 140.99,87.53 140.98,87.53 140.93,87.48 139.26,87.48 137.51,89.24 136.94,89.24 136.13,90.05 133.16,90.05 132.06,91.14 131.27,91.14 130.89,91.52 126.37,91.52 125.58,92.31 125.45,92.31 124.82,92.94 124.82,95.88 124.11,96.59 124.11,96.8 123.69,97.22 123.69,98.14 123.63,98.2 123.63,98.58 123.53,98.69 v1(123.38,98.69)
  IN2 w0.114: 141.03,87.57 143.26,87.57 143.83,87 144.98,87 145.23,87.25 146.54,87.25 146.82,86.97 148.76,86.97 149.55,86.19 151.7,86.19 152.14,85.76 154.54,85.76 156.85,83.44 159.45,83.44 159.81,83.09 162.3,83.09 162.58,83.37 169.24,83.37 169.65,83.77 171.35,83.77 172.16,84.59 176.95,84.59 178.04,83.5 179.84,83.5 181.42,81.92 181.42,81.23 183.83,78.82 183.83,74.68 185.35,73.16 185.35,68.15 187.38,66.12 188.63,66.12 188.91,66.4 189.68,66.4 190.85,65.23 191.62,65.23 192.97,64.72 195.96,64.72 197.53,63.99 197.55,63.98 197.89,63.78 198.24,63.59 199.65,63.59 201.31,61.93 202.23,61.93 202.25,61.91 203.76,60.4 206.93,60.4 207.83,59.5 207.83,59.13 209.8,57.16 210.17,57.16 211.02,56.32 212.21,56.32 212.69,55.83 212.69,54.58 213.04,54.22 213.04,51.47 213.17,51.35 213.17,47.17 216.1,44.24 216.1,37.11 218.12,35.09 218.12,30.68 217.79,30.35 217.79,27.43 214.41,24.06 211.67,24.06 207.17,19.56 207.17,18.11 206.66,17.59 206.66,14.55 206.94,14.26 207.18,14.26 207.48,13.96 v2(207.49,13.95)
  BOTTOM w0.079: v1(123.38,98.69) 123.38,98.84 123.12,99.09 123,99.09 122.92,99.01 U400.BJ6
  BOTTOM w0.097: v2(207.49,13.95) 207.48,13.96 207.75,14.24 208.09,14.24 208.53,13.81 208.53,13.05 210.22,11.35 210.22,10.38 211.27,9.33 212.47,9.33 212.6,9.45 212.89,9.45 213,9.34 CN4300.17
PCIE_RXN10_WWAN: length 105.5
  TOP w0.097: v2(187.78,71.18) 187.78,70.85 v2(188.1,70.53)
  IN1 w0.079: v1(130.76,98.4) 130.58,98.58 130.46,98.58 130.4,98.52 130.4,98.14 130.11,97.85 130.11,97.82
  IN1 w0.102: 139.86,94.49 138.97,94.49 138.11,95.36 134.34,95.36 134.22,95.23 131.1,95.23 129.82,96.51 129.82,97.53 130.11,97.82
  IN1 w0.114: 139.86,94.49 140.25,94.49 140.5,94.75 142.37,94.75 143.24,93.88 143.55,93.88 144.08,93.35 144.08,93.09 144.48,92.69 145.25,92.69 145.68,93.12 149.74,93.12 150.3,92.56 150.3,92.2 150.85,91.65 151.27,91.65 151.68,92.05 153.54,92.05 153.9,91.7 155.51,91.7 156.19,92.38 156.19,93.22 156.66,93.68 158.27,93.68 158.44,93.51 160.57,93.51 161.28,94.21 161.56,94.21 162.25,94.91 162.75,94.91 163.55,95.7 165.71,95.7 166.2,95.2 166.91,95.2 167.41,95.7 172.34,95.7 172.63,95.99 173.99,95.99 174.35,95.64 178.41,95.64 179.35,94.69 182.78,94.69 188.12,89.35 188.12,82.6 188.35,82.37 188.35,79.53 188.98,78.9 188.98,76.64 188.59,76.25 187.74,75.4 187.56,75.22 187.56,70.41 187.66,70.31 187.87,70.31 v2(188.1,70.53)
  BOTTOM w0.079: v1(130.76,98.4) 130.76,98.56 130.64,98.68 130.53,98.68 130.31,98.46 U400.BY7
  BOTTOM w0.097: v2(188.1,70.53) 188.31,70.32 189.56,70.32 190.25,71.01 191.01,71.01 191.17,70.86 192.94,70.86 193.69,70.1 194.29,70.1 194.48,70.29 194.48,70.68 195.07,71.28 196.02,71.28 196.32,70.98 198.31,70.98 198.45,71.12 CN4200.41
PCIE_RXN11_SSD: length 178.1
  TOP w0.097: R4308.2 209.69,12.32 206.66,12.32 206.14,12.85 205.27,12.85 v2(205.08,12.65)
  IN2 w0.102: 140.82,86.42 140.81,86.42 140.79,86.4 140.67,86.4 139.89,87.17 138.9,87.17 137.3,88.78 136.67,88.78 136.31,89.13 133.72,89.13 132.68,90.18 131.61,90.18 130.6,91.19 126.12,91.19 126.01,91.3 125.28,91.3 124.34,92.23 124.34,93.93 123.81,94.47 123.33,94.47 122.79,95 122.79,98.42 122.81,98.44 122.81,98.84 v1(122.43,99.22)
  IN2 w0.114: v2(205.08,12.65) 205.29,12.86 205.57,12.86 206.08,13.37 206.08,18.33 206.45,18.69 206.45,20.34 208.54,22.43 209.44,22.43 211.55,24.53 214.2,24.53 217.36,27.68 217.36,30.51 217.69,30.84 217.69,31.5 217.09,32.1 217.09,34.92 215.68,36.33 215.68,43.71 214.1,45.29 213.8,45.29 213.06,46.03 213.06,46.48 212.04,47.5 212.04,53.66 211.44,54.26 211.44,55.3 210.2,56.54 210,56.74 209.63,56.74 207.41,58.96 207.41,59.33 207.3,59.45 206.76,59.98 203.59,59.98 202.05,61.51 200.99,61.51 199.47,63.02 198.44,63.02 197.81,62.39 197.29,62.39 196.84,62.84 194.36,62.84 193.96,62.44 192.87,62.44 190.5,64.81 189.2,64.81 188.62,65.38 187.05,65.38 184.92,67.51 184.92,72.97 183.27,74.62 183.27,78.76 180.91,81.13 180.91,81.81 179.73,82.99 177.86,82.99 176.79,84.05 172.32,84.05 171.59,83.32 169.88,83.32 169.5,82.94 162.81,82.94 162.5,82.63 159.59,82.63 159.23,82.99 156.69,82.99 154.48,85.2 151.37,85.2 151.04,85.53 149.61,85.53 148.65,86.49 146.7,86.49 145.97,85.76 144.99,85.76 144.33,86.42 140.82,86.42
  BOTTOM w0.079: v1(122.43,99.22) 122.14,99.51 U400.BG5
PCIE_RXN11_SSD_C: length 3.7
  TOP w0.097: v2(211.36,12.16) 211.06,12.46 210.91,12.46 210.75,12.3 R4308.1
  BOTTOM w0.097: v2(211.36,12.16) 211.68,12.49 212.73,12.49 212.88,12.34 CN4300.29
PCIE_RXN12_SSD: length 171.3
  TOP w0.097: R4304.2 207.92,17.11 207.75,16.94 207.17,16.94 v2(206.62,17.49) 206.07,16.95 205.7,16.95 205.57,16.82 205.37,16.82 v2(205.04,17.15)
  IN2 w0.102: 140.36,85.82 140.34,85.84 140.32,85.84 140.29,85.87 140.28,85.87 140.04,86.11 139.73,86.42 138.67,86.42 136.91,88.17 136.41,88.17 135.93,88.65 133.47,88.65 132.49,89.63 131.37,89.63 130.88,90.12 125.2,90.12 123.05,92.28 123.05,93.86 122.13,94.77 122.13,98.29 122.05,98.37 122.05,98.69 v1(121.52,99.22)
  IN2 w0.114: v2(205.04,17.15) 205.04,16.96 204.93,16.84 204.64,16.84 204.47,17.02 204.47,17.86 205.52,18.91 205.52,20.33 208.27,23.08 209.18,23.08 211.37,25.27 214.02,25.27 216.67,27.91 216.67,30.97 216.58,31.06 216.58,31.67 216.44,31.81 216.44,34.57 215.03,35.98 215.03,43.32 214.13,44.23 213.9,44.23 212.36,45.77 212.36,46 211.3,47.05 211.3,53.1 210.79,53.61 210.79,55.03 210.56,55.27 210,55.82 209.73,56.09 209.36,56.09 206.76,58.69 206.76,58.96 206.39,59.33 203.11,59.33 201.58,60.86 200.13,60.86 199.98,60.71 198.15,60.71 197.46,61.4 196.73,61.4 196.64,61.49 192.88,61.49 190.28,64.09 188.37,64.09 187.86,64.6 186.87,64.6 184.26,67.21 184.26,72.69 182.56,74.4 182.56,78.52 180.2,80.88 180.2,81.53 179.4,82.33 177.58,82.33 176.56,83.34 172.58,83.34 171.86,82.63 170.39,82.63 170.04,82.28 163.09,82.28 162.8,81.98 159.23,81.98 158.87,82.34 156.4,82.34 154.33,84.41 150.27,84.41 149.84,84.84 144.97,84.84 144.05,85.76 140.43,85.76 140.36,85.82
  BOTTOM w0.079: v1(121.52,99.22) 121.24,99.51 U400.BE5
PCIE_RXN12_SSD_C: length 7.4
  TOP w0.097: C4301.1 209.97,17.11 209.81,16.94 209.62,16.94 v2(209.32,17.25) 209.29,17.23 208.96,17.23 R4304.1
  BOTTOM w0.097: v2(209.32,17.25) 209.6,16.97 209.87,16.97 210.54,16.3 210.54,15.89 210.74,15.69 212.73,15.69 212.88,15.84 CN4300.43
PCIE_RXP5_LAN: length 91.4
  TOP w0.097: C4003.2 189.53,70.52 189.41,70.65 189.41,70.96 189.6,71.16 v2(189.83,71.16)
  IN2 w0.102: 139.34,92.6 139.33,92.62 139.33,92.64 138.67,93.3 138.67,94.57 138.08,95.15 134.36,95.15 134.07,94.86 133.34,94.86 132.13,96.07 130.33,96.07 129.5,96.9 129.5,97.41 127.49,99.42 127.26,99.42 127.11,99.26 v1(127.11,99.15)
  IN2 w0.114: 139.34,92.6 139.51,92.44 139.59,92.44 139.61,92.45 140.1,92.45 140.11,92.44 141.49,92.44 142.16,91.76 145.17,91.76 145.95,92.54 147.07,92.54 148.12,91.5 149.65,91.5 150.47,90.68 153.96,90.68 154.87,89.77 156.38,89.77 158.3,87.85 158.52,87.85 159.43,86.95 160.47,86.95 161.68,88.16 162.97,88.16 163.07,88.05 165.46,88.05 166.24,88.83 167.69,88.83 167.89,88.63 170.64,88.63 171.38,89.36 174.5,89.36 174.75,89.61 177.7,89.61 178.05,89.97 178.58,89.97 179.44,90.83 179.84,90.83 180.52,90.15 180.73,90.15 182.12,88.76 183.56,88.76 185.38,86.95 185.38,86.38 186.97,84.79 186.97,84.3 188.88,82.39 188.88,81.4 189.34,80.94 189.34,76.41 189.02,76.08 189.02,73.38 190.31,72.09 190.31,70.82 190.08,70.59 189.63,70.59 189.46,70.77 189.46,71.01 189.6,71.16 v2(189.83,71.16)
  BOTTOM w0.079: U400.BP6 126.61,99.07 126.73,99.19 127.06,99.19 v1(127.11,99.15)
PCIE_RXP5_LAN_L: length 5.3
  TOP w0.097: U4000.17 192.46,68.51 192.28,68.69 192.28,69.08 191.78,69.58 190.84,69.58 190.62,69.35 189.43,69.35 189.33,69.46 189.33,69.72 189.44,69.83 189.86,69.83 C4003.1
PCIE_RXP6_WLAN: length 57.4
  IN2 w0.102: 139.73,91.51 139.22,91.51 138.84,91.89 138.84,92.57 137.05,94.37 134.24,94.37 134.16,94.45 133.37,94.45 132.74,95.08 130.72,95.08 128.96,96.83 128.96,97.24 127.7,98.5 127.19,98.5 126.15,99.55 v1(126.15,99.61)
  IN2 w0.114: v2(167.41,88.36) 167.23,88.18 166.34,88.18 165.58,87.42 165.18,87.42 164.68,86.93 164.21,86.93 163.74,87.4 162.17,87.4 161.97,87.2 161.32,87.2 160.64,86.52 159.26,86.52 158.38,87.41 158.12,87.41 156.3,89.24 154.75,89.24 153.86,90.12 153.25,90.12 152.95,89.83 150.72,89.83 149.9,90.64 147.75,90.64 147.36,91.03 146.07,91.03 145.75,91.34 141.99,91.34 141.76,91.57 141.04,91.57 140.85,91.38 139.86,91.38 139.73,91.51
  BOTTOM w0.079: v1(126.15,99.61) 126.05,99.51 U400.BN5
  BOTTOM w0.097: CN4100.41 170.7,83.68 170.47,83.9 170.06,83.9 169.41,84.56 169.41,84.99 169.12,85.28 168.1,85.28 167.44,85.94 167.44,86.13 166.94,86.63 166.94,87.9 v2(167.41,88.36)
PCIE_RXP8_SSD: length 171.4
  TOP w0.097: C4300.2 210.75,16.34 210.95,16.54 211.34,16.54 v2(211.37,16.51)
  IN2 w0.102: v1(125.15,99.19) 125.61,98.74 125.61,98.66 125.76,98.51 125.76,98.02 125.54,97.79 125.54,96.83 127.36,95 127.36,93.87 127.78,93.45 132.39,93.45 133.59,92.26 136.33,92.26 136.69,91.9 137.09,91.9 138.97,90.02 139.47,90.02 139.93,89.57 140.42,89.57 140.88,89.11 141.03,89.11
  IN2 w0.114: 141.03,89.11 147.07,89.11 147.61,88.58 149.82,88.58 150.05,88.35 152.1,88.35 153.14,87.31 156.14,87.31 157.27,86.17 157.27,85.89 158.12,85.04 161.99,85.04 162.41,85.47 167.94,85.47 168.12,85.65 168.89,85.65 169.48,86.25 170.54,86.25 171.12,86.82 171.69,86.82 172.4,87.53 173.21,87.53 173.46,87.79 174.45,87.79 175.16,87.08 177.58,87.08 178.24,86.42 178.24,85.98 179.18,85.04 180.77,85.04 183.06,82.76 183.47,82.76 185.4,80.82 185.4,77.06 186.93,75.54 186.93,69.38 187.9,68.41 189.91,68.41 191.11,67.21 192.18,67.21 193.63,68.66 195.72,68.66 196.81,67.57 196.81,67.21 198.78,65.23 201.09,65.23 202.04,64.29 202.55,64.29 203.28,63.56 203.28,63.04 204.4,61.92 207.57,61.92 209.37,60.12 209.37,59.75 210.44,58.69 210.81,58.69 211.65,57.84 212.89,57.84 213.3,57.43 213.95,57.43 216.09,55.3 216.09,54.6 215.53,54.04 215.53,47.95 217.62,45.86 217.62,37.88 220.25,35.25 220.25,30.13 219.75,29.63 219.75,28.8 219.41,28.46 219.41,26.9 216.59,24.08 216.59,23.13 215.24,21.77 211.54,21.77 210.29,20.53 210.29,19.74 212.05,17.99 212.05,16.9 211.84,16.69 211.55,16.69 v2(211.37,16.51)
  BOTTOM w0.079: U400.BL5 124.84,99.51 v1(125.15,99.19)
PCIE_RXP9_SSD: length 182.7
  IN2 w0.102: v1(124.29,99.63) 124.77,99.15 124.77,99.02 124.87,98.92 124.87,98.13 125,98 125,96.65 126.12,95.54 126.12,93.71 126.75,93.07 127.31,93.07 127.57,92.82 131.62,92.82 131.92,92.52 131.92,92.1 132.16,91.85 132.64,91.85 133.23,91.27 136.62,91.27 137.21,90.67 137.47,90.67 138.87,89.27 139.06,89.27 139.49,88.84 140.2,88.84 140.6,88.45 141.03,88.45
  IN2 w0.114: v2(208.29,11.52) 208.02,11.79 208.02,12.7 208.2,12.88 208.2,15.48 208.3,15.58 208.3,19.45 211.97,23.12 213.29,23.12 213.65,22.76 215.22,22.76 215.95,23.49 215.95,24.35 218.69,27.09 218.69,28.78 219.1,29.2 219.1,29.9 219.59,30.39 219.59,34.86 216.98,37.47 216.98,44.66 214.82,46.82 214.82,54 214.21,54.61 214.21,55.4 214.01,55.6 214.01,55.8 212.62,57.19 211.38,57.19 210.54,58.04 210.17,58.04 208.73,59.48 208.73,59.85 207.3,61.28 204.12,61.28 202.53,62.87 202.44,62.87 200.77,64.55 198.53,64.55 197.45,65.63 193.34,65.63 192.64,66.32 191.08,66.32 189.7,67.7 187.05,67.7 186.24,68.51 186.24,75.08 184.72,76.6 184.72,80.29 183.37,81.64 182.92,81.64 182.46,82.11 182.46,82.42 180.48,84.4 178.61,84.4 177.43,85.58 174.25,85.58 173.71,86.12 172.16,86.12 171.41,85.37 169.83,85.37 168.89,84.43 167.88,84.43 167.51,84.8 164.8,84.8 164.26,84.25 162.21,84.25 161.92,83.96 160.27,83.96 160.13,84.11 159.85,84.38 157.25,84.38 156.63,85.01 156.63,85.75 155.73,86.64 152.84,86.64 152.23,87.25 152.23,87.3 151.84,87.69 149.74,87.69 149.56,87.86 147.35,87.86 146.76,88.45 141.03,88.45
  BOTTOM w0.079: U400.BK5 124.17,99.51 v1(124.29,99.63)
  BOTTOM w0.097: v2(208.29,11.52) 208.08,11.31 208.08,10.08 208.79,9.36 209.38,9.36 211.8,6.93 211.96,6.93 212.28,6.6 212.68,6.6 212.91,6.84 CN4300.7
PCIE_RXP10_SSD: length 178.5
  IN2 w0.102: 141.03,87.8 141.02,87.8 141,87.78 140.94,87.78 140.85,87.69 139.34,87.69 137.59,89.44 137.02,89.44 136.21,90.25 133.24,90.25 132.15,91.34 131.35,91.34 130.97,91.72 126.45,91.72 125.67,92.51 125.54,92.51 125.03,93.02 125.03,95.97 124.32,96.68 124.32,96.88 123.89,97.31 123.89,98.23 123.83,98.29 123.83,98.89 v1(123.4,99.32)
  IN2 w0.114: 141.03,87.8 143.35,87.8 143.93,87.23 144.88,87.23 145.14,87.48 146.64,87.48 146.92,87.2 148.85,87.2 149.64,86.42 151.8,86.42 152.23,85.98 154.64,85.98 156.95,83.67 159.55,83.67 159.9,83.32 162.21,83.32 162.49,83.59 169.14,83.59 169.55,84 171.26,84 172.07,84.82 177.05,84.82 178.14,83.72 179.93,83.72 181.64,82.01 181.64,81.33 184.06,78.92 184.06,74.78 185.58,73.25 185.58,68.25 187.48,66.35 188.53,66.35 188.81,66.63 189.77,66.63 190.94,65.46 191.67,65.46 193.01,64.95 196.01,64.95 197.63,64.2 197.66,64.18 198.3,63.82 199.75,63.82 201.4,62.16 202.32,62.16 203.85,60.63 207.03,60.63 208.06,59.6 208.06,59.23 209.9,57.39 210.27,57.39 211.11,56.55 212.3,56.55 212.92,55.93 212.92,54.67 213.27,54.32 213.27,51.56 213.39,51.44 213.39,47.27 216.33,44.33 216.33,37.2 218.35,35.18 218.35,30.58 218.02,30.25 218.02,27.34 214.51,23.83 211.76,23.83 207.4,19.47 207.4,18.01 206.88,17.5 206.88,14.65 207.04,14.49 207.23,14.49 v2(207.49,14.75)
  BOTTOM w0.079: v1(123.4,99.32) 123.22,99.51 U400.BJ5
  BOTTOM w0.097: v2(207.49,14.75) 207.8,14.44 208.18,14.44 208.73,13.89 208.73,13.13 210.42,11.44 210.42,10.46 211.35,9.53 212.39,9.53 212.51,9.65 212.8,9.65 212.99,9.84 CN4300.19
PCIE_RXP10_WWAN: length 105.5
  IN1 w0.079: v1(130.69,99.13) 130.24,98.68 130.24,98.21 129.95,97.93 129.94,97.93 129.93,97.91
  IN1 w0.102: 139.86,94.26 139.85,94.26 139.82,94.3 139.78,94.3 139.77,94.3 138.89,94.3 138.03,95.17 134.42,95.17 134.3,95.04 131.02,95.04 129.62,96.43 129.62,97.61 129.93,97.91
  IN1 w0.114: v2(188.1,69.85) 187.86,70.08 187.57,70.08 187.33,70.32 187.33,75.32 187.58,75.56 188.43,76.41 188.76,76.74 188.76,78.8 188.12,79.44 188.12,82.28 187.89,82.51 187.89,89.26 182.68,94.46 179.26,94.46 178.32,95.41 174.25,95.41 173.9,95.76 172.73,95.76 172.44,95.47 167.5,95.47 167.01,94.98 166.11,94.98 165.61,95.47 163.64,95.47 162.85,94.68 162.35,94.68 161.65,93.99 161.38,93.99 160.67,93.28 158.35,93.28 158.17,93.45 156.75,93.45 156.42,93.12 156.42,92.28 155.61,91.47 153.81,91.47 153.45,91.83 151.77,91.83 151.37,91.42 150.76,91.42 150.07,92.11 150.07,92.47 149.65,92.89 145.78,92.89 145.35,92.46 144.38,92.46 143.85,92.99 143.85,93.26 143.46,93.65 143.15,93.65 142.28,94.52 140.6,94.52 140.34,94.26 139.86,94.26
  BOTTOM w0.079: v1(130.69,99.13) 130.41,98.86 U400.BY6
  BOTTOM w0.097: CN4200.43 198.95,71.53 198.85,71.44 198.71,71.44 198.65,71.37 198.65,71.04 198.39,70.78 196.23,70.78 195.94,71.08 195.15,71.08 194.67,70.6 194.67,70.21 194.37,69.91 193.61,69.91 192.86,70.66 191.09,70.66 190.93,70.81 190.34,70.81 189.64,70.12 188.28,70.12 188.1,69.94 v2(188.1,69.85)
PCIE_RXP11_SSD: length 178.1
  TOP w0.097: R4309.2 209.97,12.61 209.88,12.52 206.74,12.52 206.22,13.04 205.19,13.04 205.08,13.16 v2(205.08,13.42)
  IN2 w0.102: 140.72,86.19 140.59,86.19 139.81,86.97 138.82,86.97 137.21,88.58 136.58,88.58 136.23,88.93 133.64,88.93 132.6,89.97 131.53,89.97 130.51,90.99 126.04,90.99 125.93,91.09 125.19,91.09 124.14,92.15 124.14,93.85 123.72,94.26 123.24,94.26 122.59,94.92 122.59,98.43 v1(122.43,98.59)
  IN2 w0.114: v2(205.08,13.42) 205.08,13.21 205.2,13.09 205.48,13.09 205.85,13.46 205.85,18.42 206.22,18.79 206.22,20.43 208.44,22.66 209.35,22.66 211.45,24.76 214.11,24.76 217.13,27.78 217.13,30.61 217.46,30.94 217.46,31.41 216.86,32 216.86,34.82 215.45,36.23 215.45,43.62 214,45.06 213.71,45.06 212.83,45.94 212.83,46.39 211.81,47.41 211.81,53.56 211.21,54.16 211.21,55.21 209.9,56.51 209.54,56.51 207.18,58.87 207.18,59.23 206.67,59.75 203.49,59.75 201.96,61.28 200.89,61.28 199.38,62.79 198.53,62.79 197.9,62.16 197.2,62.16 196.74,62.61 194.45,62.61 194.05,62.21 192.78,62.21 190.4,64.58 189.1,64.58 188.53,65.16 186.95,65.16 184.69,67.42 184.69,72.88 183.04,74.53 183.04,78.67 180.68,81.03 180.68,81.72 179.64,82.76 177.76,82.76 176.7,83.83 172.42,83.83 171.68,83.09 169.98,83.09 169.6,82.71 162.9,82.71 162.6,82.4 159.49,82.4 159.14,82.76 156.6,82.76 154.39,84.97 151.27,84.97 150.94,85.3 149.52,85.3 148.55,86.26 146.79,86.26 146.06,85.53 144.89,85.53 144.24,86.19 140.72,86.19
  BOTTOM w0.079: v1(122.43,98.59) 122.3,98.46 122.18,98.46 122.08,98.56 121.98,98.56 121.9,98.64 121.9,98.76 U400.BG6
PCIE_RXP11_SSD_C: length 3.7
  TOP w0.097: v2(211.36,12.93) 211.08,12.66 210.88,12.66 210.75,12.78 R4309.1
  BOTTOM w0.097: v2(211.36,12.93) 211.36,12.86 211.53,12.69 212.73,12.69 212.88,12.84 CN4300.31
PCIE_RXP12_SSD: length 171.2
  TOP w0.097: v2(205.04,16.37) 205.27,16.6 205.28,16.6 205.3,16.62 205.65,16.62 205.78,16.75 206.09,16.75 v2(206.62,16.22) 207.14,16.74 207.75,16.74 207.92,16.58 R4302.2
  IN2 w0.102: 140.2,85.66 139.65,86.21 138.58,86.21 136.83,87.97 136.33,87.97 135.85,88.45 133.38,88.45 132.41,89.42 131.29,89.42 130.79,89.92 125.12,89.92 122.84,92.2 122.84,93.77 121.93,94.69 121.93,98.21 121.85,98.29 121.85,98.54 121.8,98.59 v1(121.55,98.59)
  IN2 w0.114: v2(205.04,16.37) 205.04,16.51 204.94,16.61 204.55,16.61 204.24,16.92 204.24,17.96 205.29,19.01 205.29,20.42 208.17,23.31 209.08,23.31 211.27,25.5 213.93,25.5 216.44,28.01 216.44,30.87 216.35,30.96 216.35,31.57 216.21,31.71 216.21,34.48 214.8,35.89 214.8,43.23 214.04,44 213.81,44 212.13,45.68 212.13,45.91 211.07,46.96 211.07,53 210.56,53.51 210.56,54.94 210.4,55.11 209.84,55.66 209.64,55.87 209.27,55.87 206.54,58.6 206.54,58.86 206.29,59.1 203.02,59.1 201.49,60.64 200.23,60.64 200.08,60.48 198.05,60.48 197.36,61.17 196.63,61.17 196.54,61.26 192.78,61.26 190.19,63.86 188.27,63.86 187.77,64.37 186.77,64.37 184.03,67.11 184.03,72.6 182.33,74.3 182.33,78.42 179.97,80.78 179.97,81.44 179.31,82.1 177.49,82.1 176.47,83.11 172.67,83.11 171.96,82.4 170.49,82.4 170.13,82.05 163.18,82.05 162.89,81.76 159.13,81.76 158.78,82.11 156.31,82.11 154.24,84.18 150.17,84.18 149.74,84.61 144.87,84.61 143.96,85.53 140.34,85.53 140.2,85.66
  BOTTOM w0.079: U400.BE6 121.03,98.82 121.03,98.59 121.12,98.51 121.47,98.51 v1(121.55,98.59)
PCIE_RXP12_SSD_C: length 7.4
  TOP w0.097: R4302.1 208.98,16.49 v2(209.32,16.49) 209.57,16.74 209.86,16.74 209.97,16.63 C4300.1
  BOTTOM w0.097: v2(209.32,16.49) 209.6,16.77 209.79,16.77 210.34,16.21 210.34,15.81 210.66,15.49 212.73,15.49 212.88,15.34 CN4300.41
PCIE_TXN5_LAN: length 7.5
  TOP w0.097: U4000.14 194.33,69.81 194.42,69.91 194.42,70.29 194.53,70.4 194.53,70.75 194.68,70.9 194.68,73.16 194.98,73.47 194.98,73.89 194.72,74.15 193.67,74.15 193.46,74.37 193.46,74.54 C416.2
PCIE_TXN5_LAN_C: length 112.8
  TOP w0.097: v2(129,114.66) 128.76,114.9 128.76,114.99 128.86,115.09 131.6,115.09 133.51,117.01 133.51,117.24 133.76,117.49 137.32,117.49 137.68,117.13 138.58,117.13 138.81,117.36 143.55,117.36 144.1,116.81 150.94,116.81 160.47,107.28 166.09,107.28 170.9,102.47 172.27,102.47 173.59,101.15 173.59,99.78 174.48,98.89 175.88,98.89 178.92,95.84 184.64,95.84 189.09,91.39 189.09,84.18 188.65,83.74 187.68,83.74 185.94,82 185.94,80.95 187.38,79.51 188.88,79.51 190.11,78.29 191.07,78.29 191.5,77.86 191.5,77.45 192.44,76.51 193.28,76.51 193.51,76.28 193.51,76.05 193.21,75.76 C416.1
  BOTTOM w0.079: U400.BR2 127.41,102.1 127.41,102.37 127.91,102.87 127.91,106.52 127.24,107.19 127.04,107.19 126.82,107.42 126.82,108.28 126.84,108.29 126.84,108.31
  BOTTOM w0.097: v2(129,114.66) 128.83,114.66 128.74,114.56 128.74,114.17 128.47,113.91 128.11,113.91 127.99,113.79 127.34,113.79 126.23,112.68 126.23,109.19 126.84,108.58 126.84,108.31
PCIE_TXN6_WLAN: length 12.4
  BOTTOM w0.097: CN4100.37 169.7,83.73 169.55,83.88 169.33,83.88 168.92,84.28 168.64,84.28 arc(167.98,84.41) 167.42,84.79 166.39,85.82 arc(166.08,86.29) 165.97,86.84 165.97,87.05 arc(166.08,87.64) 166.42,88.15 167.11,88.84 167.23,88.96 arc(167.42,89.25) 167.49,89.59 167.49,90.82 arc(167.59,91.32) 167.88,91.75 168.11,91.98 168.11,91.98 168.25,92.11 168.25,92.16 C418.2
PCIE_TXN6_WLAN_C: length 80.8
  TOP w0.097: v2(163.51,108.99) 163.25,108.74 160.25,108.74 150.27,118.71 144.51,118.71 144.16,118.36 133.39,118.36 132.64,117.6 132.64,117.37 131.23,115.97 127.4,115.97 127.03,115.6 127.03,115.2 v2(126.86,115.02)
  BOTTOM w0.079: 124.87,109.86 124.87,109.84 124.89,109.83 124.89,109.05 125.57,108.37 125.57,107.42 126.58,106.41 127.08,106.41 127.29,106.2 127.29,103.28 126.43,102.42 126.43,102.12 126.49,101.94 126.5,101.88 126.49,101.8 126.43,101.57 126.46,101.36 126.58,101.12 126.65,100.6 U400.BR4
  BOTTOM w0.097: 124.87,109.86 124.87,112.56 126.86,114.55 v2(126.86,115.02) ; C418.1 168.13,93.49 168.13,93.65 168.79,94.31 168.79,97.27 169.98,98.46 169.98,104.59 165.81,108.76 163.74,108.76 v2(163.51,108.99)
PCIE_TXN8_SSD: length 190.5
  TOP w0.097: C4306.2 207.68,18.7 207.37,18.7 207.05,19.02 207.05,19.87 207.44,20.26 209.87,20.26 210.5,20.89 212.47,20.89 212.55,20.97 212.55,21.62 213.17,22.24 213.17,23.78 214.84,25.45 215.29,25.66 216.45,26.22 217.66,26.8 220.39,26.8 225.02,29.07 v2(225.92,29.07)
  IN2 w0.114: v2(125.52,105.75) 125.69,105.91 125.69,106.25 126.11,106.68 128.92,106.68 130.17,107.93 131.9,107.93 132.82,107.01 141.76,107.01 143.98,109.22 144.81,109.22 145.04,109.45 161.32,109.45 163.2,107.57 164.42,107.57 165.61,106.38 167.72,106.38 168.43,105.67 174.79,105.67 177.74,102.72 183.57,102.72 185.13,101.16 190.37,101.16 194.57,96.96 194.57,95.02 198.76,90.84 200.41,90.84 203.01,88.24 203.01,86.79 205.37,84.42 205.37,76.06 207.5,73.93 207.5,72.98 208.59,71.89 208.59,70.92 209.6,69.91 209.6,68.3 209.84,68.05 212.43,68.05 219.38,61.1 219.38,60.23 221.3,58.31 221.3,54.63 222.03,53.9 222.03,48.8 222.96,47.87 222.96,47.86 223.58,47.24 223.58,40.84 224.67,39.76 224.67,29.55 225.32,28.9 225.74,28.9 v2(225.92,29.07)
  BOTTOM w0.079: U400.BN2 125.56,101.79 125.27,102.08 125.27,104.97 125.72,105.42 125.72,105.54 v2(125.52,105.75)
PCIE_TXN9_SSD: length 204.1
  TOP w0.097: C4314.2 209.72,8.19 209.57,8.19 209.31,7.93 208.34,7.93 208.07,8.2 208.07,8.39 v2(207.79,8.67)
  IN2 w0.114: v2(207.79,8.67) 208.06,8.95 208.06,9.3 208.29,9.53 209.59,9.53 210.68,10.62 210.68,11.06 211.27,11.64 212.25,11.64 212.5,11.89 212.5,13.09 213.1,13.7 213.1,14.93 214.28,16.1 214.28,17.94 215.02,18.67 215.93,18.67 217.28,20.02 217.83,20.02 219.11,21.29 219.11,21.61 222.57,25.08 224.16,25.08 224.72,24.52 225.41,24.52 225.92,25.02 225.92,26.92 226.62,27.62 226.62,28 226.34,28.28 226.34,30.07 225.2,31.21 225.2,34.19 225.61,34.59 225.61,34.81 225.11,35.32 225.11,40.19 224.06,41.24 224.06,48.9 222.54,50.42 222.54,57.8 219.79,60.55 219.79,61.28 211.45,69.63 210.53,69.63 209.23,70.92 209.23,71.84 208.39,72.68 208.39,75.6 207.97,76.03 207.17,76.03 206.19,77.01 206.19,81.21 205.91,81.48 205.91,84.5 204.53,85.88 204.53,88.21 201.24,91.5 198.69,91.5 195.11,95.08 195.11,97.02 190.54,101.58 185.3,101.58 183.71,103.18 177.94,103.18 174.25,106.86 166.46,106.86 163.45,109.87 144.87,109.87 144.72,109.72 143.89,109.72 141.59,107.43 132.99,107.43 132.07,108.35 129.99,108.35 128.75,107.1 125.24,107.1 124.74,106.6 124.74,106.31 v2(124.9,106.14)
  BOTTOM w0.079: U400.BM4 125.25,100.83 125.25,101.25 125.3,101.29 125.3,101.75 125.05,102 125.05,105.36 124.7,105.7 124.7,105.95 v2(124.9,106.14)
PCIE_TXN9_SSD_C: length 3.6
  TOP w0.097: v2(211.66,8.02) 211.51,8.17 211.06,8.17 210.9,8.02 C4314.1
  BOTTOM w0.097: CN4300.11 213.08,7.84 212.58,8.34 211.98,8.34 v2(211.66,8.02)
PCIE_TXN10_SSD: length 188.7
  TOP w0.097: v2(209.15,10.03) 209.28,10.17 209.74,10.17 C4316.2
  IN2 w0.102: 129.75,104.63 129.73,104.63 129.71,104.62 128.14,104.62 127.92,104.4 126.31,104.4 125.98,104.07 124.96,104.07 124.32,104.72 v2(124.32,104.97)
  IN2 w0.114: v2(209.15,10.03) 209.36,10.24 209.63,10.24 210.22,10.83 210.22,12.42 211.23,13.43 211.7,13.43 212.68,14.42 212.68,15.1 213.86,16.28 213.86,18.26 215.09,19.49 216.15,19.49 217.12,20.45 217.67,20.45 218.69,21.47 218.69,23.15 219.81,24.27 220.96,24.27 223.22,26.53 223.22,38.85 222.08,39.98 222.08,44.35 221.5,44.93 221.5,47.24 220.13,48.61 220.13,53.67 219.83,53.96 219.83,57.65 217.93,59.55 217.93,60.5 211.86,66.57 209.28,66.57 208.15,67.7 208.15,69.28 204,73.43 204,74.7 203.54,75.16 203.54,76.07 203.31,76.3 203.31,79.8 202.21,80.9 202.21,85.11 200.53,86.8 200.53,87.76 199.94,88.35 199.2,88.35 196.1,91.45 195.68,91.45 187.41,99.72 184.53,99.72 183.07,101.17 176.94,101.17 173.92,104.2 167.62,104.2 167.01,104.81 164.8,104.81 163.6,106 162.56,106 161.74,106.82 161.74,106.83 160.79,107.77 147.49,107.77 147.27,107.99 145.73,107.99 145.5,107.76 145.18,107.76 142.08,104.67 132.12,104.67 131.52,105.26 130.9,105.26 130.27,104.63 129.75,104.63
  BOTTOM w0.079: v2(124.32,104.97) 124.13,104.78 124.13,104.6 124.19,104.54 124.43,104.54 124.69,104.28 124.69,101.81 U400.BL2
PCIE_TXN10_SSD_C1: length 4.1
  TOP w0.097: C4316.1 210.75,10.22 210.88,10.34 211.11,10.34 v2(211.39,10.06)
  BOTTOM w0.097: v2(211.39,10.06) 211.68,10.35 212.36,10.35 212.63,10.62 212.63,10.88 212.74,10.99 212.82,10.99 212.97,10.84 CN4300.23
PCIE_TXN10_WWAN: length 5.4
  TOP w0.097: C407.1 199.23,76.56 v2(199.23,76.09)
  BOTTOM w0.097: v2(199.23,76.09) 199.64,75.68 199.64,75.2 200.1,74.74 200.1,73.21 199.95,73.06 CN4200.47
PCIE_TXN10_WWAN_C: length 99.4
  TOP w0.097: v2(198.71,78.67) 198.71,77.97 C407.2
  IN1 w0.114: v2(198.71,78.67) 198.71,79.94 198.26,80.39 198.26,82.83 196.86,84.23 196.86,86.31 196.35,86.81 196.35,92.77 194.32,94.8 194.32,96.23 190.22,100.32 187,100.32 184.22,103.1 177.36,103.1 176.77,103.69 167.33,103.69 166.56,104.46 164.62,104.46 163.16,105.92 162.16,105.92 158.44,109.63 156.5,109.63 155.48,110.66 143.69,110.66 140.53,107.5 133.08,107.5 132.11,106.53 130.84,106.53 130.6,106.78 130.6,107.07 v2(130.41,107.25)
  BOTTOM w0.079: U400.BY4 129.87,100.83 129.57,101.14 129.57,101.57 129.78,101.78 129.78,102.74 129.85,102.81 129.85,105.77 130.41,106.34 v2(130.41,107.25)
PCIE_TXN11_SSD: length 186.8
  TOP w0.097: C4308.2 209.75,14.3 209.45,14.3 v2(209.3,14.15)
  IN2 w0.102: 137.5,103.79 137.49,103.79 137.47,103.8 136.27,103.8 134.94,102.47 130.46,102.47 129.22,103.71 126.58,103.71 126.23,103.36 123.95,103.36 123.71,103.6 123.71,103.79 v2(123.48,104.01)
  IN2 w0.114: 137.5,103.79 138.44,103.79 139.11,103.12 143.87,103.12 144.53,102.46 147.54,102.46 150.06,104.97 151,104.97 152.68,106.65 160.58,106.65 162.19,105.03 163.2,105.03 164.32,103.92 166.61,103.92 167.22,103.31 173.52,103.31 176.57,100.26 182.75,100.26 184.17,98.84 187.04,98.84 196.28,89.6 196.28,87.1 200.95,82.42 200.95,80.62 202.42,79.16 202.42,75.83 202.59,75.67 202.59,74.82 203.02,74.39 203.02,73.15 207.27,68.9 207.27,66.48 208.85,64.9 210.62,64.9 211.07,64.44 211.07,63.83 211.48,63.43 212.71,63.43 213.73,62.41 214.38,62.41 217.05,59.75 217.05,59.14 218.96,57.24 218.96,53.56 219.25,53.27 219.25,48.21 220.56,46.9 220.56,44.58 221.17,43.97 221.17,39.22 222.34,38.05 222.34,26.89 220.59,25.14 219.45,25.14 217.81,23.51 217.81,21.83 217.32,21.34 216.77,21.34 215.79,20.36 214.52,20.36 212.99,18.83 212.99,16.64 212.11,15.77 210.45,15.77 210.31,15.91 209.25,15.91 208.62,15.28 208.62,14.58 208.87,14.33 209.12,14.33 v2(209.3,14.15)
  BOTTOM w0.079: v2(123.48,104.01) 123.67,103.83 123.67,103.57 123.98,103.26 123.98,102.09 124.07,101.86 124.07,101.82 124.03,101.73 123.99,101.65 123.99,101.48 124.03,101.37 124.07,101.28 124.16,100.75 U400.BL4
PCIE_TXN11_SSD_C: length 3.9
  TOP w0.097: v2(211.41,14.13) 211.1,14.44 210.86,14.44 210.75,14.33 C4308.1
  BOTTOM w0.097: v2(211.41,14.13) 211.69,14.41 211.82,14.41 212.24,13.99 212.73,13.99 212.88,13.84 CN4300.35
PCIE_TXN12_SSD: length 199.3
  TOP w0.097: v2(226.73,26.02) 226.56,26.19 225.61,26.19 224.95,26.85 223.96,26.85 223.02,26.6 220.6,25.92 218.23,25.92 215.31,24.69 214.16,23.53 214.16,21.92 213.44,21.21 213.44,20.14 213.09,19.79 212.5,19.79 212.3,19.59 211.95,19.59 211.04,18.68 210.95,18.68 C4310.2
  IN2 w0.114: v2(122.91,104.32) 122.72,104.5 122.44,104.5 122.19,104.76 122.19,106.81 124.16,108.79 124.79,108.79 125.6,107.97 128.21,107.97 129.49,109.25 132.41,109.25 133.36,108.3 141.23,108.3 143.53,110.6 144.36,110.6 144.51,110.75 164.22,110.75 167.22,107.75 174.83,107.75 178.41,104.17 183.96,104.17 185.67,102.46 190.9,102.46 195.98,97.38 195.98,95.44 198.14,93.28 202.08,93.28 202.75,92.61 202.75,91.22 205.92,88.06 205.92,85.91 207.01,84.82 207.01,83.07 208.59,81.48 208.59,80.2 211.64,77.16 211.64,70.67 220.8,61.51 220.8,60.86 223.58,58.09 223.58,50.75 224.98,49.35 224.98,41.64 225.99,40.62 225.99,35.72 226.5,35.21 226.5,34.22 226.09,33.81 226.09,31.56 227.22,30.44 227.22,28.64 227.77,28.09 227.77,26.92 227.08,26.23 226.95,26.23 v2(226.73,26.02)
  BOTTOM w0.079: v2(122.91,104.32) 122.68,104.54 122.5,104.54 122.39,104.43 122.39,104.22 122.79,103.82 122.79,103.37 123.55,102.61 123.55,102.1 123.51,102.01 123.51,101.75 123.53,101.71 123.57,101.5 123.53,101.37 123.49,101.29 123.37,100.62 U400.BJ4
