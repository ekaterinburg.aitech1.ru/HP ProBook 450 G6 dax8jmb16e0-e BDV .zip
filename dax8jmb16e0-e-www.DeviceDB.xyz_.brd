# Allegro board dax8jmb16e0-e-www.DeviceDB.xyz_.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3V_VCC on BOTTOM (solid shape): 202.56,57.87 202.56,57.44 202.56,57.41 202.57,57.38 202.57,55.92 202.15,55.5 202.12,55.49 202.09,55.49 201.81,55.46 201.7,55.19 201.82,55 202.04,54.96 202.12,54.94 202.16,54.86 202.16,54.81 201.53,54.18 201.53,53.57 201.05,53.09 199.77,53.09 199.75,53.1 199.47,53.1 199.28,52.9 199.27,52.89 198.95,52.56 198.48,52.56 198.27,52.77 198.27,53.52 198.46,53.7 199.31,53.7 199.32,53.7 199.43,53.68 199.55,53.7 199.58,53.7 199.6,53.72 199.69,53.78 199.75,53.87 199.78,53.9 199.79,54.04 199.78,54.12 199.78,55.15 199.96,55.33 200.49,55.33 200.54,55.38 200.6,55.39 200.63,55.34 200.63,55.17 200.58,55.08 200.48,55.08 200.13,55.07 199.99,54.74 200.21,54.48 200.54,54.56 200.56,54.57 200.58,54.57 200.61,54.56 200.63,54.52 200.63,54.47 200.51,54.35 200.49,54.33 200.46,54.33 200.22,53.86 200.69,54.1 200.69,54.13 200.7,54.15 200.91,54.35 200.91,55.47 201.49,56.06 201.49,56.33 201.74,56.57 201.74,57.6 201.76,57.67 201.83,57.7 202.02,57.77 202.15,57.93 202.16,57.97 202.19,57.99 202.43,57.99
+3V_VCC on IN1 (solid shape): outline of 169 points within 195.77,47.38 201.74,52.46
+3V_VCC_READER on TOP (solid shape): 43.65,34.37 43.65,33.72 43.26,33.34 43.26,32.9 43.22,32.85 43.21,32.85 43.11,32.75 43.11,31.83 43.1,31.8 43.06,31.78 42.93,31.78 42.92,31.8 42.92,32.75 42.9,32.75 42.82,32.83 42.82,32.85 42.8,32.85 42.5,33.15 42.1,33.15 41.84,33.41 41.84,34.37 41.97,34.5 43.52,34.5
+3V_VCC_READER on BOTTOM (solid shape): 42.93,33.71 42.93,32.77 43.1,32.61 43.1,31.77 42.85,31.53 42.85,31.36 42.83,31.33 42.8,31.3 42.8,31.26 42.78,31.14 42.8,31.02 42.8,31.01 42.8,30.23 42.8,30.22 42.78,30.1 42.8,29.98 42.8,29.97 42.8,29.27 42.8,29.26 42.8,29.01 42.96,28.82 42.97,28.82 43,28.78 43.13,28.78 43.19,28.78 43.46,28.78 43.49,28.75 43.49,27.34 43.47,27.3 43.43,27.29 43.39,27.29 43.39,25.98 43.36,25.94 43.14,25.94 43.1,25.96 43.09,26 43.09,27.29 42.89,27.29 42.89,26 42.88,25.96 42.84,25.94 42.64,25.94 42.6,25.96 42.59,26 42.59,27.29 42.55,27.29 42.51,27.3 42.49,27.34 42.49,27.39 42.23,27.39 42.19,27.4 42.18,27.44 42.18,28.29 41.9,28.56 41.9,30.73 41.91,30.76 42.04,30.85 42.07,30.97 42.07,31.27 42.04,31.38 41.94,31.45 41.93,31.46 41.91,31.49 41.91,31.72 41.93,31.75 41.95,31.75 42.06,31.82 42.1,31.95 42.1,32.25 42.06,32.37 41.94,32.44 41.93,32.45 41.9,32.47 41.9,33.49 42.15,33.74 42.19,33.74 42.23,33.77 42.87,33.77
+3V_WLAN_C on TOP (solid shape): 180.83,92.59 182.18,92.59 182.23,92.54 182.23,91.9 182.13,91.8 180.88,91.8 180.65,92.03 179.76,92.03 179.64,92.16 179.64,92.92 179.68,92.96 179.93,92.96 179.94,92.97 180.45,92.97
+3V_WLAN_P on TOP (solid shape): outline of 392 points within 160.28,88.78 181.62,93.91
+3V_WLAN_P on BOTTOM (solid shape): 179.43,92.64 179.43,91.59 179.43,91.57 179.42,91.55 179.23,91.37 179.23,90.39 179.24,90.33 179.25,90.27 179.24,90.18 179.16,90.13 178.97,89.94 178.88,89.91 178.81,89.96 178.81,91.26 178.59,91.26 178.59,89.71 178.62,89.71 178.67,89.68 178.65,89.62 178.62,89.59 178.51,89.59 178.45,89.62 178.37,89.64 178.32,89.69 178.32,91.42 177.73,92 177.73,92.64 177.86,92.77 179.31,92.77
+3V_WLAN_P on BOTTOM (solid shape): 162.8,92.77 162.8,92.18 162.31,91.7 162.17,91.7 161.84,91.36 161.7,91.36 161.69,91.28 161.68,91.27 161.59,91.26 161.59,89.71 161.68,89.7 161.69,89.69 161.7,89.61 161.58,89.49 160.89,89.49 160.88,89.48 160.51,89.48 160.4,89.59 160.38,89.59 160.38,89.71 161.31,89.71 161.31,91.26 161.09,91.26 161.09,89.71 160.38,89.71 160.38,89.94 160.41,89.96 160.45,89.99 160.48,90.03 160.51,90.07 160.54,90.12 160.55,90.17 160.56,90.22 160.56,90.28 160.55,90.33 160.54,90.38 160.52,90.43 160.49,90.47 160.45,90.51 160.41,90.54 160.36,90.57 160.31,90.59 160.26,90.6 160.22,90.61 159.8,91.03 159.8,92.35 160.45,92.99 162.57,92.99
+3V_WWAN_P on TOP (solid shape): outline of 231 points within 189.67,79.82 207.98,83.8
+3V_WWAN_P on BOTTOM (solid shape): outline of 472 points within 187.97,78.47 212.25,86.54
+3VLANVCC on TOP (solid shape): 192.16,66.22 192.33,66.22 192.33,66.21 193.34,66.21 193.4,66.15 193.4,66.05 193.38,66.02 192.36,66.02 192.35,66.01 192.33,66.01 192.33,65.99 192.26,65.92 192.12,65.92 191.89,65.69 191.04,65.69 190.38,65.03 187.37,65.03 187.22,65.18 187.22,66.02 187.5,66.3 189.37,66.3 189.48,66.2 190.09,66.2 190.14,66.24 190.71,66.24 190.76,66.24 190.86,66.25 190.94,66.27 191.01,66.32 191.08,66.39 191.99,66.39
+3VLANVCC on TOP (solid shape): 198.41,71.68 198.41,71.3 198.56,71.15 199.3,71.15 202.24,68.21 202.24,66.84 202.22,66.77 202.15,66.74 201.84,66.5 201.94,66.11 201.97,66.04 201.95,65.97 201.9,65.9 201.87,65.82 201.87,65.8 201.79,65.73 201.79,65.31 200.45,63.96 196.84,63.96 196.23,64.57 196.23,65.54 196.4,65.54 196.76,65.18 197.95,65.18 198.25,64.88 199.58,64.88 199.7,65.01 200.38,65.03 200.52,65.1 200.52,65.81 200.78,66.07 200.78,66.43 200.78,66.44 200.78,67.11 200.73,67.17 200.7,67.24 200.73,67.31 200.82,67.67 200.56,67.92 200.52,67.93 200.52,68.48 199.34,69.66 199.34,69.7 199.28,69.84 199.14,69.9 199.1,69.9 199.07,69.93 198.15,69.93 197.75,70.34 197.75,70.36 197.6,70.63 197.3,70.69 197.24,70.67 197.19,70.64 196.66,70.64 195.83,69.82 195.73,69.82 195.63,69.72 195.63,69.71 195.63,68.75 195.56,68.69 195.46,68.69 195.43,68.72 195.43,69.83 195.45,69.87 195.46,69.88 195.64,70.14 195.54,70.44 195.54,70.97 195.67,71.1 195.89,71.1 196.03,71.16 196.09,71.31 196.09,71.53 196.32,71.76 198.33,71.76
+3VLANVCC on IN1 (solid shape): outline of 100 points within 186.07,59.9 197.26,70.38
+3VLANVCC on IN2 (solid shape): outline of 99 points within 191.18,69.64 196.5,72.27
+3VLCD_CON on TOP (solid shape): outline of 82 points within 29.48,123.88 32.62,132.64
+3VLCD_CON on BOTTOM (solid shape): 32.46,131.54 32.47,131.51 32.47,131.49 32.45,131.35 32.49,131.22 32.49,131.21 32.49,131.04 32.01,130.56 31.92,130.56 31.81,130.46 30.77,130.46 30.69,130.54 30.69,131.23 30.84,131.38 30.84,131.53 30.89,131.57 31.1,131.57 31.13,131.6 32.39,131.6
+3VLCD_CON on IN2 (solid shape): 32.43,131.42 32.44,131.4 32.44,131.38 32.48,131.21 32.62,131.06 32.62,131.03 32.62,130.07 32.55,129.99 32.47,130 32.1,129.98 31.93,129.66 32.12,129.35 32.47,129.34 32.57,129.34 32.62,129.26 32.62,126.49 32.58,126.41 32.5,126.39 32.45,126.4 32.4,126.41 32.26,126.39 32.15,126.32 32.03,126.11 32.06,125.88 32.1,125.81 32.16,125.76 32.23,125.71 32.3,125.68 32.37,125.67 32.43,125.67 32.49,125.68 32.57,125.71 32.61,125.7 32.62,125.66 32.62,125.58 32.15,125.11 29.92,125.11 29.84,125.02 29.66,125.02 29.59,125.06 29.56,125.13 29.5,125.36 29.28,125.52 29.27,125.55 29.27,125.94 29.69,126.36 29.72,126.37 29.75,126.37 30.09,126.33 30.31,126.59 30.42,126.74 30.45,126.92 30.46,126.95 30.48,126.97 30.65,127.51 30.09,127.58 30.02,127.56 29.95,127.58 29.91,127.62 29.86,127.64 29.84,127.66 29.83,127.69 29.83,128.4 29.86,128.47 29.95,128.5 30.41,128.85 29.95,129.21 29.86,129.23 29.83,129.31 29.83,130.32 29.87,130.37 29.89,130.38 30.09,130.49 30.18,130.7 30.18,130.71 30.97,131.5 32.34,131.5
+3VPCU on TOP (solid shape): 39.3,45.27 39.3,44.86 38.9,44.46 38.9,43.34 38.73,43.17 38.27,43.17 38.14,43.3 38.14,45.28 38.34,45.47 39.1,45.47
+3VPCU on TOP (solid shape): 180.04,32.72 180.04,30.21 179.64,29.8 178.37,29.8 178.14,30.03 178.14,31.03 178.14,31.03 178.14,32.61 178.14,32.77 178.52,33.15 179.61,33.15
+3VPCU on TOP (solid shape): 136.69,70.14 136.69,69.89 136.46,69.66 135.51,69.66 135.48,69.69 135.48,69.7 134.89,69.7 134.87,69.69 134.6,69.96 134.58,69.96 134.58,70.27 134.74,70.42 136.41,70.42
+3VPCU on TOP (solid shape): 190.76,82.2 190.76,81.92 190.48,81.64 189.28,81.64 189.18,81.54 189.18,80.74 189.01,80.57 187.38,80.57 186.7,81.26 186.7,81.69 187.46,82.45 190.51,82.45
+3VPCU on TOP (solid shape): 128.74,72.86 128.74,70.33 128.6,70.19 127.91,70.19 127.61,70.5 127.61,72.19 128,72.59 128,73.12 128.01,73.16 128.05,73.17 128.43,73.17
+3VPCU on TOP (solid shape): 50.2,99.03 50.2,97.54 50.05,97.39 49.51,97.39 49.21,97.69 47.84,97.69 47.76,97.77 47.76,98.13 47.86,98.23 48.42,98.23 48.57,98.38 48.57,99.95 48.65,100.03 49.2,100.03
+3VPCU on TOP (solid shape): 180.45,59.64 180.45,59.34 180.27,59.16 180.27,58.7 180.23,58.66 179.58,58.66 179.38,58.86 179.38,59.57 179.56,59.75 179.62,59.76 179.67,59.77 180.32,59.77
+3VPCU on TOP (solid shape): 76.51,126.52 76.51,125.84 76.31,125.63 74.13,125.63 74.05,125.55 74.01,125.55 73.81,125.35 72.58,125.35 72.55,125.38 72.55,125.81 72.77,126.03 73.48,126.03 73.57,126.12 74.3,126.12 74.43,126.24 75.12,126.24 75.5,126.62 76.41,126.62
+3VPCU on TOP (solid shape): 169.34,31.2 169.37,31.18 169.39,31.15 169.39,30.46 169.59,30.46 169.59,31.15 169.6,31.18 169.64,31.2 170.87,31.2 171.03,31.04 171.03,30.03 170.8,29.8 169.35,29.8 169.21,29.94 169.21,31.18 169.22,31.2
+3VPCU on TOP (solid shape): 167.34,31.27 167.37,31.26 167.39,31.22 167.39,30.46 167.59,30.46 167.59,31.22 167.6,31.26 167.64,31.27 167.67,31.27 167.75,31.2 167.75,30.36 167.19,29.8 165.82,29.8 165.77,29.85 165.51,29.85 165.36,30 165.36,30.82 165.64,31.09 166.58,31.09 166.76,31.27
+3VPCU on TOP (solid shape): 198.9,101.32 198.9,100.86 199.2,100.56 200.24,100.56 200.29,100.51 200.29,99.85 200.24,99.8 199.45,99.8 199.04,99.4 199.04,99.01 198.89,98.86 198.67,98.86 198.18,98.86 197.9,99.14 197.9,100.28 197.9,100.29 197.9,100.9 197.93,100.91 198.02,100.99 198.06,101.1 198.06,101.36 198.27,101.57 198.66,101.57
+3VPCU on TOP (solid shape): 204.9,63.01 204.9,62.76 204.32,62.18 204.15,62.18 204.15,62.01 203.84,61.7 203.27,61.7 203.19,61.73 203.17,61.81 203.14,61.98 203.04,62.13 203.02,62.14 203.02,62.21 203.04,62.24 203.16,62.46 203.13,62.71 203.13,62.73 203.15,62.77 203.18,62.78 203.24,62.78 203.37,62.65 203.97,62.65 204.35,63.04 204.35,63.14 204.39,63.18 204.73,63.18
+3VPCU on TOP (solid shape): 214.53,54.8 214.53,54.49 214.54,54.44 214.56,54.39 214.56,54.34 214.69,54.21 214.69,54.01 214.67,53.99 214.61,53.9 214.58,53.8 214.55,53.73 214.48,53.71 213.69,53.71 213.44,53.95 213.22,53.96 213.01,53.95 212.91,54.06 212.91,54.39 213.05,54.53 213.38,54.53 213.41,54.54 213.42,54.54 213.69,54.62 213.82,54.86 213.83,54.88 213.86,54.91 214.42,54.91
+3VPCU on TOP (solid shape): 182.94,93.42 184.29,93.42 184.72,92.99 185.07,92.64 187.18,90.53 187.18,88.19 185.73,86.75 184.89,86.75 183.78,85.63 183.32,85.63 183.24,85.7 183.24,86.06 185.15,87.96 185.16,87.97 185.26,88.01 185.33,88.08 185.36,88.09 185.58,88.09 186.29,88.8 186.29,89.34 186.3,89.37 186.15,89.87 185.66,89.67 185.64,89.62 185.62,89.58 185.05,89.01 184.86,89.01 184.68,88.83 183.55,88.83 183.32,89.06 183.32,89.75 183.49,89.92 185.13,89.92 185.13,90.42 185.69,90.98 185.69,91.39 185.63,91.54 185.48,91.59 185.25,91.59 185.12,91.72 182.61,91.72 182.33,92 182.33,92.58 182.27,92.64 182.27,92.65 182.26,92.65 182.22,92.69 181.74,92.69 181.62,92.82 181.62,93.22 181.82,93.43 182.94,93.43
+3VPCU on TOP (solid shape): 39.35,57.46 39.35,56.18 39.34,56.15 39.32,56.13 39.07,55.79 39.32,55.45 39.34,55.43 39.35,55.4 39.35,55.07 39.34,55.03 39.3,55.02 39.18,55.02 39.18,54.31 39.3,54.31 39.34,54.3 39.35,54.26 39.35,54.08 39.34,54.04 39.3,54.03 39.18,54.03 39.18,53.32 39.3,53.32 39.34,53.31 39.35,53.27 39.35,52.44 39.31,52.36 39.22,52.34 38.76,52.05 39.11,51.64 39.19,51.61 39.22,51.54 39.22,51.06 39.06,50.9 38.1,50.9 38.01,50.99 38.01,57.94 38.08,58.02 38.79,58.02
+3VPCU on TOP (solid shape): 186.77,35.72 186.84,35.69 186.88,35.62 187.02,35.36 187.32,35.3 187.35,35.3 187.37,35.29 187.49,35.17 187.49,34.23 187.54,34.18 187.54,33.64 187.49,33.6 187.49,33.26 187.08,32.85 187.08,32.8 187.06,32.76 187.03,32.75 187.01,32.75 187.01,31.94 186.95,31.88 186.87,31.88 186.83,31.9 186.81,31.93 186.81,32.75 186.61,32.75 186.61,31.93 186.6,31.9 186.56,31.88 184.46,31.88 184.23,32.11 184.23,33.03 184.54,33.34 184.76,33.34 184.95,33.53 184.95,34.03 184.95,34.03 184.95,34.3 184.96,34.34 185,34.35 185.19,34.35 185.61,34.35 185.73,34.76 185.73,34.79 185.75,34.82 186.02,35.09 186.03,35.09 186.25,35.23 186.31,35.48 186.32,35.51 186.33,35.53 186.52,35.72
+3VPCU on TOP (solid shape): 214.84,63.89 214.84,61.73 214.79,61.68 214.05,61.68 213.93,61.8 213.93,62.84 213.88,62.89 213.85,62.98 213.9,63.05 213.82,63.7 213.4,63.2 213.4,63.1 213.31,63.05 212.92,63.05 212.51,63.3 212.23,62.91 212.2,62.83 212.13,62.79 212.01,62.79 211.5,62.82 211.49,62.31 211.49,62.03 210.6,61.14 209.79,61.14 209.66,61.27 209.66,61.85 210.12,62.31 210.14,62.3 210.47,62.41 210.55,62.74 210.55,62.75 210.55,62.82 211.67,63.94 212.1,63.94 212.13,63.97 212.13,63.97 212.24,64.04 212.31,64.14 212.31,64.15 212.66,64.5 214.24,64.5
+3VPCU on TOP (solid shape): 194.67,59.97 194.67,59.11 194.38,58.82 194.38,58.68 194.37,58.58 194.38,58.44 194.4,58.41 194.5,58.27 194.64,58.18 194.65,58.17 195.11,57.71 195.39,57.71 195.87,57.24 195.88,57.23 195.95,57.16 196.05,57.13 196.35,57.13 196.42,57.15 196.47,57.18 196.52,57.23 196.55,57.3 196.55,57.32 196.58,57.35 197.56,57.35 197.6,57.3 197.6,57.28 197.65,57.16 197.77,57.11 197.79,57.11 197.85,57.05 198.26,57.05 198.41,56.9 198.41,56.86 198.38,56.81 198.35,56.76 198.33,56.65 198.35,56.53 198.33,56.44 198.25,56.39 197.77,56.39 197.69,56.47 197.34,56.47 197.18,56.44 197.06,56.33 197.02,56.28 196.99,56.24 196.69,56.24 196.43,56.29 196.21,56.16 196.17,56.14 195.82,56.14 195.76,56.18 195.69,56.19 195.54,56.19 195.26,56.47 194.8,56.47 194.33,56.94 194.33,56.95 194.16,57.12 194.16,57.13 194.09,57.23 193.99,57.3 193.98,57.3 193.38,57.9 193.38,58.64 193.54,58.87 193.47,59.15 193.46,59.18 193.48,59.21 193.58,59.31 193.58,59.85 193.84,60.1 193.86,60.1 193.93,60.18 194.47,60.18
+3VPCU on BOTTOM (solid shape): 162.42,15.17 162.67,15.17 162.92,14.92 162.92,14.66 162.67,14.41 162.42,14.41 162.29,14.28 162.03,14.28 161.91,14.41 161.91,15.42 162.16,15.42
+3VPCU on BOTTOM (solid shape): 182.89,95.64 182.89,93.48 183.38,92.99 183.38,91.98 183.07,91.67 182.96,91.67 182.9,91.73 182.31,91.73 181.6,92.45 181.6,93.99 181.54,94.05 181.54,94.16 179.43,96.27 179.43,97.08 179.92,97.57 180.96,97.57
+3VPCU on BOTTOM (solid shape): 135.24,71.92 135.24,69.8 135.14,69.7 135.14,69.27 134.96,69.09 134.82,69.09 134.62,68.89 134.61,68.89 134.51,68.82 134.44,68.72 134.44,68.71 134.33,68.6 134.33,67.33 134.6,67.06 134.67,67.06 134.7,67.04 135.08,67.04 135.83,66.29 135.83,65.8 135.47,65.45 134.82,65.45 133.8,66.46 133.8,67.88 133.08,68.6 133.08,69.82 133.58,70.32 134.68,70.32 134.79,70.42 134.79,71.88 134.89,71.99 135.16,71.99
+3VPCU on BOTTOM (solid shape): 213.29,54.39 213.98,54.39 214.23,54.13 214.23,53.37 213.98,53.12 212.96,53.12 212.87,53.17 212.87,53.27 212.9,53.53 212.74,53.75 212.69,53.81 212.71,53.89 212.61,54.39 212.11,54.28 211.7,54.28 211.56,54.41 211.56,54.62 211.74,54.79 212.89,54.79
+3VPCU on BOTTOM (solid shape): 132.09,19.74 132.09,19.16 132.04,19.07 131.94,19.07 131.43,18.75 131.94,18.43 132.04,18.43 132.09,18.34 132.09,18.09 131.91,17.91 131.45,17.91 131.44,17.92 131.19,17.99 130.93,18.05 130.62,18.36 130.62,18.6 130.65,18.72 130.64,18.85 130.64,18.87 130.65,18.89 130.76,19 131.1,19 131.15,19.06 131.15,19.74 131.38,19.97 131.86,19.97
+3VPCU on SVCC (solid shape): outline of 420 points within 174.58,30.79 202.44,93.45
+3VPCU on IN1 (solid shape): 214.31,54.16 214.31,52.88 214.96,52.23 214.96,51.14 215.19,50.91 215.19,47.84 216.39,46.64 216.39,46.36 216.19,46.16 215.92,46.16 215.9,46.16 215.89,46.17 215.24,46.81 214.02,48.03 214,48.14 214.08,48.21 214.36,48.74 213.77,48.83 213.66,48.81 213.59,48.9 213.59,51.22 214,51.63 214.06,51.74 214.04,51.99 213.87,52.18 213.85,52.19 213.57,52.46 213.57,54.18 213.7,54.31 214.16,54.31
+3VPCU on IN1 (solid shape): outline of 553 points within 164.98,28.14 187.51,36.21
+3VPCU on IN2 (solid shape): 186.25,84.55 186.25,84.09 186.29,84.06 186.29,83.94 186.64,83.59 188.05,82.17 188.07,82.15 188.07,82.13 188.07,80.6 187.91,80.44 187.88,80.43 187.85,80.44 187.8,80.47 187.76,80.5 187.47,80.51 187.26,80.3 187.24,80.28 187.21,80.27 186.95,80.27 186.58,80.64 186.58,81.42 184.41,83.58 184.41,84.99 184.51,85.1 184.51,85.19 184.65,85.32 184.65,85.74 184.69,85.78 185.02,85.78
+3VPCU on IN2 (solid shape): outline of 104 points within 142.43,92.88 144.51,95.64
+3VPCU_PD on TOP (solid shape): 197.57,114.69 197.57,113.09 196.83,112.35 195.62,112.35 195.53,112.45 195.51,112.47 195.51,112.49 195.51,112.59 195.48,112.68 195.47,112.69 195.47,113.32 195.56,113.41 195.58,113.42 195.69,113.42 195.78,113.44 195.85,113.49 195.92,113.53 195.99,113.51 196.05,113.48 196.12,113.46 196.4,113.46 196.55,113.52 196.61,113.66 196.61,113.97 196.55,114.11 196.4,114.17 196.12,114.17 196.04,114.15 195.97,114.09 195.9,114.06 195.82,114.08 195.76,114.11 195.69,114.12 195.41,114.12 195.34,114.11 195.27,114.06 195.14,113.94 195.08,113.77 195.05,113.71 194.99,113.69 193.35,113.69 193.28,113.62 192.9,113.62 192.65,113.37 192.64,113.37 192.52,113.29 192.44,113.17 192.43,113.16 192.41,113.14 192.41,112.6 192.16,112.35 191.26,112.35 191.22,112.36 191.21,112.4 191.21,113.38 191.01,113.38 191.01,112.4 191,112.36 190.96,112.35 190.76,112.35 190.72,112.39 190.72,113.7 190.73,113.7 190.73,113.81 190.73,113.83 190.75,113.84 190.85,113.95 191.5,113.95 191.56,114.01 191.63,114.08 191.63,114.21 191.63,114.23 191.64,114.25 191.87,114.48 191.87,114.56 191.88,114.6 191.92,114.61 194.85,114.61 195.35,115.11 197.16,115.11
+3VSUS on TOP (solid shape): 205.13,105.26 205.13,104.98 205,104.84 204.67,104.84 204.48,104.65 204.45,104.65 204.3,104.5 204.3,104.19 204.25,104.14 204.04,104.14 204,104.18 204,104.4 203.87,104.53 202.83,104.53 202.78,104.58 202.78,105.06 202.83,105.11 204,105.11 204.1,105.2 204.61,105.2 204.82,105.41 204.99,105.41
+3VSUS on TOP (solid shape): 203.97,102.57 203.97,102.3 203.66,101.99 203.65,101.99 203.38,101.73 203.48,101.38 203.51,101.29 203.46,101.22 203.27,100.91 203.44,100.6 203.46,100.58 203.46,100.56 203.46,100.13 203.14,99.81 201.17,99.81 200.22,98.86 199.35,98.86 199.27,98.94 199.27,99.32 199.53,99.57 200.24,99.57 201.3,100.64 202.75,100.64 202.78,100.67 202.78,102.32 203.11,102.65 203.89,102.65
+3VSUS on BOTTOM (solid shape): 203.34,102.01 203.34,101.12 203.18,100.97 202.8,100.97 201.43,102.34 201.43,102.7 201.45,102.73 201.48,102.75 202.6,102.75
+3VSUS on BOTTOM (solid shape): outline of 99 points within 203.21,106.36 212,115.22
+3VSUS on IN1 (solid shape): 203.82,108.69 203.82,108.39 202.93,107.5 202.93,106.46 203.86,105.53 205.28,105.53 205.29,105.53 205.39,105.5 205.49,105.51 205.51,105.51 205.53,105.51 207.09,103.94 207.96,103.94 208.09,103.82 208.09,103.08 207.98,102.98 207.01,102.98 206.33,103.66 202.17,103.66 200.36,105.47 200.36,107.19 202.09,108.92 203.59,108.92
+5V on TOP (solid shape): 48.45,69.3 48.45,68.63 48.43,68.61 48.43,68.09 48.24,67.9 48.24,67.49 47.91,67.16 47.07,67.16 46.17,66.26 42.74,66.26 42.43,66.58 42.43,69.04 42.96,69.58 44.65,69.58 44.78,69.44 47.3,69.44 47.61,69.75 47.99,69.75
+5V on TOP (solid shape): 222.74,25.38 223.22,25.38 223.25,25.38 223.51,25.38 223.76,25.12 223.76,24.95 224.51,24.21 224.51,23.7 223.72,22.92 223.05,22.92 222.72,23.25 222.72,23.3 222.39,23.63 221.16,23.63 221.08,23.7 221.08,25.34 221.22,25.48 222.64,25.48
+5V on TOP (solid shape): 28.72,124.86 28.73,124.84 28.73,124.81 28.72,124.79 28.64,124.54 28.75,124.31 28.77,124.24 28.75,124.17 28.49,123.91 28.45,123.9 28.42,123.9 28.27,123.95 28.12,123.94 28.06,123.91 28.01,123.88 26.99,123.88 26.95,123.9 26.95,123.9 26.87,123.95 26.79,123.99 26.64,123.99 26.51,123.94 26.47,123.93 26.44,123.94 26.2,124.19 26.2,125.1 26.33,125.23 28.35,125.23
+5V on TOP (solid shape): 191.65,30.21 191.65,29.24 191.7,29.19 193.29,29.19 193.39,29.1 193.39,29.02 193.31,28.68 193.56,28.44 193.58,28.43 194.03,27.98 198.92,27.98 199.17,27.73 199.17,26.34 199.12,25.91 199.52,25.75 199.61,25.73 199.65,25.65 199.65,23.32 199.37,23.04 196.73,23.04 196.47,23.3 196.46,23.33 196.47,23.37 196.53,23.54 196.5,23.73 196.49,23.8 196.54,23.86 196.74,24.12 196.65,24.43 196.62,24.5 196.65,24.57 196.41,25.18 196.14,24.58 196.17,24.51 196.14,24.44 196.11,24.41 196.08,24.36 196.03,24.34 195.79,24.34 195.51,24.61 195.46,24.62 195.39,24.65 195.36,24.72 195.36,25.46 195.21,25.61 195.21,25.98 195.15,26.04 195.15,26.05 194.94,26.29 194.63,26.28 194.62,26.27 194.46,26.27 194.43,26.3 193.74,26.3 193.67,26.33 193.64,26.4 193.43,26.74 193.04,26.66 192.97,26.63 192.9,26.66 192.52,26.72 192.3,26.4 192.27,26.33 192.2,26.3 191.06,26.3 190.63,26.73 189.7,26.73 189.44,26.98 189.44,27.51 189.66,27.73 190.56,27.73 190.61,27.78 190.61,29.24 190.66,29.29 190.66,29.4 190.66,30.26 190.8,30.4 191.46,30.4
+5V on TOP (solid shape): outline of 380 points within 186.43,6.13 203.16,15.79
+5V on BOTTOM (solid shape): 140.88,25.89 140.88,25.66 140.24,25.02 140.24,23.88 140.13,23.77 139.77,23.77 139.66,23.88 139.66,25.28 140.42,26.04 140.72,26.04
+5V on BOTTOM (solid shape): 223.88,56.9 223.88,55.73 223.56,55.41 221.62,55.41 221.4,55.63 221.4,57 221.55,57.16 223.63,57.16
+5V on BOTTOM (solid shape): 222.06,38.38 222.06,37.17 221.55,36.66 221.55,36.15 221.32,35.92 220.48,35.92 220.33,36.07 220.33,37.04 221.12,37.83 221.12,38.21 221.45,38.54 221.9,38.54
+5V on BOTTOM (solid shape): 225.59,70.92 225.94,70.92 226.3,70.57 226.3,69.53 225.79,69.02 225.79,68.41 225.71,68.33 224.67,68.33 224.49,68.51 224.49,70.67 224.77,70.95 225.56,70.95
+5V on BOTTOM (solid shape): 80.68,86.11 81.57,86.11 81.77,85.91 81.77,81.89 81.64,81.77 79.84,81.77 79.66,81.95 79.66,83.16 79.66,83.32 78.44,84.54 78.44,84.77 80.04,86.37 80.43,86.37
+5V on BOTTOM (solid shape): 48.73,70.77 48.73,67.52 48.42,67.21 47.76,67.21 47.46,67.52 45.42,67.52 45.37,67.57 45.37,68.28 45.45,68.36 47.4,68.36 47.53,68.48 47.53,70.12 47.38,70.27 47.38,70.48 47.36,70.49 47.35,70.52 47.35,70.54 47.21,70.93 46.8,70.92 46.76,70.91 46.73,70.92 46.47,71.19 46.47,72.16 46.57,72.26 47.24,72.26
+5V on BOTTOM (solid shape): 199.19,25.82 199.42,25.73 199.66,25.82 200.45,25.82 201.86,24.41 201.86,20.07 198.97,17.18 198.97,15.62 197.63,14.28 195.42,14.28 195.33,14.34 195.34,14.45 195.43,14.69 195.33,14.92 195.13,15.13 195.13,18.25 195.29,18.42 196.6,18.42 197.06,18.88 197.06,20.54 198.84,22.31 198.84,23.39 198.71,23.52 198.71,23.7 198.65,23.77 198.65,24.73 198.65,24.73 198.65,25.61 198.86,25.82
+5V on BOTTOM (solid shape): 188.18,7.22 200.48,7.22 200.51,7.21 200.53,7.19 200.78,7 201.09,7.09 201.11,7.1 201.15,7.1 201.44,6.81 202.53,6.81 202.54,6.8 202.91,6.8 203.18,6.53 203.18,6.25 203.05,6.12 187.22,6.12 186.97,6.3 186.96,6.32 186.95,6.35 186.9,6.35 186.22,6.83 185.81,7.24 185.81,7.3 185.83,7.33 185.87,7.35 185.89,7.34 186.39,7.64 185.94,8.01 185.85,8.03 185.81,8.11 185.81,8.39 185.89,8.46 186.94,8.46
+5V on BOTTOM (solid shape): outline of 264 points within 16.21,115.8 27.24,125.66
+5V on BOTTOM (solid shape): outline of 309 points within 97.24,52.18 163.79,67.21
+5V on BOTTOM (solid shape): outline of 506 points within 215.54,8.79 226.23,25.94
+5V on SVCC (solid shape): outline of 91 points within 157.82,27.21 194.04,54.95
+5V on IN1 (solid shape): 221.76,39.4 221.8,39.39 221.81,39.35 221.81,37.34 221.54,37.07 220.96,37.07 220.48,37.55 220.48,39.02 220.86,39.4
+5V on IN1 (solid shape): 222.03,56.69 222.03,55.8 221.81,55.58 221.81,54.67 221.8,54.63 221.76,54.62 221.09,54.62 220.81,54.89 220.81,56.7 220.91,56.8 221.92,56.8
+5V on IN1 (solid shape): 80.62,86.07 80.62,85.59 79.08,84.05 78.88,84.05 76.23,86.7 72.37,86.7 71.75,86.07 71.75,85.67 69.33,83.25 69.28,83.2 69.23,83.15 68.58,82.49 68.52,82.45 68.47,82.39 68.25,82.17 63.73,82.17 62.44,80.88 61.17,80.88 61.07,80.98 61.07,84.44 63.43,86.8 68.64,86.8 71.48,89.64 77.05,89.64
+5V on IN1 (solid shape): 36.3,77.65 36.3,76.08 36.05,75.82 34.3,75.82 34.25,75.87 34.23,75.97 34.31,76.04 34.53,76.67 33.91,76.45 33.84,76.36 33.73,76.39 33.54,76.59 33.54,77.63 33.84,77.93 36.03,77.93
+5V on IN1 (solid shape): outline of 167 points within 9.74,103.33 17.36,117.02
+5V on IN1 (solid shape): outline of 611 points within 200.29,5.64 217.28,11.59
+5V on IN2 (solid shape): 40.98,74.86 40.98,73.77 42.17,72.57 42.17,71.18 44.28,69.07 44.28,67.39 43.44,66.55 42.63,66.55 42.27,66.91 42.27,69.09 40.69,70.68 40.69,72.23 39.43,73.49 39.43,74.48 38.16,75.75 35.09,75.75 34.92,75.91 34.92,77.03 35.09,77.2 38.64,77.2
+5V on IN2 (solid shape): outline of 496 points within 47.07,66.99 66.66,82.4
+5V on IN2 (solid shape): outline of 844 points within 214.02,8.9 224.49,24.11
+5V_ALW on BOTTOM (solid shape): 193.77,21.44 193.77,20.7 193.78,20.68 193.78,19.82 193.68,19.71 192.9,19.71 192.67,19.94 192.67,21.62 192.68,21.66 192.72,21.67 193.54,21.67
+5V_CAM on TOP (solid shape): 30.25,131.59 30.25,130.74 29.88,130.38 29.88,130.34 29.65,130.1 29.65,128.69 29.69,128.65 29.72,128.57 29.69,128.5 29.65,128.46 29.63,128.4 29.6,128.37 29.6,127.73 29.5,127.63 29.49,127.63 29.35,127.54 29.26,127.4 29.26,127.39 29.24,127.38 29.24,127.23 28.91,126.9 28.91,126.65 28.89,126.62 28.89,126.58 28.71,126.4 28.71,126.27 28.69,126.23 28.66,126.22 26.98,126.22 26.93,126.27 26.93,127.23 27.01,127.31 27.5,127.31 27.58,127.39 27.63,127.39 27.71,127.31 28.06,127.31 28.24,127.49 28.29,127.5 28.34,127.49 28.38,127.47 28.42,127.45 28.88,127.7 28.61,128.14 28.59,128.14 28.57,128.17 28.57,128.49 28.51,128.55 28.51,128.68 28.56,128.72 28.56,129.08 28.51,129.13 28.51,129.48 28.51,129.49 28.56,129.68 28.51,129.87 28.51,129.88 28.51,130.46 28.54,130.53 28.61,130.56 28.92,130.72 28.94,131.08 28.94,131.09 28.94,131.63 29.19,131.88 29.95,131.88
+5V_HDMIC on BOTTOM (solid shape): 228.56,71.58 228.56,71.07 229.47,70.16 229.47,68.8 229.47,68.79 229.46,68.49 229.6,68.22 230.17,67.66 230.17,67 228.69,65.53 227.31,65.53 227.28,65.54 227.26,65.58 227.11,65.73 227.11,69.32 227.31,69.53 227.31,70.97 226.94,71.34 225.73,71.34 225.61,71.46 225.61,72.32 225.64,72.34 225.64,73.69 225.79,73.84 226.3,73.84
+5V_LED_KBLIGHT on BOTTOM (solid shape): 139.53,17.68 139.53,17 140.35,16.18 140.35,16.16 140.43,16.05 140.55,16.01 140.83,16.01 140.86,16.01 140.89,16.02 140.91,16.02 141.12,15.82 141.12,15.24 141.05,15.15 140.94,15.17 140.87,15.25 140.51,15.25 140.22,14.96 140.22,14.93 140.21,14.9 140.17,14.88 138.7,14.88 138.7,14.87 138.61,14.78 138.59,14.76 138.59,13.97 138.58,13.94 138.56,13.93 138.5,13.9 138.35,13.9 138.31,13.91 138.3,13.95 138.3,14.78 138.1,14.78 138.1,13.95 138.09,13.91 138.05,13.9 137.85,13.9 137.81,13.91 137.8,13.95 137.8,14.78 137.6,14.78 137.6,13.95 137.59,13.91 137.55,13.9 137.27,13.9 137.09,14.08 137.09,14.94 137.58,15.43 137.66,15.43 137.8,15.49 137.86,15.63 137.86,15.93 137.84,16.01 137.79,16.07 137.79,16.54 138.11,16.85 138.11,17.81 138.12,17.85 138.16,17.86 139.35,17.86
+5V_USBP1 on BOTTOM (solid shape): outline of 328 points within 219.77,27.59 228.37,48.65
+5V_USBP1 on IN1 (solid shape): outline of 108 points within 225.98,27.62 228.46,33.36
+5VPCU on TOP (solid shape): 168.56,31.15 168.56,29.19 168.21,28.83 167.72,28.83 167.6,28.96 167.6,29.6 168.41,30.41 168.41,31.15 168.46,31.2 168.51,31.2
+5VPCU on TOP (solid shape): 154.64,30.64 154.64,29.85 155.18,29.32 155.18,28.83 154.95,28.61 154.41,28.61 154.14,28.89 154.14,29.55 154.49,29.9 154.49,30.64 154.54,30.69 154.59,30.69
+5VPCU on TOP (solid shape): 188.58,34.68 188.58,33.42 188.23,33.08 188.12,33.08 187.79,32.75 187.79,32.01 187.77,31.98 187.66,31.98 187.64,32.01 187.64,32.92 187.74,33.03 187.74,33.06 187.8,33.12 187.8,33.38 187.87,33.45 187.87,34.28 187.8,34.35 187.8,34.73 187.89,34.83 188.43,34.83
+5VPCU on TOP (solid shape): 190.61,33 190.61,32.03 190.31,31.73 189.34,31.73 189.09,31.98 188.87,31.98 188.83,32 188.81,32.03 188.81,32.75 188.61,32.75 188.61,32.03 188.6,32 188.56,31.98 188.45,31.98 188.41,32.02 188.41,32.75 188.41,32.77 188.4,32.8 188.42,32.83 188.95,33.36 190.25,33.36
+5VPCU on TOP (solid shape): 7.53,116.21 7.72,116.21 7.76,116.2 7.81,116.19 7.86,116.18 7.91,116.19 7.96,116.2 7.99,116.21 8.43,116.21 8.46,116.2 8.52,116.17 8.58,116.16 8.63,116.16 8.68,116.16 8.7,116.16 8.71,116.15 8.95,115.91 8.95,114.58 9.05,114.48 9.05,111.51 8.7,111.16 7.73,111.16 7.7,111.19 6.76,111.19 6.72,111.19 6.69,111.16 5.75,111.16 5.58,111.32 5.58,111.49 7.7,111.49 7.7,111.69 6.76,111.69 6.76,111.49 5.58,111.49 5.58,111.99 7.7,111.99 7.7,112.19 6.76,112.19 6.76,111.99 5.58,111.99 5.58,112.49 7.7,112.49 7.7,112.69 6.76,112.69 6.76,112.49 5.58,112.49 5.58,112.64 5.57,112.65 5.57,112.99 7.7,112.99 7.7,113.19 6.76,113.19 6.76,112.99 5.57,112.99 5.57,113.49 7.7,113.49 7.7,113.69 6.76,113.69 6.76,113.49 5.57,113.49 5.57,113.82 5.52,113.87 5.52,113.99 7.7,113.99 7.7,114.19 6.76,114.19 6.76,113.99 5.52,113.99 5.52,116.87 5.62,116.97 6.76,116.97
+5VPCU on TOP (solid shape): 221.75,96.83 221.75,96.77 221.74,96.71 221.75,96.64 221.75,96.27 221.75,96.26 221.77,96.09 221.91,95.98 221.92,95.97 221.95,95.94 222.39,95.94 222.94,95.38 222.94,91.95 223.12,91.78 223.12,90.99 223.11,90.95 223.07,90.94 222.9,90.94 222.75,91.08 222.75,91.38 222.44,91.7 222.14,92 220.86,92 220.83,92.01 220.81,92.05 220.81,92.07 220.55,92.33 220.53,92.4 220.5,92.45 220.33,92.59 220.11,92.6 220.1,92.6 219.5,92.6 219.14,92.97 218.71,92.97 218.5,93.07 218.27,93.07 218.24,93.07 218.22,93.09 217.86,93.45 217.86,94.24 217.96,94.33 218.37,94.33 218.55,94.15 218.55,93.58 218.7,93.43 219.51,93.43 219.82,93.12 220.43,93.12 220.56,93.25 220.56,94.77 220.4,94.93 220.4,95.86 221.45,96.91 221.67,96.91
+5VPCU on TOP (solid shape): outline of 1167 points within 189.9,31.5 224.29,82.07
+5VPCU on BOTTOM (solid shape): 187,115.73 187,115.42 187.21,115.22 187.51,115.22 187.61,115.12 187.61,114.76 187.51,114.66 186.37,114.66 186.22,114.81 186.22,115.7 186.37,115.85 186.88,115.85
+5VPCU on BOTTOM (solid shape): 214.58,40.57 214.58,36.68 212.99,35.08 207.78,35.08 206.64,33.94 205.79,33.94 205.5,34.23 205.5,36.87 206.46,37.83 208.25,37.83 211.2,40.77 214.38,40.77
+5VPCU on BOTTOM (solid shape): 6.73,116.83 6.73,116.25 6.89,116.08 7.98,116.08 8.16,115.91 8.16,114.31 8.01,114.15 6.5,114.15 5.94,114.71 5.77,114.71 5.62,114.86 4.25,114.86 4.1,115.02 4.1,116.11 5.14,117.15 6.41,117.15
+5VPCU on BOTTOM (solid shape): 219.03,43.49 219.03,42.25 219.39,41.89 220.89,41.89 221.39,41.38 221.39,39.32 221.04,38.97 217.89,38.97 217.85,38.98 217.84,39.02 217.84,42.4 217.45,42.8 217.45,43.3 217.76,43.62 218.91,43.62
+5VPCU on BOTTOM (solid shape): 142,16.65 142.23,16.53 142.49,16.59 142.6,16.59 142.83,16.36 143.98,16.36 144,16.34 144,16.24 143.98,16.21 142.91,16.21 142.6,15.91 142.05,15.91 141.99,15.85 141.99,15.35 142.02,15.32 142.85,15.32 142.9,15.27 142.9,14.13 142.69,13.92 141.82,13.92 141.22,14.52 141.22,16.58 141.3,16.65
+5VPCU on BOTTOM (solid shape): 219.21,114.58 219.21,113.7 219.28,113.63 219.29,113.6 219.39,113.34 219.65,113.23 219.67,113.23 219.69,113.22 220.61,112.3 220.61,111.94 220.63,111.92 220.64,111.9 220.73,111.75 220.88,111.66 220.89,111.66 221.34,111.21 221.88,111.21 222.39,110.7 222.39,107.17 222.41,107.14 223.78,107.14 224.27,106.66 224.27,105.97 224.02,105.72 222.08,105.72 221.83,105.97 221.83,106.36 220.96,107.22 220.96,109.58 218.96,111.59 218.96,111.99 217.64,113.31 217.64,114.2 218.12,114.69 219.11,114.69
+5VPCU on BOTTOM (solid shape): outline of 90 points within 176.82,108.34 182.53,111.46
+5VPCU on SVCC (solid shape): outline of 953 points within 2.03,6.12 214,117.16
+5VPCU on IN1 (solid shape): 219.19,114.81 219.19,114.18 219.01,114 214.59,114 214.44,114.15 214.44,114.76 214.59,114.92 219.08,114.92
+5VPCU on IN1 (solid shape): outline of 170 points within 187.77,31.45 193.63,36.21
+5VPCU on IN1 (solid shape): outline of 404 points within 214.59,92.39 224.54,109.12
+5VPCU on IN2 (solid shape): outline of 1363 points within 212.28,77.98 222.69,96.12
+VCC_CORE on TOP (solid shape): outline of 3140 points within 77.25,85.2 125.46,116.4
+VCC_CORE on BOTTOM (solid shape): 118.52,110.75 118.52,105.07 118.52,105.06 118.52,104.65 118.37,104.5 117.25,104.5 117.12,104.37 117.06,104.32 117.01,104.26 116.85,104.09 116.85,102.85 116.65,102.65 115.91,102.65 115.55,103 115.55,105.26 115.82,105.53 115.82,106.7 115.9,106.78 115.9,108.25 116.7,109.05 116.7,110.9 117.03,111.23 118.04,111.23
+VCC_CORE on BOTTOM (solid shape): outline of 530 points within 77.59,103.71 100.39,125.63
+VCC_CORE on BOTTOM (solid shape): outline of 1071 points within 113.06,85.26 122.1,88.32
+VCC_CORE on BOTTOM (solid shape): outline of 1085 points within 113.05,95.55 121.3,99.69
+VCC_CORE on SVCC (solid shape): outline of 113 points within 73.24,85.4 121.8,117.05
+VCC_GT on TOP (solid shape): outline of 3577 points within 70.7,85.78 109.13,105.06
+VCC_GT on BOTTOM (solid shape): outline of 2801 points within 68.36,89.16 105.11,105.09
+VCC_IO on TOP (solid shape): 123.43,88.35 123.43,85.91 123.58,85.76 123.58,85.32 123.5,85.25 122.13,85.25 122.08,85.3 122.08,85.6 122.18,85.7 122.28,85.7 122.33,85.71 122.38,85.73 122.49,85.73 122.61,85.86 122.61,88.5 122.63,88.53 122.66,88.55 123.22,88.55
+VCC_IO on BOTTOM (solid shape): 94.45,113.98 94.45,111.23 93.3,110.09 93.3,107.3 92.39,106.38 92.39,102.39 88.32,98.33 84.39,98.33 84.21,98.51 84.21,102.11 84.56,102.47 86.95,102.47 87.5,103.01 88.16,103.48 88.62,104.14 89.29,104.81 89.29,109.5 90.2,110.42 90.2,114.23 90.46,114.48 93.94,114.48
+VCC_IO on BOTTOM (solid shape): 137.77,117.27 137.77,115.68 137.3,115.21 137.3,115.04 137.28,115.02 137.24,114.98 137.21,114.94 137.19,114.89 137.18,114.84 137.17,114.79 137.17,114.74 137.18,114.69 137.19,114.63 136.81,114.25 136.81,114.08 136.72,113.99 136.69,113.98 136.66,113.95 136.63,113.92 136.6,113.89 136.59,113.86 135.65,112.92 134.13,112.92 133.51,113.53 133.51,115.88 135.64,115.88 135.65,115.83 135.66,115.77 135.68,115.73 135.71,115.68 135.74,115.64 135.78,115.6 135.82,115.57 135.87,115.55 135.92,115.53 135.97,115.52 136.03,115.52 136.08,115.53 136.13,115.55 136.18,115.57 136.22,115.6 136.26,115.64 136.29,115.68 136.32,115.73 136.34,115.77 136.35,115.83 136.36,115.88 136.35,115.93 136.34,115.99 136.32,116.03 136.29,116.08 136.26,116.12 136.22,116.16 136.18,116.19 136.13,116.21 136.08,116.23 136.03,116.24 135.97,116.24 135.92,116.23 135.87,116.21 135.82,116.19 135.78,116.16 135.74,116.12 135.71,116.08 135.68,116.03 135.66,115.99 135.65,115.93 135.64,115.88 133.51,115.88 133.51,117.33 133.87,117.68 137.35,117.68
+VCC_IO on BOTTOM (solid shape): outline of 138 points within 122.13,85.24 123.55,87.97
+VCC_IO on BOTTOM (solid shape): outline of 207 points within 111.19,85.19 113,87.76
+VCC_IO on IN1 (solid shape): outline of 1861 points within 90.08,112.35 137.88,119.51
+VCC_IO on IN1 (solid shape): outline of 4732 points within 84.11,84.99 127.64,99.34
+VCC_SA on TOP (solid shape): 124.62,97.87 124.62,97.06 124.48,96.92 124.48,88 124.14,87.66 124.14,86.65 124.03,86.54 123.68,86.54 123.6,86.62 123.6,88.68 123.45,88.83 122.79,88.83 122.61,89.01 122.61,96.22 123.2,96.22 123.2,96.17 123.21,96.12 123.22,96.06 123.25,96.02 123.28,95.97 123.31,95.93 123.35,95.9 123.4,95.87 123.45,95.85 123.5,95.84 123.55,95.84 123.61,95.84 123.66,95.85 123.71,95.87 123.75,95.9 123.8,95.93 123.83,95.97 123.86,96.02 123.89,96.06 123.9,96.12 123.91,96.17 123.91,96.22 123.9,96.27 123.89,96.33 123.86,96.37 123.83,96.42 123.8,96.46 123.75,96.49 123.71,96.52 123.66,96.54 123.61,96.55 123.55,96.55 123.5,96.55 123.45,96.54 123.4,96.52 123.35,96.49 123.31,96.46 123.28,96.42 123.25,96.37 123.22,96.33 123.21,96.27 123.2,96.22 122.61,96.22 122.61,97.72 122.92,98.02 124.47,98.02
+VCC_SA on BOTTOM (solid shape): 122.39,128.65 122.39,124.99 121.56,124.17 121.56,123.23 121.4,123.07 120.38,123.07 120.12,122.81 120.12,122.68 120.12,119.08 119.92,118.88 118.68,118.88 118.5,119.06 116.65,119.06 116.59,119.11 116.59,121.7 116.72,121.82 117.2,121.82 117.53,122.15 117.53,125.46 117.69,125.62 118.97,125.62 119.1,125.75 119.1,125.98 119.43,125.98 119.43,126.56 119.1,126.56 119.1,129.42 119.35,129.67 121.37,129.67
+VCC_SA on BOTTOM (solid shape): outline of 270 points within 123.47,85.57 126.03,88.32
+VCC_SA on BOTTOM (solid shape): outline of 431 points within 121.83,91.98 125.45,98.02
+VCC_SA on SVCC (solid shape): outline of 117 points within 111.46,85.88 126.25,124.99
+VCC_TS on TOP (solid shape): 23.93,132.31 23.95,132.3 23.96,132.29 24.13,132.13 24.14,131.99 24.18,131.88 24.26,131.8 24.27,131.8 24.29,131.77 24.29,131.69 24.27,131.65 24.26,131.64 24.09,131.34 24.26,131.04 24.27,131.03 24.29,130.99 24.29,128.48 24.41,128.36 24.41,128.35 24.67,128.09 24.67,127.28 24.58,127.19 23.78,127.19 23.78,127.16 23.77,127.12 23.73,127.11 22.46,127.11 22.18,127.39 22.18,128.25 23.15,129.22 23.15,129.52 23,129.67 23,131.41 22.89,131.52 22.89,131.55 22.88,131.62 22.85,131.7 22.83,131.74 22.8,131.78 22.8,132.13 22.98,132.31
+VCC_TS on IN1 (solid shape): 24.02,132.33 24.02,130.6 23.94,130.51 23.2,130.51 22.89,130.82 22.89,131.43 22.95,131.63 22.89,131.82 22.89,132.14 23.33,132.57 23.41,132.59 23.76,132.59
+VCCA_XTAL on BOTTOM (solid shape): 141.66,100.19 142.49,100.19 144.08,98.61 144.78,98.61 144.98,98.41 144.98,97.65 144.74,97.4 143.15,97.4 142.88,97.67 142.88,97.97 141.96,98.89 141.95,98.95 142,98.98 142.07,98.98 142.21,99.04 142.26,99.17 142.26,99.47 142.21,99.6 142.07,99.66 141.79,99.66 141.73,99.65 141.65,99.6 141.64,99.6 141.48,99.6 141.47,99.6 141.45,99.61 141.13,99.7 140.81,99.42 140.71,99.45 140.23,99.93 139.68,99.93 139.46,99.71 138.63,99.71 138.42,99.61 138.4,99.59 138.36,99.57 138.32,99.59 138.29,99.62 138.29,99.88 138.41,100.01 139.03,100.01 139.53,100.51 141.34,100.51
+VCCGT_+VCORE on TOP (solid shape): outline of 164 points within 101.33,102.27 104.88,107.55
+VCCGT_+VCORE on TOP (solid shape): outline of 1280 points within 105.65,87.86 113.67,107.06
+VCCGT_+VCORE on BOTTOM (solid shape): outline of 1011 points within 105.19,95.75 112.92,98.01
+VCCGT_+VCORE on IN1 (solid shape): outline of 1701 points within 103.82,95.45 113.27,106.91
+VCCSFR on TOP (solid shape): outline of 918 points within 122.84,95.71 129.71,108.51
+VCCSFR on BOTTOM (solid shape): 124.85,108.26 124.85,107.14 124.44,106.74 122.89,106.74 122.84,106.79 122.84,107.5 123.16,107.82 123.35,107.82 123.38,107.84 123.42,107.83 123.47,107.81 123.52,107.79 123.57,107.78 123.63,107.77 124.09,107.77 124.55,108.23 124.55,108.36 124.56,108.4 124.6,108.41 124.7,108.41
+VCCSFR on IN1 (solid shape): outline of 2502 points within 94.27,94.57 128.38,109.96
+VCCST on TOP (solid shape): 127.29,110.75 127.29,110.32 127.13,110.17 127.13,108.18 126.93,107.97 125.62,107.97 125.43,108.16 125.43,108.59 125.94,109.1 125.94,110.7 126.12,110.88 127.16,110.88
+VCCST on TOP (solid shape): 137.09,113.11 137.09,112.3 137.47,111.92 137.47,110.5 137.45,110.47 136,110.47 135.63,110.84 135.63,111.24 135.27,111.6 135.26,111.66 135.3,111.69 135.4,111.69 135.91,112.21 135.91,112.98 135.79,113.11 135.79,113.24 136.97,113.24
+VCCST on IN1 (solid shape): 137.02,112.44 137.02,111.82 136.58,111.38 134.98,111.38 134.92,111.32 134.85,111.27 134.8,111.2 134.09,110.49 131.9,110.49 131.49,110.08 129,110.08 128.25,109.34 127.64,108.72 126.55,108.72 126.37,108.9 126.37,110.14 126.93,110.7 128.53,110.7 128.65,110.82 128.66,110.82 128.76,110.89 128.83,110.99 128.83,111 128.96,111.13 131.22,111.13 131.61,111.51 133.64,111.51 134.88,112.76 135.68,112.76 136.71,112.76
+VCCSTG on TOP (solid shape): 132.42,112.86 132.42,109.25 132.29,109.12 131.78,109.12 131.61,108.95 130.31,108.95 130.08,109.17 130.08,111.61 131.43,112.96 132.32,112.96
+VCCSTG on BOTTOM (solid shape): 121.98,108.34 121.98,107.96 121.67,107.65 121.67,107.5 121.53,107.36 120.89,107.36 120.8,107.45 120.8,108.4 120.89,108.49 121.83,108.49
+VCCSTG on IN1 (solid shape): 132.6,112.83 132.6,112.2 132.19,111.79 131.35,111.79 130.95,111.38 128.89,111.38 128.85,111.41 128.84,111.42 128.47,111.59 128.17,111.32 128.13,111.18 128.16,111.01 128.15,110.98 128.12,110.96 128.09,110.95 126.83,110.95 126.12,110.25 126.12,110.22 124.7,108.79 122.66,108.79 121.55,107.68 121.14,107.68 120.81,108.01 120.81,108.46 122.21,109.86 123.94,109.86 124.6,110.53 124.66,110.59 124.72,110.67 125.23,111.18 125.52,111.18 126.31,111.97 126.91,111.97 127.01,111.96 127.16,111.97 127.19,112 127.2,112 127.35,112.09 127.44,112.24 127.44,112.25 128.22,113.03 132.4,113.03
+VIN on TOP (solid shape): outline of 1596 points within 113.05,22.69 187.45,34.57
+VIN on BOTTOM (solid shape): 123.5,34.5 123.5,34.04 123.55,33.99 124.52,33.99 124.57,34.04 124.57,34.52 124.65,34.6 125.03,34.6 125.15,34.47 125.15,34.07 125.28,33.94 126.53,33.94 127.19,34.6 132.04,34.6 132.22,34.42 132.22,32.29 131.99,32.06 125.67,32.06 125.27,31.65 123.56,31.65 123.55,31.65 123.13,31.65 123.13,31.65 122.84,31.65 122.03,30.84 112.1,30.84 111.92,31.02 111.92,33.43 112.12,33.63 114.77,33.63 115.11,33.98 115.13,33.99 115.15,33.99 115.24,33.99 115.32,34.01 115.33,34.02 115.45,34.02 115.45,34.01 116.47,34.01 116.47,34.02 116.57,34.02 117.15,34.6 123.4,34.6
+VIN_1.0V_DEEP_SUS on TOP (solid shape): 129.04,128.89 129.04,128.55 129.17,128.43 129.35,128.43 129.35,128.43 130.12,128.43 132.29,128.43 132.31,128.4 132.32,128.38 132.32,127.56 131.45,126.7 122.08,126.7 121.45,127.34 121.45,128.53 121.62,128.71 122.28,128.71 125.05,128.71 125.51,128.25 127.29,128.25 127.49,128.45 127.49,128.91 127.67,129.09 128.84,129.09
+VIN_1.0V_DEEP_SUS on BOTTOM (solid shape): 129.19,128.68 129.73,128.68 129.98,128.43 130.28,128.43 130.44,128.43 130.69,128.68 131.05,128.68 131.33,128.4 131.5,128.4 131.81,128.71 132.16,128.71 132.27,128.61 132.27,128.07 131.81,127.61 131.81,124.14 131.68,124.01 131.1,124.01 131.05,123.96 131.05,123.4 131,123.35 130.84,123.35 130.82,123.37 130.82,123.93 130.74,124.01 130.51,124.01 130.28,124.24 130.28,126.88 129.41,127.75 128.19,127.75 128.05,127.89 128.05,128.25 127.87,128.43 127.72,128.43 127.54,128.61 127.54,129.14 127.77,129.37 128.51,129.37
+VIN_1.8VPCU on TOP (solid shape): 162.24,24.49 162.24,22.03 162.06,21.85 161.48,21.85 161.3,21.67 160.36,21.67 160.13,21.9 160.13,23.45 160.94,24.26 160.94,24.67 161.02,24.74 161.98,24.74
+VIN_1.8VPCU on BOTTOM (solid shape): 160.74,24.47 160.74,23.42 161.58,22.59 161.58,20.91 161.4,20.73 161.4,19.36 161.96,18.8 161.96,17.71 161.7,17.46 160.61,17.46 159.77,18.29 159.77,20.66 160.14,21.02 160.14,23.84 160.31,24.01 160.31,24.34 160.49,24.52 160.69,24.52
+VIN_3VPCU on TOP (solid shape): 183.65,22.87 183.65,21.19 183.29,20.84 181.67,20.84 180.6,21.9 180.6,22.74 180.73,22.87 181.82,22.87 181.95,22.99 183.52,22.99
+VIN_3VPCU on BOTTOM (solid shape): 186.11,28.66 186.11,26.29 184.87,25.05 184.85,25.05 184.63,24.94 184.54,24.71 184.34,24.51 184.34,23.89 183.7,23.26 183.7,21.11 183.37,20.78 182.72,20.78 182.52,20.58 181.77,20.58 181.57,20.38 180.96,20.38 180.88,20.46 180.88,20.96 180.66,21.18 180.36,21.18 179.94,21.6 179.94,21.72 179.99,21.77 180.6,21.77 180.65,21.82 180.65,21.93 180.6,21.98 180.56,21.98 180.56,21.98 180.01,21.98 179.92,22.08 179.92,22.18 179.94,22.2 180.6,22.2 180.63,22.23 180.63,22.43 180.6,22.46 179.97,22.46 179.92,22.51 179.92,22.64 179.97,22.69 180.58,22.69 180.68,22.79 180.68,22.84 180.6,22.92 179.99,22.92 179.92,22.99 179.92,23.07 179.97,23.12 180.91,23.12 181.22,23.43 181.48,23.53 181.58,23.8 182.13,24.34 182.13,28.1 182.81,28.78 185.99,28.78
+VIN_5VPCU on TOP (solid shape): outline of 313 points within 187.29,20.06 195.11,26.93
+VIN_5VPCU on BOTTOM (solid shape): 190.14,23.99 190.14,21.91 189.21,20.98 189.21,20.63 188.63,20.05 188.63,19.41 188.58,19.36 188.58,18.85 188.45,18.73 187.82,18.73 187.69,18.85 187.69,19.87 187.31,20.24 187.31,20.38 187.3,20.45 187.27,20.51 187.27,23.89 187.51,24.14 188.04,24.14 188.53,24.62 189.51,24.62
+VIN_BLIGHT on TOP (solid shape): 47.13,129.47 47.13,128.58 47.3,128.4 47.3,125.84 46.85,125.38 45.58,125.38 45.49,125.47 45.49,126.08 45.73,126.32 45.73,126.95 46.17,127.39 46.17,129.47 46.4,129.7 46.9,129.7
+VIN_BLIGHT on BOTTOM (solid shape): 49.08,128.99 49.08,125.2 48.67,124.8 46.82,124.8 46.38,125.24 46.38,126.65 46.69,126.96 46.69,127.13 46.95,127.39 46.95,129.06 47.07,129.19 48.88,129.19
+VIN_CPU_GPU on BOTTOM (solid shape): outline of 632 points within 68.72,34.12 126.4,85.48
+VIN_DDR on TOP (solid shape): 152.43,23.04 152.43,22.23 152.26,22.05 151.65,22.05 151.14,22.56 149.51,22.56 149.16,22.92 148.04,22.92 147.94,23.02 147.94,23.5 148.12,23.68 151.8,23.68
+VIN_DDR on BOTTOM (solid shape): 154.67,28.61 154.7,28.59 154.72,28.55 154.72,27.34 154.71,27.26 154.72,27.17 154.72,26.14 154.53,25.95 153.89,25.95 153.73,25.79 153.73,24.28 153.3,23.85 153.3,21.88 153.22,21.8 152.64,21.8 152.54,21.9 152.13,21.9 151.67,22.36 149.66,22.36 148.9,23.12 148.9,25.66 149.21,25.96 149.94,25.96 150.99,27.01 150.99,28.33 151.27,28.61
+VIN_VCC_CORE on TOP (solid shape): outline of 942 points within 54.26,93.78 121.14,129.75
+VIN_VCC_CORE on BOTTOM (solid shape): 56.09,129.27 56.09,127.34 54.25,125.49 51.91,125.49 51.77,125.63 51.77,129.01 52.23,129.47 55.89,129.47
+VIN_VCC_CORE on BOTTOM (solid shape): 60.89,101.74 60.89,101.19 60.63,100.93 60.08,100.93 59.98,100.82 59.98,98.56 60.89,97.64 60.89,97.11 71.51,86.49 71.51,85.84 72.03,85.32 72.03,85.18 70.26,83.42 69.5,83.42 69.43,83.34 69.38,83.34 67.7,81.66 67.7,81.37 67.72,81.34 67.72,81.13 67.9,80.96 67.9,78.84 67.32,78.26 67.32,76.71 67.2,76.59 63.68,76.59 63.25,77.01 63.25,82.56 61.26,84.55 61.26,87.79 61.03,88.02 59.06,88.02 58.73,88.35 58.73,91.01 58.89,91.17 58.89,92.36 57.09,94.15 57.09,98.16 56.75,98.51 56.65,98.51 56.55,98.61 56.55,100.51 56.56,100.52 56.56,101.66 56.76,101.87 60.76,101.87
+VIN_VCC_CORE on BOTTOM (solid shape): 65.61,122.08 65.61,121.23 65.39,121.01 65.39,116.46 65.31,116.39 64.5,116.39 64.31,116.58 64.31,118.46 64.17,118.6 63.28,118.6 63.18,118.5 63.18,117.23 62.9,116.95 62.19,116.95 61.98,116.74 61.98,115.68 62.21,115.45 62.97,115.45 63.28,115.75 63.58,115.75 63.78,115.56 63.78,112.82 64.19,112.4 64.78,112.4 65.39,111.79 65.39,111.69 65.39,107.65 65.25,107.51 64.33,107.51 64.24,107.6 64.24,109.33 64.12,109.45 63.18,109.45 63.13,109.4 63.13,108.62 62.95,108.44 62.44,108.44 62.09,108.79 62.09,112.2 61.45,112.83 59.75,112.83 58.48,114.1 58.48,121.9 58.81,122.23 65.46,122.23
+VIN_VCC_CORE on BOTTOM (solid shape): 106.08,123.68 111.06,123.68 111.21,123.53 111.21,122.28 111.82,121.67 111.82,120.25 111.26,119.69 107.69,119.69 107.17,120.21 100.94,120.21 100.77,120.38 100.77,120.65 110.09,120.65 110.09,120.6 110.1,120.55 110.12,120.5 110.15,120.45 110.18,120.41 110.22,120.37 110.27,120.34 110.31,120.32 110.37,120.3 110.42,120.3 110.47,120.3 110.52,120.3 110.58,120.32 110.62,120.34 110.67,120.37 110.71,120.41 110.74,120.45 110.77,120.5 110.79,120.55 110.8,120.6 110.8,120.65 110.8,120.71 110.79,120.76 110.77,120.81 110.74,120.85 110.71,120.9 110.67,120.93 110.62,120.96 110.58,120.98 110.52,121 110.47,121.01 110.42,121.01 110.37,121 110.31,120.98 110.27,120.96 110.22,120.93 110.18,120.9 110.15,120.85 110.12,120.81 110.1,120.76 110.09,120.71 110.09,120.65 100.77,120.65 100.77,123.14 101.51,123.88 105.88,123.88
AGND on TOP (solid shape): 222.21,16.16 222.21,15.73 221.12,14.64 220.91,14.64 220.89,14.66 220.89,15.6 220.96,15.68 221.19,15.68 221.78,16.26 222.1,16.26
AGND on TOP (solid shape): 225.71,10.55 225.71,9.56 226.14,9.12 226.14,8.39 225.99,8.23 224.7,8.23 224.24,7.78 224.24,6.41 224.11,6.28 223.05,6.28 222.87,6.46 222.87,6.81 223.4,7.35 223.4,7.75 224.06,8.41 224.06,9.84 224.16,9.94 225.03,9.94 225.11,10.02 225.11,10.6 225.15,10.65 225.61,10.65
AGND on TOP (solid shape): 228.14,23.44 228.14,22.8 228.23,22.71 229.37,22.71 229.83,23.17 231.63,23.17 231.76,23.04 231.76,22.71 231.68,22.64 231.2,22.64 231,22.43 231,21.82 230.92,21.75 227.87,21.75 227.64,21.98 227.64,22.61 227.52,22.74 227.52,23.5 227.59,23.58 228,23.58
AGND on TOP (solid shape): 227.95,19.74 228.46,19.74 228.6,19.6 228.41,18.8 228.89,18.12 228.89,13.41 228.43,12.28 229.4,11.53 231.25,11.53 231.25,11.49 231.38,11.36 231.38,10.47 231.25,10.34 229.47,10.34 229.4,10.34 228.45,10.58 227.72,11.23 227.72,13.5 227.8,13.6 227.88,13.7 227.88,17.84 227.47,18.55 227.39,19.37 227.76,19.74 227.95,19.74
AGND on TOP (solid shape): 226.42,23.5 226.42,22.94 226.26,22.78 226.24,22.77 226.21,22.76 225.92,22.7 225.78,22.44 225.74,22.36 225.65,22.35 225.37,22.3 225.21,22.07 225.21,22.05 225.18,22.03 225.08,22.03 224.93,21.88 224.93,21.08 225.03,20.97 225.03,20.67 225.04,20.67 225.04,18.2 224.8,17.96 224.8,17.73 224.7,17.64 224.67,17.63 224.63,17.64 224.6,17.65 224.46,17.65 224.32,17.65 224.18,17.59 224.12,17.44 224.11,17.34 224.1,17.29 224.1,17.18 224.09,17.14 224.05,17.12 223.96,17.13 223.66,17.13 223.5,17.12 223.5,17.12 223.36,17.12 223.21,17.06 223.15,16.92 223.15,16.8 223.14,16.76 223.1,16.74 222.8,16.74 222.65,16.59 222.44,16.59 222.28,16.74 222.28,17.8 222.39,17.91 223.63,17.91 223.86,18.14 223.86,22.71 224.7,23.55 226.37,23.55
AGND on BOTTOM (solid shape): 222.44,12.73 222.44,12.05 222.38,11.87 222.44,11.68 222.44,11.18 222.99,10.62 222.99,7.65 222.51,7.17 221.6,7.17 221.52,7.21 221.51,7.31 221.55,7.48 221.5,7.66 221.4,7.76 221.27,7.82 221.25,7.82 221.13,7.95 220.76,7.95 220.3,8.41 220.3,8.78 220.01,9.07 220.01,9.39 221.29,10.67 221.29,12.71 221.37,12.78 222.39,12.78
AGND on BOTTOM (solid shape): 226.13,23.08 226.13,22.8 226.11,22.77 226.09,22.77 225.78,22.42 226.09,22.06 226.12,22.05 226.13,22.01 226.13,21.2 225.96,21.03 225.94,21.02 225.91,21.02 225.6,20.97 225.45,20.7 225.42,20.63 225.35,20.6 224.54,20.6 224.49,20.55 224.49,18.32 224.8,18.01 224.8,17.73 223.58,16.52 222.97,16.52 221.65,15.19 221.24,15.19 220.81,15.63 220.81,15.88 221.14,16.21 221.14,16.67 222.26,17.79 223.48,17.79 223.93,18.24 223.93,22.71 224.52,23.3 225.92,23.3
