# Allegro board dax8jmb16e0-e-www.DeviceDB.xyz_.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_ODT0: length 64.2
  IN1 w0.079: v1(108.7,83.75) 108.26,83.31 108.26,82.07 109.18,81.16 109.18,80.48 110.16,79.49 110.16,78.74
  IN1 w0.165: 110.16,78.74 110.17,78.73 110.17,71.89 109.91,71.63 109.91,70.67 108.8,69.56 108.8,58.87 106.38,56.46 106.38,56.32 106.96,55.74 106.96,55.4 106.72,55.16 106.43,55.16 105.95,55.63 105.55,55.63 101.56,51.63 98.79,51.63 96.07,48.91 94.71,48.91 90.28,44.47 90.28,40.21 90.45,40.04 90.83,40.04 90.99,40.21 90.99,41 v2(90.82,41.18)
  BOTTOM w0.079: v1(108.7,83.75) 108.43,83.48 108.43,83.4 U400.AE31
  BOTTOM w0.127: v2(90.82,41.18) 89.87,42.12 89.87,43.93 89.6,44.2 JDIM2800.155
M_A_ODT1: length 63
  IN1 w0.079: 109.98,80.69 109.58,81.08 109.58,81.64 109.15,82.07 109.15,82.65 108.7,83.1 v1(108.7,83.1)
  IN1 w0.165: 109.98,80.69 111.11,79.56 111.11,78.24 111.51,77.83 111.51,71.42 110.16,70.06 110.16,59.05 109.83,58.72 109.83,58.49 110.62,57.69 110.62,57.46 110.39,57.23 110.16,57.23 109.36,58.02 109.13,58.02 108.89,57.79 108.89,57.55 109.69,56.76 109.69,56.52 109.46,56.29 109.22,56.29 108.43,57.09 108.19,57.09 107.96,56.85 107.96,56.57 108.92,55.61 108.92,55.07 107.94,54.09 105.2,54.09 99.18,48.07 95.06,48.07 91.47,44.48 91.47,43.32 91.64,43.16 91.65,43.16 v2(91.96,42.86)
  BOTTOM w0.079: U400.AF31 108.82,83.22 v1(108.7,83.1)
  BOTTOM w0.127: JDIM2800.161 91.1,44.24 91.45,43.9 91.45,43.36 v2(91.96,42.86)
M_A_PARITY: length 55.6
  IN1 w0.165: v2(86.11,44.07) 86.18,44.14 86.18,45.81 93.06,52.68 94.48,52.68 103.25,61.45 103.25,61.99 102.8,62.44 102.8,62.72 102.99,62.91 103.27,62.91 103.75,62.43 104.04,62.43 104.25,62.64 104.25,62.93 103.78,63.4 103.78,63.67 103.97,63.86 104.25,63.86 104.52,63.59 104.72,63.59 104.83,63.71 104.83,69.64 106.59,71.39 106.59,74.1 106.64,74.15 106.64,79.15 103.74,82.05 103.74,82.56 v1(104.16,82.98)
  BOTTOM w0.079: v1(104.16,82.98) 104.4,83.22 U400.W31
  BOTTOM w0.127: JDIM2800.143 84.6,44.21 84.74,44.07 v2(86.11,44.07)
M_A_RAS#: length 57.5
  IN1 w0.079: v1(105.06,82.44) 105.25,82.25 105.46,82.25 108.21,79.5 108.21,76.21
  IN1 w0.165: v2(88.67,38.36) 88.36,38.67 88.04,38.99 88.04,41.47 87.28,42.23 87.28,45.13 93.58,51.43 95,51.43 106.09,62.51 106.09,69.55 107.77,71.22 107.77,74.21 108.21,74.66 108.21,76.21
  BOTTOM w0.079: U400.Y32 105.19,82.57 v1(105.06,82.44)
  BOTTOM w0.127: JDIM2800.152 88.85,38.18 v2(88.67,38.36)
M_A_WE#: length 60.7
  IN1 w0.079: v1(106.87,83.07) 106.41,82.61 106.41,81.87 108.47,79.81 108.51,79.81 108.89,79.43 108.89,78.75
  IN1 w0.165: v2(88.69,43.9) 88.69,45.35 93.93,50.59 95.38,50.59 101.18,56.39 101.54,56.39 101.84,56.09 102.1,56.09 102.27,56.25 102.27,56.52 101.94,56.85 101.94,57.15 102.15,57.36 102.38,57.36 103.3,56.44 103.54,56.44 103.77,56.67 103.77,56.9 102.85,57.83 102.85,58.06 103.08,58.29 103.32,58.29 104.24,57.37 104.47,57.37 104.71,57.6 104.71,57.84 103.78,58.76 103.78,58.99 104.08,59.29 104.3,59.29 105.23,58.36 105.46,58.36 106.93,59.83 106.93,69.49 108.34,70.9 108.34,73.61 108.89,74.16 108.89,78.75
  BOTTOM w0.079: v1(106.87,83.07) 107.02,83.22 U400.AC31
  BOTTOM w0.127: JDIM2800.151 88.6,44.28 88.69,44.19 v2(88.69,43.9)
M_B_A0: length 92.8
  IN2 w0.079: 111.79,67.65 111.79,67.65 111.11,68.33 111.11,73.74 110.95,73.9 v1(110.6,73.9)
  IN2 w0.165: 111.79,67.65 112.33,65.19 112.8,63.51 112.86,63.28 113.3,61.68 126.55,48.44 140.33,48.44 141.91,46.86 149.7,46.86 151.08,45.48 156.37,45.48 157.5,44.36 161.2,44.36 161.37,44.19 161.37,42.97 161.3,42.91 161.3,42.58 161.3,42.57 161.3,41.69 161.3,41.69 161.3,40.37 162.97,38.69 162.97,38.2 161.94,37.16 161.94,36.68 161.77,36.52 161.54,36.52 161.37,36.68 161.37,37.13 161.23,37.27 161.01,37.27 160.88,37.14 160.88,36.38 160.72,36.21 160.48,36.21 160.32,36.38 160.32,37.58 160.61,37.88 161.6,37.88 161.93,38.21 161.93,38.81 v2(161.82,38.93)
  BOTTOM w0.079: U400.AG36 109.55,80.03 109.7,79.88 109.81,79.67 109.81,79.15 109.89,79.07 109.89,75.24 110.24,74.89 110.24,74.26 v1(110.6,73.9)
  BOTTOM w0.127: v2(161.82,38.93) JDIM2801.144
M_B_A1: length 96.1
  IN2 w0.079: v1(110.63,71.99) 110.93,71.69 110.93,67.92 111.31,67.53 111.31,67.36
  IN2 w0.165: 111.31,67.36 112.36,63.51 112.68,62.31 112.84,61.7 112.94,61.45 126.37,48.02 135.81,48.02 135.94,47.89 135.94,46.64 136.14,46.44 136.31,46.44 136.43,46.57 136.43,47.82 136.63,48.02 136.8,48.02 136.95,47.87 136.95,46.57 137.08,46.44 137.33,46.44 137.45,46.57 137.45,47.89 137.57,48.02 137.78,48.02 137.94,47.85 137.94,46.57 138.07,46.44 138.33,46.44 138.45,46.57 138.45,47.89 138.57,48.02 138.82,48.02 138.95,47.89 138.95,46.57 139.07,46.44 139.32,46.44 139.44,46.57 139.44,47.89 139.56,48.02 139.81,48.02 139.94,47.89 139.94,46.57 140.06,46.44 140.28,46.44 140.44,46.61 140.44,47.25 140.57,47.38 140.8,47.38 140.97,47.21 140.97,46.61 141.13,46.44 149.52,46.44 150.9,45.06 156.2,45.06 157.32,43.95 159.14,43.95 159.41,43.68 159.41,42.99 v2(159.3,42.88)
  BOTTOM w0.079: 109.43,78.72 109.43,79.05 109.29,79.19 109.29,79.67 109.32,79.76 109.32,80.03 109.29,80.13 109.29,80.34 109.32,80.46 109.32,80.48 109.55,80.7 U400.AG35
  BOTTOM w0.127: v2(159.3,42.88) 159.3,42.99 159.61,43.3 159.61,43.48 159.46,43.63 159.27,43.63 158.95,43.31 158.66,43.31 158.53,43.44 158.53,43.59 159.07,44.13 JDIM2801.133 ; v1(110.63,71.99) 110.45,71.81 110.19,71.81 109.43,71.05 108.87,71.05 108.49,71.43 108.49,71.99 109.43,72.93 109.43,78.72
M_B_A2: length 96
  IN2 w0.079: 104.64,69.91 104.64,70.06 104.76,70.19 104.76,70.92 104.88,71.05 104.88,71.76 106.51,73.39 106.51,75.27 v1(107.32,76.08)
  IN2 w0.165: 104.64,69.91 104.64,65.06 105.41,61.22 106.53,58.45 107.37,57 107.56,56.66 119.46,44.76 119.6,44.06 119.93,43.23 120.04,43.05 121.89,40.62 122.99,39.32 123.94,38.67 125.43,37.97 131.86,36.87 150.8,36.87 151.4,37.47 151.72,37.47 152.1,37.85 155.66,37.85 156.64,36.87 159.24,36.87 159.48,37.11 159.48,37.35 159.32,37.51 158.41,37.51 157.86,38.06 157.86,39.32 158.06,39.51 158.74,39.51 v2(158.9,39.35)
  BOTTOM w0.079: U400.AF34 108.5,80.8 108.5,80.13 108.47,80.04 108.47,79.83 108.48,79.78 108.51,79.7 108.51,76.96 108.42,76.87
  BOTTOM w0.127: v1(107.32,76.08) 107.6,75.8 108.14,75.8 108.31,75.98 108.31,76.76 108.42,76.87 ; v2(158.9,39.35) 158.9,38.83 158.82,38.74 JDIM2801.132
M_B_A3: length 95.6
  IN2 w0.079: 110.07,70.95 109.98,71.04 109.98,71.8 110.04,71.86 110.19,71.86 110.26,71.92 110.26,72.2 110.42,72.37 110.75,72.37 110.8,72.42 110.8,72.57 v1(110.63,72.75)
  IN2 w0.165: v2(158.64,42.86) 158.64,43.34 158.44,43.54 158.21,43.54 158.02,43.35 158.02,42.96 157.82,42.75 157.26,42.75 157.1,42.92 157.1,43.15 157.18,43.24 157.18,43.49 156.37,44.3 156.26,44.3 156.09,44.14 156.09,43.95 155.96,43.82 155.71,43.82 155.54,43.99 155.54,44.52 155.41,44.65 150.73,44.65 149.35,46.02 135.63,46.02 135.47,46.19 135.47,47.47 135.34,47.6 135.12,47.6 134.95,47.43 134.95,46.15 134.83,46.02 134.58,46.02 134.46,46.15 134.46,47.48 134.34,47.6 134.16,47.6 133.94,47.38 133.94,46.24 133.77,46.07 133.6,46.07 133.44,46.22 133.44,47.43 133.27,47.59 133.04,47.59 132.88,47.43 132.88,47.07 132.75,46.95 132.57,46.95 131.92,47.6 126.2,47.6 112.43,61.37 112.28,61.91 111.83,63.51 110.71,67.51 110.57,67.64 110.57,67.95 110.3,68.23 110.3,68.46 110.57,68.74 110.57,68.9 110.45,69.02 110.14,69.02 110.02,69.14 110.02,69.32 110.14,69.44 110.45,69.44 110.57,69.56 110.57,69.74 110.45,69.86 110.14,69.86 110.02,69.98 110.02,70.16 110.14,70.28 110.45,70.28 110.57,70.4 110.57,70.67 110.42,70.82 110.19,70.82 110.07,70.95
  BOTTOM w0.079: U400.AG37 109.64,79.48 109.64,79.08 109.69,79.03 109.69,78.77
  BOTTOM w0.127: JDIM2801.131 158.57,44.15 158.09,43.67 158.09,42.01 158.3,41.79 158.51,41.79 158.64,41.92 v2(158.64,42.86) ; v1(110.63,72.75) 110.63,72.51 110.43,72.32 110.22,72.32 109.43,71.53 109.17,71.53 108.97,71.74 108.97,71.95 109.71,72.7 110.13,72.7 110.25,72.83 110.25,73.02 110.11,73.16 109.81,73.16 109.69,73.29 109.69,73.47 109.81,73.6 110.08,73.6 110.2,73.72 110.2,73.9 110.08,74.03 109.81,74.03 109.69,74.16 109.69,74.35 109.77,74.44 109.94,74.44 110.05,74.55 110.05,74.73 109.93,74.86 109.81,74.86 109.69,74.99 109.69,78.77
M_B_A4: length 94.6
  IN2 w0.165: v1(107.65,78.39) 106.76,77.5 105.76,77.5 105.6,77.34 105.6,73.46 105.11,72.66 104.64,71.88 104.52,71.46 104.22,69.92 104.22,64.92 104.51,63.51 105.01,61.1 106.15,58.27 107.2,56.43 118.96,44.67 119.07,44.1 119.27,43.57 119.76,42.68 121.64,40.24 122.31,39.41 122.71,39.01 122.74,38.99 123.83,38.23 125.35,37.55 125.67,37.47 126.81,37.26 131.8,36.46 131.83,36.45 150.94,36.45 151.57,37.08 151.84,37.08 152.23,37.47 155.41,37.47 156.42,36.45 159.67,36.45 159.9,36.68 159.9,37.63 158.47,39.06 v2(158.33,39.06)
  BOTTOM w0.079: v1(107.65,78.39) 108,78.74 108,79.15 107.83,79.33 107.83,79.75 107.9,79.87 107.9,80.52 U400.AE35
  BOTTOM w0.127: JDIM2801.128 157.82,38.55 v2(158.33,39.06)
M_B_A5: length 94.5
  IN2 w0.079: v1(107.32,75.49) 106.77,74.95 106.77,73.31 105.32,71.86 105.32,71.04 105.06,70.77 105.06,69.86
  IN2 w0.165: v2(157.11,39.19) 157.45,38.86 157.45,37.43 157.28,37.27 156.81,37.27 156.68,37.39 156.68,38.11 156.56,38.23 152,38.23 151.67,37.9 151.24,37.9 150.63,37.29 131.89,37.29 125.51,38.42 124.37,38.93 123.41,39.55 122.63,40.4 121.99,41.32 121.48,42.35 121.48,43.34 107.99,56.83 107.68,57.31 107.49,57.63 106.77,58.97 105.81,61.34 105.06,65.42 105.06,69.86
  BOTTOM w0.079: U400.AF35 108.67,80.32 108.67,80.1 108.63,80 108.63,79.86 108.67,79.72 108.67,76.87 108.62,76.81 108.62,76.68
  BOTTOM w0.127: v1(107.32,75.49) 107.86,75.49 108.09,75.27 108.09,74.45 107.93,74.3 107.5,74.3 107.37,74.17 107.37,74 107.55,73.82 108.49,73.82 108.62,73.94 108.62,76.68 ; JDIM2801.126 157.32,38.03 157.54,38.25 157.54,38.76 v2(157.11,39.19)
M_B_A6: length 94.4
  IN2 w0.079: 105.48,69.91 105.48,70.64 105.67,70.84 105.67,71.87 106.94,73.14 106.94,74.02 107.68,74.76 107.68,76.48 v1(107.53,76.64)
  IN2 w0.165: v2(157.96,40.66) 158.34,40.28 158.34,40.05 158.22,39.93 157.84,39.93 157.56,39.65 156.96,39.65 156.5,39.2 155.86,39.2 155.68,39.38 155.27,39.38 155.06,39.17 155.06,38.88 154.75,38.56 151.9,38.56 151.6,38.26 151,38.26 150.46,37.71 132.13,37.71 131.71,37.77 130.68,37.95 130.19,38.44 129.96,38.44 129.72,38.2 129.46,38.2 129.29,38.37 129.29,39.8 128.99,40.11 128.62,40.11 128.33,39.82 128.33,38.61 128.11,38.39 125.65,38.82 125.6,38.84 125.34,38.97 124.99,39.32 124.65,39.32 124.11,39.59 123.91,39.72 123.76,39.88 122.82,40.91 122.69,41.09 122.28,41.76 121.9,42.52 121.9,43.51 108.36,57.05 108.03,57.66 107.29,59.06 106.98,59.62 106.22,61.46 105.48,65.46 105.48,69.91
  BOTTOM w0.079: 108.31,77.83 108.31,78.14 108.34,78.16 108.34,79.29 108.25,79.38 U400.AE37
  BOTTOM w0.127: 108.31,77.83 108.31,77.25 108.09,77.02 108.09,76.23 107.96,76.1 107.78,76.1 107.7,76.18 107.7,76.46 v1(107.53,76.64) ; JDIM2801.127 157.57,44.33 157.31,44.07 157.31,41.32 v2(157.96,40.66)
M_B_A7: length 94.2
  IN2 w0.079: v1(106.88,84.32) 106.33,83.78 106.33,82.81 106.1,82.58 106.1,82.1
  IN2 w0.165: 106.1,82.1 106.1,80.37 106.23,80.24 106.71,80.24 106.89,80.07 106.89,79.84 106.76,79.71 106.21,79.71 106.1,79.61 106.1,79.33 106.23,79.21 107.12,79.21 107.25,79.09 107.25,78.91 107.12,78.79 106.25,78.79 105.19,77.73 105.19,73.5 104.68,72.9 104.24,71.59 103.8,69.12 103.8,64.87 104.08,63.51 104.6,60.97 105.11,59.72 105.77,58.1 106.27,57.12 106.58,56.46 118.54,44.5 118.72,43.7 118.94,43.23 119.23,42.6 121.94,39.19 122.43,38.7 122.49,38.65 123.61,37.87 123.97,37.67 125.34,37.1 129.6,36.33 131.8,36.04 151.1,36.04 151.68,36.62 151.94,36.62 152.48,37.17 155.08,37.17 v2(156.52,35.72)
  BOTTOM w0.079: v1(106.88,84.32) 107.08,84.52 U400.AC29
  BOTTOM w0.127: v2(156.52,35.72) 156.32,35.93 JDIM2801.122
M_B_A8: length 94.1
  IN2 w0.079: v1(107.65,77.81) 107.83,77.81 107.93,77.7 107.93,74.63 107.12,73.82 107.12,73.08 106.05,72.01 106.05,70.72 105.89,70.56 105.89,70.05
  IN2 w0.165: 105.89,70.05 105.89,65.5 106.62,61.58 107.36,59.8 107.97,58.71 108.71,57.29 122.32,43.68 122.32,42.63 122.5,42.3 122.66,42.14 122.82,42.14 122.99,41.97 122.99,41.44 123.11,41.22 124.27,40 124.75,39.83 125.31,39.83 125.63,39.85 126.02,40.24 126.18,40.24 126.35,40.07 126.35,39.41 126.69,39.07 127.16,39.07 127.41,39.32 127.41,40.09 127.26,40.24 127.26,40.52 127.38,40.63 129.06,40.63 129.44,40.25 129.91,40.25 130.31,39.85 130.31,38.94 130.54,38.71 130.96,38.42 131.51,38.23 132.34,38.13 150.28,38.13 150.82,38.66 151.55,38.66 151.78,38.89 154.45,38.89 154.62,39.06 154.62,39.57 154.78,39.73 155.1,39.73 155.29,39.92 155.81,39.92 155.97,39.75 155.97,39.67 156.09,39.55 156.32,39.55 156.88,40.11 157.33,40.11 157.49,40.28 157.49,40.54 157.37,40.66 v2(156.89,40.66)
  BOTTOM w0.079: 108.1,78.24 108.1,78.38 108.17,78.45 108.17,79.22 108.05,79.34 107.99,79.4 107.99,79.7 108.06,79.82 108.06,80.14 108.14,80.22 U400.AE36
  BOTTOM w0.127: v2(156.89,40.66) 156.89,41.67 156.52,42.04 156.52,42.68 157.04,43.19 157.04,44.18 157.07,44.21 JDIM2801.125 ; 108.1,78.24 108.1,77.67 108.01,77.58 107.78,77.58 107.65,77.7 v1(107.65,77.81)
M_B_A9: length 90.9
  IN2 w0.079: 106.31,70.13 106.31,72.02 107.42,73.13 107.42,73.87 108.1,74.55 108.1,78.59 108.03,79 107.94,79.24 107.93,79.26 106.95,80.96 106.54,81.97 106.5,82.2 106.5,83.11 106.58,83.29 v1(106.88,83.69)
  IN2 w0.165: 106.31,70.13 106.31,65.53 107.03,61.7 107.74,59.98 108.34,58.91 108.95,57.73 109.08,57.51 122.81,43.78 122.81,42.87 123.43,42.24 124.32,42.24 124.57,42.49 125.54,42.49 126.97,41.05 129.23,41.05 129.61,40.67 130.09,40.67 130.53,40.23 130.99,40.23 131.3,39.93 131.3,38.95 131.61,38.64 132.39,38.55 150.07,38.55 151.11,39.59 151.71,39.59 152.08,39.22 153.63,39.22 154.17,39.77 154.9,40.24 155.51,40.24 155.67,40.3 v2(156.26,40.66)
  BOTTOM w0.079: U400.AB29 106.51,84.23 106.6,84.1 106.65,84.05 v1(106.88,83.69)
  BOTTOM w0.127: JDIM2801.121 156.07,44.2 v2(156.26,40.66)
M_B_A10: length 94.5
  IN2 w0.079: 112.25,67.29 112.25,67.59 111.31,68.53 111.31,74.58 110.84,75.05 v1(110.57,75.05)
  IN2 w0.165: 112.25,67.29 113.25,63.51 113.65,62 113.69,61.88 126.72,48.86 140.51,48.86 142.08,47.28 149.87,47.28 151.25,45.9 156.55,45.9 157.56,44.89 161.58,44.89 161.78,44.68 161.78,41.78 162.2,41.36 162.2,40.06 163.39,38.87 163.39,38.73 163.56,38.56 163.7,38.56 163.86,38.4 163.86,38.19 163.7,38.02 163.39,38.02 162.58,37.21 162.35,36.99 162.35,36.24 162.52,36.08 163.04,36.08 163.2,36.24 163.2,37.15 163.43,37.38 163.64,37.38 163.74,37.28 163.74,36.19 163.91,36.02 164.14,36.02 164.32,36.19 v2(164.32,38.4)
  BOTTOM w0.079: U400.AG34 109.55,81.31 109.78,81.08 109.8,81.06 109.8,80.04 109.97,79.73 109.98,79.72 109.98,79.22 110.06,79.14 110.06,75.56 v1(110.57,75.05)
  BOTTOM w0.127: JDIM2801.146 v2(164.32,38.4)
M_B_A11: length 94.2
  IN2 w0.079: 103.38,69.31 103.93,71.57 104.38,73.18 104.86,73.67 104.86,78.19 105.57,78.9 105.57,84.56 105.65,84.64 106.59,84.64 v1(106.86,84.91)
  IN2 w0.165: v2(155.82,35.71) 154.99,36.53 154.26,36.53 154.06,36.73 152.64,36.73 152.13,36.23 151.82,36.23 151.21,35.62 131.78,35.62 130.94,35.7 128.03,36.15 125.24,36.69 125.16,36.71 124.04,37.15 123.03,37.71 120.87,39.21 120.6,39.41 120.47,39.53 119.07,42.03 118.27,42.83 118.27,43.06 118.35,43.14 118.35,43.38 118.19,43.54 117.87,43.54 117.65,43.76 117.65,43.99 117.94,44.28 117.94,44.5 117.78,44.66 117.55,44.66 117.36,44.47 117.12,44.47 116.99,44.6 116.99,44.83 117.22,45.05 117.22,45.22 117.09,45.35 116.92,45.35 116.82,45.24 116.64,45.24 116.52,45.37 116.52,45.54 116.62,45.64 116.62,45.82 106.19,56.25 105.71,57.11 105.11,58.59 104.2,60.85 103.62,63.51 103.38,64.59 103.38,69.31
  BOTTOM w0.079: U400.AC28 107.12,85.17 v1(106.86,84.91)
  BOTTOM w0.127: JDIM2801.120 v2(155.82,35.71)
M_B_A12: length 94.3
  IN2 w0.079: 106.73,70.21 106.73,72.08 107.63,72.98 107.63,73.83 108.34,74.55 108.34,79.84 107.26,80.92 107.26,85.16 107.15,85.26 106.23,85.26 v1(105.96,84.99)
  IN2 w0.165: 106.73,70.21 106.73,65.57 107.43,61.82 108.12,60.17 108.71,59.11 109.21,58.13 109.44,57.75 109.51,57.67 109.75,57.67 109.89,57.82 110.12,57.82 110.29,57.65 110.29,57.51 110.1,57.31 110.1,57.09 110.25,56.93 110.46,56.93 110.61,57.09 110.82,57.09 110.96,56.95 110.96,56.74 110.81,56.58 110.81,56.38 110.95,56.23 111.16,56.23 111.31,56.39 111.52,56.39 111.66,56.25 111.66,56.04 111.51,55.88 111.51,55.68 122.44,44.75 122.64,44.75 122.85,44.95 123.05,44.95 123.2,44.81 123.2,44.6 123,44.4 123,44.2 123.14,44.05 123.35,44.05 123.55,44.25 123.75,44.25 123.9,44.1 123.9,43.9 123.27,43.27 123.27,43.04 123.65,42.66 124.14,42.66 124.39,42.91 125.71,42.91 127.15,41.47 129.41,41.47 129.79,41.09 130.26,41.09 130.65,40.7 131.12,40.7 131.64,40.18 152.62,40.18 152.73,40.29 154.18,40.29 154.58,40.69 v2(155.41,40.69)
  BOTTOM w0.079: v1(105.96,84.99) 106.14,85.17 U400.AB28
  BOTTOM w0.127: v2(155.41,40.69) 155.57,40.85 155.57,41.61 155.15,42.02 155.15,43.05 155.29,43.19 155.44,43.19 155.57,43.32 JDIM2801.119
M_B_A13: length 95.2
  IN2 w0.079: v1(112.31,73.96) 112.57,73.96 112.73,73.79 112.73,71.94 112.66,71.86 112.66,71.63
  IN2 w0.165: 112.66,71.63 112.66,69.32 115.32,66.65 115.32,64.47 117.64,62.16 117.64,60.97 126.33,52.29 130.56,52.29 131.89,50.95 145.25,50.95 146.82,49.38 150.94,49.38 152.32,48 157.42,48 158.43,46.99 163.49,46.99 166.26,44.22 166.26,41.94 166.59,41.61 166.88,41.61 167.2,41.29 167.2,40.71 166.81,40.32 166.81,39.84 166.66,39.69 166.25,39.69 166.09,39.52 166.09,39.18 166.25,39.02 166.63,39.02 166.8,38.85 166.8,36.81 166.62,36.63 165.97,36.63 165.84,36.51 165.84,35.52 166.01,35.36 166.33,35.36 166.45,35.48 166.45,35.96 166.62,36.12 166.96,36.12 167.32,36.48 v2(167.32,38.31)
  BOTTOM w0.079: v1(112.31,73.96) 112.06,74.21 111.73,74.21 111.54,74.4 111.54,75.01 111.72,75.19 111.72,77.75 111.18,78.29 111.18,79.12 111.19,79.13 111.19,79.72 111.16,79.79 111.16,79.98 111.19,80.06 111.19,80.47 111.27,80.55 U400.AK35
  BOTTOM w0.127: v2(167.32,38.31) JDIM2801.158
M_B_ACT#: length 92.5
  IN2 w0.079: v1(104.12,84.97) 103.92,84.73 103.8,84.53 103.78,84.43 103.78,84.25 103.79,82.21 104.22,78.97 104.27,77.97 103.98,74.42 103.9,73.88 102.54,70.64 102.54,69.99
  IN2 w0.165: 102.54,69.99 102.54,64.24 103.4,60.6 104.83,57 105.2,56.05 105.51,55.75 114.28,46.97 115.92,44.49 116.34,43.91 116.34,43.67 115.7,43.02 115.7,42.79 115.89,42.59 116.13,42.59 116.59,43.06 116.92,43.06 117.07,42.91 117.66,42.09 118.64,40.64 120.48,37.93 120.96,37.46 121.23,37.26 122.46,36.61 125.19,35.83 129.41,35.03 131.25,34.78 152.05,34.78 153.11,35.84 153.65,35.84 v2(154.09,35.4)
  BOTTOM w0.079: U400.W28 v1(104.12,84.97)
  BOTTOM w0.127: JDIM2801.114 154.32,35.63 v2(154.09,35.4)
M_B_ALERT#: length 88.9
  IN2 w0.079: 103.95,73.24 104.03,73.61 104.19,74.53 104.48,77.84 104.58,80.45 104.67,82.93 104.67,83.03 104.69,83.15 104.73,83.25 v1(105.11,84.13)
  IN2 w0.165: 103.95,73.24 102.96,68.79 102.96,64.41 103.17,63.51 103.8,60.73 105.11,57.47 105.28,57.06 105.4,56.76 105.8,56.04 114.63,47.22 115.08,46.64 116.9,44 120.17,39.16 121.15,37.86 121.46,37.61 121.85,37.44 121.98,37.39 125.03,36.31 125.36,36.22 129.47,35.45 131.37,35.23 131.65,35.2 151.35,35.2 152.34,35.76 152.71,35.96 152.94,36.06 153.09,36.12 153.65,36.12 153.91,36.07 v2(154.76,35.75)
  BOTTOM w0.079: v1(105.11,84.13) 105.48,84.49 U400.Y29
  BOTTOM w0.127: JDIM2801.116 154.82,36.12 v2(154.76,35.75)
M_B_BG#0: length 94.4
  IN2 w0.079: 107.15,70.26 107.15,72.22 107.83,72.9 107.83,73.69 108.58,74.44 108.58,80.84 107.42,82 107.42,85.4 107.35,85.48 107.35,85.92 107.27,86 105.74,86 105.59,85.85 105.59,84.86 105.37,84.64 104.39,84.64 v1(104.15,84.4)
  IN2 w0.165: 107.15,70.26 107.15,65.61 107.83,61.94 108.5,60.35 108.86,59.7 109.14,59.4 112.37,56.16 112.37,55.96 112.2,55.78 112.2,55.58 112.34,55.43 112.55,55.43 112.73,55.61 112.93,55.61 113.08,55.47 113.08,55.26 112.9,55.08 112.9,54.88 113.05,54.73 113.25,54.73 113.43,54.91 113.63,54.91 113.78,54.76 113.78,54.56 113.6,54.38 113.6,54.18 122.2,45.57 123.05,45.57 124.44,44.18 124.44,43.73 124.84,43.34 125.97,43.34 126.09,43.21 126.33,43.21 126.44,43.33 126.44,43.75 126.61,43.92 126.84,43.92 127.01,43.75 127.01,42.3 127.41,41.89 129.58,41.89 129.96,41.51 130.43,41.51 130.78,41.16 131.25,41.16 131.81,40.6 152.45,40.6 152.49,40.65 153.88,40.65 v2(154.03,40.8)
  BOTTOM w0.079: v1(104.15,84.4) 104.27,84.52 U400.W29
  BOTTOM w0.127: v2(154.03,40.8) 154.39,41.15 154.39,41.69 154.57,41.86 JDIM2801.115
M_B_BG#1: length 94
  IN2 w0.079: v1(105.06,85.03) 104.63,85.47 104.63,85.91 104.89,86.17 107.89,86.17 108.17,85.9 108.17,82 108.21,81.95 108.21,81.54 108.75,81.01 108.75,74.37 108.11,73.73 108.11,72.8 107.57,72.26 107.57,70.26
  IN2 w0.165: 107.57,70.26 107.57,65.65 108.24,62.06 108.87,60.53 109.18,59.97 114.48,54.68 114.48,54.47 114.3,54.28 114.3,54.07 114.44,53.93 114.65,53.93 114.83,54.12 115.04,54.12 115.18,53.97 115.18,53.76 115,53.58 115,53.37 122.24,46.13 123.09,46.13 124.87,44.35 127.97,44.35 128.11,44.2 128.11,43.3 128.26,43.16 128.46,43.16 128.61,43.3 128.61,44.2 128.75,44.35 128.98,44.35 129.15,44.19 129.15,43.9 129.31,43.73 129.54,43.73 129.7,43.9 129.7,44.19 129.85,44.35 130.32,44.35 130.84,43.82 130.84,42.16 131.98,41.02 152.25,41.02 152.33,41.1 v2(153.4,41.1)
  BOTTOM w0.079: U400.Y28 105.2,85.17 v1(105.06,85.03)
  BOTTOM w0.127: JDIM2801.113 154.07,41.77 v2(153.4,41.1)
M_B_BS#0: length 96.1
  IN2 w0.079: 114.14,67.28 112.35,69.07 v1(112.35,72.13)
  IN2 w0.165: 114.14,67.28 114.22,67.28 114.91,66.59 114.91,64.3 117.22,61.98 117.22,60.8 126.45,51.57 126.83,51.57 127.11,51.85 127.34,51.85 127.51,51.68 127.51,50.7 127.67,50.53 128.04,50.53 128.18,50.68 128.18,51.2 128.35,51.37 128.66,51.37 128.8,51.23 128.8,50.68 128.95,50.53 129.89,50.53 130.03,50.68 130.03,51.72 130.18,51.87 130.38,51.87 130.53,51.72 130.53,50.68 130.67,50.53 145.08,50.53 146.65,48.96 150.71,48.96 152.09,47.58 157.24,47.58 158.26,46.57 163.32,46.57 165.79,44.09 165.79,42.04 165.38,41.63 165.38,41.39 165.55,41.23 166.42,41.23 166.65,40.99 166.65,40.76 166.4,40.51 165.43,40.51 165.26,40.34 165.26,39.87 165.43,39.7 v2(165.6,39.7)
  BOTTOM w0.079: U400.AJ37 110.85,79.49 110.85,78.14 111.37,77.62 111.37,76.82 111.21,76.66 111.21,76.13
  BOTTOM w0.127: v2(165.6,39.7) 165.44,39.7 165.31,39.83 165.31,40.19 165.12,40.38 164.88,40.38 164.75,40.25 164.75,39.63 165.16,39.22 165.16,38.15 165.32,37.99 JDIM2801.150 ; v1(112.35,72.13) 111.88,71.66 111.59,71.66 111.49,71.56 111.49,71.12 111.36,70.99 111.18,70.99 111.03,71.13 111.03,75.39 111.21,75.57 111.21,76.13
M_B_BS#1: length 95.5
  IN2 w0.079: v1(110.59,75.63) 111.51,74.71 111.51,68.79 112.76,67.54 112.76,67.43
  IN2 w0.165: v2(164.01,43.94) 163.05,44.9 162.82,44.9 162.65,44.73 162.65,44.18 162.9,43.94 163.39,43.94 163.59,43.75 163.59,43.57 163.43,43.41 162.79,43.41 162.62,43.25 162.62,43.02 162.88,42.75 163.3,42.75 163.56,42.49 163.56,42.3 163.42,42.16 163.13,42.16 163.01,42.03 163.01,41.8 163.18,41.63 163.64,41.63 163.81,41.47 163.81,41.18 163.68,41.06 163.21,41.06 163.06,40.91 163.06,40.74 163.23,40.58 164.23,40.58 164.37,40.43 164.37,40.24 164.24,40.11 164.04,40.11 163.88,39.95 163.88,39.44 163.74,39.31 163.54,39.31 163.4,39.45 163.4,39.92 163.23,40.09 162.86,40.09 162.62,40.33 162.62,41.53 162.2,41.95 162.2,44.86 161.75,45.31 157.73,45.31 156.72,46.32 151.42,46.32 150.05,47.7 142.25,47.7 140.68,49.27 126.97,49.27 114.53,61.71 114.53,62.57 113.88,63.23 113.8,63.51 112.86,67.04 112.76,67.43
  BOTTOM w0.079: v1(110.59,75.63) 110.91,75.63 110.98,75.71 110.98,76.76 111.19,76.97 111.19,77.56 110.68,78.07 110.68,79.26 110.51,79.43 110.51,79.66 110.61,79.91 110.61,80.06 U400.AJ36
  BOTTOM w0.127: JDIM2801.145 164.07,44.25 164.01,44.2 v2(164.01,43.94)
M_B_CAS#: length 96.1
  IN2 w0.079: v1(112.2,77.5) 112.48,77.22 113.72,77.22 114.13,76.81 114.13,72.73 114.78,72.08 114.78,71.76
  IN2 w0.165: v2(167.34,39.6) 167.35,39.6 167.85,39.1 167.85,37.25 168.11,36.99 168.62,36.99 168.79,37.16 168.79,39.67 168.62,39.83 168.02,39.83 167.85,40 167.85,40.27 168,40.42 168.61,40.42 168.79,40.59 168.79,40.89 168.62,41.05 167.83,41.05 167.67,41.22 167.67,41.53 167.86,41.72 168.4,41.72 168.71,42.03 168.71,44.73 164.36,49.08 159.35,49.08 158.34,50.09 153.19,50.09 151.81,51.47 147.69,51.47 145.93,53.23 135.19,53.23 133.19,55.23 128.94,55.23 120.9,63.27 119.49,63.27 117.43,65.33 117.43,67.39 114.78,70.05 114.78,71.76
  BOTTOM w0.079: v1(112.2,77.5) 112.2,77.65 111.91,77.94 111.91,78.58 111.64,78.84 111.64,79.73 111.67,79.8 111.67,80.02 111.64,80.1 111.64,80.37 111.67,80.46 111.67,80.64 111.64,80.72 111.64,80.97 U400.AK34
  BOTTOM w0.127: v2(167.34,39.6) 166.82,39.08 JDIM2801.156
M_B_CB0: length 2.8
  TOP w0.102: R2829.2 148.78,38.98 v2(148.82,39.02)
  BOTTOM w0.114: v2(148.82,39.02) JDIM2801.92
M_B_CB1: length 3
  TOP w0.102: R2830.2 147.56,44.59 v2(148.47,43.69)
  BOTTOM w0.102: JDIM2801.91 148.57,44.27 148.47,44.17 v2(148.47,43.69)
M_B_CB2: length 5.2
  TOP w0.102: R2831.2 150.91,44.65 v2(150.91,43.91) v2(150.91,42.45)
  BOTTOM w0.102: JDIM2801.101 151.07,44.23 150.91,44.07 v2(150.91,42.45)
M_B_CB3: length 4
  TOP w0.102: v2(151.95,42.47) 151.09,41.61 R2833.2
  BOTTOM w0.102: JDIM2801.105 152.07,44.26 151.95,44.15 v2(151.95,42.47)
M_B_CB4: length 2.9
  TOP w0.102: v2(147.82,39.05) 147.71,38.94 R2834.2
  BOTTOM w0.114: v2(147.82,39.05) JDIM2801.88
M_B_CB5: length 4.5
  TOP w0.102: v2(147.01,42.99) 146.41,43.58 R2835.2
  BOTTOM w0.114: v2(147.01,42.99) 147.57,43.55 JDIM2801.87
M_B_CB6: length 4.2
  TOP w0.102: v2(150.55,39.73) 150.55,38.79 150.5,38.74 R2836.2
  BOTTOM w0.114: v2(150.55,39.73) 150.6,39.68 150.6,38.19 150.82,37.97 JDIM2801.100
M_B_CB7: length 3.4
  TOP w0.102: v2(151.39,39.14) 151.56,38.97 R2837.2
  BOTTOM w0.102: JDIM2801.104 151.82,38.71 v2(151.39,39.14)
M_B_CKE0: length 89.6
  IN2 w0.079: v1(103.23,85) 103.69,85.46 103.69,86.04 104.05,86.39 107.91,86.39 108.33,85.96 108.33,82.14 108.45,82.02 108.45,81.65 108.95,81.16 108.95,74.17 108.41,73.64 108.41,72.8 107.99,72.38 107.99,71.89
  IN2 w0.165: v2(152.05,41.53) 151.96,41.44 132.16,41.44 131.26,42.34 131.26,44.06 130.56,44.77 125.04,44.77 123.19,46.61 122.35,46.61 115.81,53.16 115.81,54 110.09,59.72 109.7,60.1 109.7,60.1 108.95,61.6 108.62,62.54 108.45,63.51 107.99,66.13 107.99,71.89
  BOTTOM w0.079: U400.T28 103.07,85.17 v1(103.23,85)
  BOTTOM w0.127: JDIM2801.109 153.07,42.04 152.56,41.53 v2(152.05,41.53)
M_B_CKE1: length 90.3
  IN2 w0.079: 102.12,69.75 102.12,70.52 103.72,73.91 103.72,73.92 103.72,76.43 103.22,80.2 102.86,82.4 102.85,82.71 102.86,82.84 102.88,83.64 102.9,83.8 102.94,83.92 v1(103.23,84.4)
  IN2 w0.165: 102.12,69.75 102.12,64.19 103,60.48 104.43,56.85 104.5,56.67 104.83,55.74 105.2,55.05 105.64,54.25 105.64,54.23 113.88,45.99 113.89,45.99 115.92,40.74 116.05,40.51 116.36,40.23 117.18,39.62 119.25,38.27 120.16,37.36 120.53,37.08 122.1,36.29 124.43,35.56 125.12,35.39 128.75,34.64 130.18,34.45 131.23,34.36 152.28,34.36 v2(153.32,35.4)
  BOTTOM w0.079: U400.T29 v1(103.23,84.4)
  BOTTOM w0.127: JDIM2801.110 v2(153.32,35.4)
M_B_CLKN0: length 95.5
  IN2 w0.079: 110.53,80.7 110.53,80.72 110.56,80.75 110.56,81.39 109.98,81.98 109.98,83.98 109.77,84.19 109.49,84.19 109.23,84.45 109.23,84.66 109.18,84.71 109.18,85.03 109.58,85.43 v1(109.58,85.6)
  IN2 w0.114: 110.53,80.7 110.53,79.15 110.78,78.9 111.24,78.9 111.49,79.15 111.49,79.93 111.63,80.07 111.95,80.07 112.07,79.94 112.07,79.2 112.35,78.92 113.22,78.92 113.7,78.44 113.7,78.08 113.4,77.78 113.03,77.78 112.6,78.21 112.03,78.21 111.5,77.68 111.25,77.68 110.71,78.22 110.34,78.22 109.89,77.77 109.89,72.54 109.46,72.11 109.46,68.78 111.6,60.96 125.84,46.72 131.56,46.72 133.13,45.15 148.99,45.15 150.37,43.77 154.11,43.77 154.74,43.14 155.74,43.14 156.73,42.14 160.24,42.14 160.49,42.39 160.49,42.72 v2(160.7,42.93)
  BOTTOM w0.079: v1(109.58,85.6) 109.41,85.43 109.41,85.42 U400.AF28
  BOTTOM w0.097: JDIM2801.139 160.57,44.31 160.5,44.24 160.49,44 160.49,43.13 v2(160.7,42.93)
M_B_CLKN1: length 94.7
  IN2 w0.079: v1(108.72,84.99) 108.72,84.89 109.06,84.55 109.06,84.28 109.23,84.11 109.23,81.79 109.66,81.36 109.66,80.74 109.69,80.71 109.69,80.7
  IN2 w0.114: 109.69,80.7 109.69,80.14 109.94,79.89 109.94,78.62 109.55,78.22 109.55,72.64 109.13,72.22 109.13,67.51 111.04,60.64 125.6,46.08 131.32,46.08 132.88,44.53 135.74,44.53 136.15,44.11 136.15,42.9 136.31,42.75 136.67,42.75 136.79,42.86 136.79,44.25 137.07,44.53 137.89,44.53 138.18,44.23 138.18,43.36 138.36,43.19 138.57,43.19 138.84,43.46 138.84,44.23 139.14,44.53 141.17,44.53 141.51,44.19 141.51,43.86 141.63,43.74 141.87,43.74 142.17,44.04 142.17,44.25 142.45,44.53 144.02,44.53 144.57,43.97 144.94,43.97 145.49,44.53 148.73,44.53 150.13,43.13 153.87,43.13 154.48,42.52 155.73,42.52 156.48,41.78 160.26,41.78 160.59,41.45 160.59,40.16 160.72,40.02 160.72,39.12 v2(160.92,38.92)
  BOTTOM w0.079: v1(108.72,84.99) 108.42,84.99 U400.AE28
  BOTTOM w0.097: v2(160.92,38.92) 160.81,38.92 160.71,38.82 160.71,38.46 160.82,38.36 JDIM2801.140
M_B_CLKP0: length 95.7
  IN2 w0.079: v1(109.56,84.87) 109.4,84.7 109.4,84.52 109.56,84.36 109.84,84.36 110.14,84.05 110.14,82.05 110.73,81.46 110.73,80.75 110.76,80.72 110.76,80.7 ; 110.22,66.86 110.27,66.68
  IN2 w0.114: v2(159.93,42.93) 160.14,42.93 160.26,42.81 160.26,42.49 160.14,42.37 156.83,42.37 155.83,43.37 154.84,43.37 154.21,44 150.46,44 149.08,45.38 133.23,45.38 131.66,46.95 125.93,46.95 111.8,61.08 110.27,66.68 ; 110.22,66.86 109.69,68.81 109.69,72.01 110.12,72.45 110.12,77.68 110.43,78 110.61,78 111.16,77.45 111.59,77.45 112.12,77.98 112.5,77.98 112.94,77.55 113.5,77.55 113.93,77.98 113.93,78.53 113.31,79.15 112.44,79.15 112.3,79.29 112.3,80.03 112.04,80.29 111.53,80.29 111.26,80.02 111.26,79.24 111.15,79.13 110.87,79.13 110.76,79.24 110.76,80.7
  BOTTOM w0.079: U400.AF29 109.08,84.44 109.08,84.26 109.16,84.18 109.67,84.18 109.73,84.24 109.73,84.35 109.64,84.44 109.51,84.44 109.44,84.51 109.44,84.75 v1(109.56,84.87)
  BOTTOM w0.097: JDIM2801.137 160.07,44.36 160.16,44.26 160.22,44.26 160.29,44.19 160.29,43.02 160.2,42.93 v2(159.93,42.93)
M_B_CLKP1: length 94.8
  IN2 w0.079: v1(108.7,84.4) 109.06,84.04 109.06,81.72 109.49,81.29 109.49,80.75 109.46,80.71 109.46,80.7
  IN2 w0.114: v2(160.16,38.92) 160.39,38.92 160.5,39.03 160.5,39.93 160.36,40.07 160.36,41.35 160.16,41.55 156.38,41.55 155.63,42.3 154.38,42.3 153.78,42.9 150.03,42.9 148.63,44.3 145.59,44.3 145.03,43.74 144.48,43.74 143.92,44.3 142.55,44.3 142.4,44.15 142.4,43.95 141.97,43.52 141.53,43.52 141.28,43.76 141.28,44.09 141.08,44.3 139.24,44.3 139.07,44.13 139.07,43.36 138.67,42.96 138.26,42.96 137.96,43.26 137.96,44.13 137.79,44.3 137.16,44.3 137.02,44.15 137.02,42.77 136.77,42.52 136.21,42.52 135.92,42.8 135.92,44.02 135.64,44.3 132.78,44.3 131.23,45.85 125.5,45.85 110.84,60.52 108.9,67.48 108.9,72.32 109.32,72.74 109.32,78.32 109.71,78.71 109.71,79.79 109.46,80.05 109.46,80.7
  BOTTOM w0.079: U400.AE29 108.41,84.68 108.52,84.68 108.7,84.5 v1(108.7,84.4)
  BOTTOM w0.097: JDIM2801.138 160.32,37.95 160.41,38.04 160.55,38.04 160.62,38.11 160.62,38.28 160.52,38.38 160.52,38.82 160.42,38.92 v2(160.16,38.92)
M_B_CS#0: length 91.4
  IN2 w0.079: 113.85,71.84 113.85,72.09 113.65,72.29 113.65,76.21 113.53,76.33 v1(112.26,76.33)
  IN2 w0.165: 113.85,71.84 113.85,69.93 116.59,67.19 116.59,64.98 119.15,62.43 119.49,62.43 119.49,62.43 120.55,62.43 122.37,60.61 122.37,59.88 122.8,59.45 122.8,59.19 122.1,58.5 122.1,58.29 122.25,58.15 122.45,58.15 123.15,58.84 123.35,58.84 123.5,58.7 123.5,58.49 122.82,57.81 122.82,57.61 122.97,57.46 123.17,57.46 123.85,58.14 124.05,58.14 124.2,58 124.2,57.79 123.52,57.11 123.52,56.91 126.04,54.39 132.76,54.39 134.76,52.39 145.59,52.39 147.34,50.63 151.46,50.63 152.84,49.26 157.94,49.26 158.95,48.24 164.01,48.24 167.76,44.49 167.76,42.61 167.27,42.12 v2(166.73,42.12)
  BOTTOM w0.079: U400.AL37 112.07,78.9 112.25,78.72 112.25,78.21 112.72,77.73 112.72,76.79 v1(112.26,76.33)
  BOTTOM w0.127: JDIM2801.149 165.07,44.25 164.88,44.07 164.88,42.83 165.08,42.63 165.57,42.63 166.07,42.12 v2(166.73,42.12)
M_B_CS#1: length 93.4
  IN2 w0.079: v1(112.28,74.55) 112.61,74.22 112.96,74.22 113.04,74.15 113.04,71.73
  IN2 w0.165: 113.04,71.73 113.04,69.6 115.75,66.88 115.75,64.64 118.06,62.33 118.06,61.15 125.65,53.55 126.22,53.55 126.38,53.39 126.38,52.82 126.5,52.71 126.79,52.71 126.94,52.85 126.94,53.41 127.08,53.55 127.29,53.55 127.43,53.41 127.43,52.85 127.58,52.71 127.78,52.71 127.93,52.85 127.93,53.41 128.07,53.55 128.28,53.55 128.42,53.41 128.42,52.85 128.57,52.71 128.77,52.71 128.92,52.85 128.92,53.41 129.06,53.55 129.27,53.55 129.41,53.41 129.41,52.85 129.56,52.71 129.77,52.71 129.91,52.85 129.91,53.41 130.06,53.55 130.26,53.55 130.41,53.41 130.41,52.85 130.55,52.71 130.73,52.71 130.89,52.87 130.89,53.39 131.05,53.55 131.28,53.55 131.44,53.39 131.44,52 131.62,51.82 131.86,51.82 131.96,51.92 131.96,53.38 132.13,53.55 132.32,53.55 132.47,53.4 132.47,51.6 132.7,51.37 132.96,51.37 133.13,51.54 133.13,51.96 133.29,52.13 133.52,52.13 133.69,51.96 133.69,51.6 133.92,51.37 145.42,51.37 147,49.8 151.11,49.8 152.49,48.42 157.59,48.42 158.6,47.4 163.67,47.4 166.79,44.28 v2(166.79,43.86)
  BOTTOM w0.079: U400.AL35 112.39,80.55 112.39,80 112.49,79.68 112.49,78.95 112.58,78.86 112.58,78.35 113.06,77.87 113.06,75.13 112.91,74.98 112.91,74.91
  BOTTOM w0.127: v1(112.28,74.55) 112.28,74.55 112.6,74.23 112.78,74.23 112.91,74.35 112.91,74.91 ; v2(166.79,43.86) 167.07,44.13 JDIM2801.157
M_B_DQ0: length 53.2
  IN1 w0.127: v2(130.82,39.07) 130.36,39.53 130.36,39.7 130.97,41.76 130.97,44.2 115.97,59.2 115.97,63.42 114.79,64.6 114.79,69.42 115.71,70.34 v1(115.71,70.59)
  BOTTOM w0.079: 113.14,74.07 113.14,74.43 113.23,74.51 113.23,78.26 113.3,78.34 113.3,78.64 112.86,79.08 112.86,79.69 112.97,79.98 112.97,80.27 U400.AN35
  BOTTOM w0.102: v2(130.82,39.07) JDIM2801.20 ; 113.14,74.07 113.14,73.32 113.04,73.22 113.04,72.28 114.42,70.9 114.52,70.83 v1(115.71,70.59)
M_B_DQ1: length 50.2
  IN1 w0.127: v1(114.48,77.78) 112.33,77.93 111.98,77.87 111.81,77.65 111.81,75.64 111.84,75.6 111.84,71.33 110.81,70.29 110.81,58.81 116,53.1 120.44,48.66 v2(125.86,43.82)
  BOTTOM w0.079: v1(114.48,77.78) 114.73,78.04 114.73,78.52 114.54,78.71 114.54,78.98 114.16,79.36 114.16,79.73 114.19,79.82 114.19,80.03 114.16,80.1 114.16,80.36 114.19,80.42 114.19,80.67 114.16,80.74 114.16,81.01 114.21,81.13 114.21,81.41 114.1,81.52 U400.AN34
  BOTTOM w0.102: v2(125.86,43.82) 126.14,43.82 126.57,44.24 JDIM2801.3
M_B_DQ2: length 52.8
  IN1 w0.127: v2(129.82,39.05) 129.32,39.54 129.32,40.26 129.57,40.52 129.57,40.9 129.32,41.15 129.32,42.04 129.5,42.22 129.5,42.66 129.68,42.84 129.68,43.88 114.69,58.86 114.69,62.13 114.06,62.77 114.06,63.67 113.65,64.08 113.65,70.08 114.99,71.43 114.99,72.7 115.25,72.95 v1(115.65,72.95)
  BOTTOM w0.079: U400.AR35 114.94,80.52 114.94,79.9 114.96,79.83 115.21,79.58 115.21,78.99 115.4,78.8 115.4,75.8 115.1,75.5 115.1,75.21
  BOTTOM w0.102: v2(129.82,39.05) JDIM2801.16 ; v1(115.65,72.95) 115.65,73.4 v2(115.42,73.64) 115.1,73.96 115.1,75.21
M_B_DQ3: length 53.3
  IN1 w0.127: v2(126.56,40.83) 126.29,41.09 126.29,44.08 125.31,45.07 125.18,45.07 120.02,50.22 120.02,50.35 118.53,51.85 118.37,51.85 111.19,59.03 111.19,70.19 112.86,71.86 112.86,75.51 v1(114.5,77.15)
  BOTTOM w0.079: v1(114.5,77.15) 114.89,77.73 114.89,78.59 114.71,78.78 114.71,79.05 114.33,79.43 114.33,79.71 114.36,79.79 114.36,80.06 114.33,80.13 114.33,80.33 114.36,80.38 114.36,80.71 114.33,80.78 114.33,80.97 114.38,81.1 U400.AR34
  BOTTOM w0.102: v2(126.56,40.83) 126.84,40.54 126.92,40.54 127.21,40.26 127.21,39.63 127.04,39.45 127.04,38.41 126.82,38.19 JDIM2801.4
M_B_DQ4: length 52.9
  IN1 w0.127: v1(115.68,72.34) 115.68,72.41 115.54,72.55 115.36,72.55 115.27,72.46 115.27,71.23 114.94,70.9 114.94,70.77 114.03,69.86 114.03,64.24 114.66,63.61 114.66,63.43 114.46,63.23 114.46,63.05 114.64,62.87 114.94,62.87 115.07,62.74 115.07,59.02 130.11,43.98 v2(130.11,43.38)
  BOTTOM w0.079: 113.64,74.55 113.64,78.78 113.19,79.22 113.19,79.49 U400.AN37
  BOTTOM w0.102: 113.64,74.55 113.64,73.44 113.74,73.34 114.11,73.34 114.25,73.19 114.25,73.05 114.15,72.95 113.77,72.95 113.64,72.82 113.64,72.67 113.79,72.52 114.3,72.52 114.4,72.42 114.4,72.28 114.22,72.1 114.22,71.95 114.35,71.82 114.49,71.82 114.69,72.01 114.83,72.01 114.93,71.91 114.93,71.68 115.07,71.53 115.24,71.53 115.34,71.63 115.34,72.08 115.13,72.29 115.13,72.44 115.24,72.55 115.47,72.55 v1(115.68,72.34) ; JDIM2801.17 130.07,44.07 130.17,43.97 130.39,43.97 130.57,43.8 130.57,43.2 130.46,43.09 130.21,43.09 130.11,43.2 v2(130.11,43.38)
M_B_DQ5: length 52.7
  IN1 w0.127: v2(130.3,41.96) 130.46,41.96 130.59,42.09 130.59,42.53 130.48,42.63 130.48,42.92 130.59,43.02 130.59,44.04 115.58,59.05 115.58,63.22 114.41,64.4 114.41,69.63 115.3,70.52 115.3,70.77 v1(115.71,71.18)
  BOTTOM w0.079: 113.4,73.92 113.4,78.19 113.47,78.27 113.47,78.71 113.03,79.15 113.03,79.66 113.13,79.95 113.13,80.07 U400.AN36
  BOTTOM w0.102: v2(130.3,41.96) 130.3,41.61 130.44,41.47 131.09,41.47 131.2,41.58 131.2,44.07 131.07,44.21 JDIM2801.21 ; 113.4,73.92 113.4,72.43 114.65,71.18 v1(115.71,71.18)
M_B_DQ6: length 52.8
  IN1 w0.127: v1(114.56,75.37) 114.4,75.2 114.22,75.2 114.09,75.33 114.09,75.53 113.98,75.65 113.75,75.65 113.5,75.39 113.5,74.91 113.62,74.78 114.05,74.78 114.18,74.66 114.18,74.38 114.08,74.28 113.62,74.28 113.5,74.15 113.5,71.76 112.05,70.32 112.05,61.42 112.18,61.3 113.08,61.3 113.2,61.17 113.2,60.91 113.1,60.81 112.18,60.81 112.02,60.65 112.02,60.47 112.18,60.3 113.06,60.3 113.2,60.17 113.2,59.99 113.01,59.8 112.18,59.8 112.05,59.67 112.05,59.42 112.18,59.29 113.04,59.29 113.17,59.16 113.17,58.95 112.93,58.71 112.93,58.53 113.51,57.94 127.51,43.94 v2(127.51,43.79)
  BOTTOM w0.079: U400.AR36 114.77,80.04 114.77,79.87 114.81,79.73 115.04,79.51 115.04,78.92 115.23,78.73 115.23,76.03 v1(114.56,75.37)
  BOTTOM w0.102: v2(127.51,43.79) 127.51,44.25 127.57,44.3 JDIM2801.7
M_B_DQ7: length 52.6
  IN1 w0.127: v2(127.82,39.05) 128.37,39.6 128.37,40.37 128.13,40.62 127.74,40.62 127.57,40.44 127.26,40.44 127.14,40.57 127.14,41.15 126.86,41.43 126.86,44.06 111.62,59.3 111.62,70.29 113.19,71.86 113.19,75.42 113.75,75.98 v1(114.54,75.98)
  BOTTOM w0.079: U400.AR37 114.87,79.28 114.87,78.85 115.06,78.66 115.06,76.5 v1(114.54,75.98)
  BOTTOM w0.102: v2(127.82,39.05) JDIM2801.8
M_B_DQ8: length 85.9
  IN2 w0.127: v2(172.83,38.99) 173.26,39.42 173.26,40.32 173.13,40.44 173.13,44.98 165.49,52.63 163.77,52.63 163.51,52.89 161.08,52.89 160.54,53.43 154.65,53.43 153.25,54.84 149.38,54.84 147.57,56.64 136.74,56.64 134.79,58.59 131.52,58.59 123.81,66.31 123.81,67.54 121.84,69.5 120.07,69.5 v2(117.88,71.68)
  BOTTOM w0.079: 115.45,75.16 115.45,75.3 115.56,75.42 115.56,78.87 115.38,79.06 115.38,79.69 115.48,79.98 115.51,80.19 115.56,80.38 U400.AU35
  BOTTOM w0.102: v2(117.88,71.68) 117.81,71.68 116.78,72.71 116.78,73.03 115.45,74.36 115.45,75.16 ; v2(172.83,38.99) 173.32,38.5 JDIM2801.182
M_B_DQ9: length 85.3
  IN2 w0.127: v1(116.1,76.24) 115.3,75.44 115.3,74.1 116.1,73.3 116.1,69.97 118.47,67.6 118.47,65.76 119.92,64.3 121.33,64.3 125.45,60.19 125.63,60.19 125.98,60.54 126.16,60.54 126.34,60.36 126.34,60.18 125.99,59.83 125.99,59.65 126.16,59.47 126.34,59.47 126.7,59.82 126.88,59.82 127.06,59.64 127.06,59.46 126.7,59.11 126.7,58.93 126.83,58.81 127.01,58.81 127.34,59.14 127.54,59.14 127.72,58.96 127.72,58.78 127.38,58.44 127.38,58.26 129.37,56.27 133.62,56.27 135.62,54.27 146.77,54.27 148.53,52.51 152.24,52.51 153.61,51.13 158.77,51.13 159.78,50.12 164.79,50.12 170.34,44.57 170.34,43.44 v2(170.24,43.34)
  BOTTOM w0.079: U400.AU34 116,81.32 116,81.08 116.05,80.97 116.05,80.75 116.02,80.6 116.02,80.41 116.06,80.32 116.06,80.15 116.03,80.05 116.03,79.78 116.05,79.7 116.05,79.15 116.07,79.14 116.07,77.46 116.45,77.08 116.45,76.59 v1(116.1,76.24)
  BOTTOM w0.102: JDIM2801.169 170.07,44.05 170.24,43.87 v2(170.24,43.34)
M_B_DQ10: length 87
  IN2 w0.127: v2(173.59,42.44) 173.59,41.14 173.72,41.02 173.9,41.02 174.02,41.14 174.02,45.17 165.81,53.39 164.09,53.39 163.82,53.65 161.39,53.65 160.36,54.69 157.92,54.69 157.44,54.21 157.44,54.2 156.2,54.2 155.71,54.69 154.47,54.69 153.56,55.6 149.69,55.6 147.8,57.49 139.12,57.49 138.58,58.03 136.78,58.03 135.45,59.35 131.84,59.35 124.57,66.62 124.57,68.15 122.13,70.59 120.2,70.59 119.21,71.58 119.21,74.73 v1(117.85,76.09)
  BOTTOM w0.079: v1(117.85,76.09) 118.03,76.09 118.43,76.49 118.43,77.37 117.35,78.46 117.35,79.18 117.52,79.36 117.52,79.68 117.45,79.9 117.45,80.52 U400.AW35
  BOTTOM w0.102: JDIM2801.187 174.57,43.42 v2(173.59,42.44)
M_B_DQ11: length 86
  IN2 w0.127: v1(116.09,75.04) 115.58,74.53 115.58,74.15 116.47,73.26 116.47,70.34 118.85,67.96 118.85,65.92 120.08,64.69 121.49,64.69 124.67,61.51 125.73,61.51 130.59,56.65 133.77,56.65 135.77,54.65 146.93,54.65 148.68,52.89 152.39,52.89 153.77,51.51 158.93,51.51 159.94,50.5 164.95,50.5 170.72,44.72 170.72,42.12 170.65,42.04 v2(170.19,42.04)
  BOTTOM w0.079: U400.AW34 116.38,81.52 116.17,81.31 116.17,81.12 116.22,81.01 116.22,80.73 116.19,80.58 116.19,80.45 116.22,80.36 116.22,80.12 116.19,80.03 116.19,79.81 116.22,79.73 116.22,79.22 116.24,79.21 116.24,77.53 116.67,77.1 116.67,76.61
  BOTTOM w0.097: 116.67,76.61 116.67,76.23
  BOTTOM w0.102: v2(170.19,42.04) 170.42,42.04 171.1,42.73 171.1,44.23 171.07,44.26 JDIM2801.173 ; v1(116.09,75.04) 116.67,75.62 116.67,76.23
M_B_DQ12: length 85.4
  IN2 w0.127: v1(116.09,76.85) 115.87,77.07 115.17,77.07 115.01,76.91 115.01,73.72 115.2,73.54 115.2,70.29 118.09,67.4 118.09,65.6 119.76,63.92 121.17,63.92 129.21,55.89 133.46,55.89 135.46,53.89 146.33,53.89 148.09,52.13 152.08,52.13 153.46,50.75 158.61,50.75 159.62,49.73 164.63,49.73 169.96,44.41 169.96,43.72 169.63,43.39 169.63,39.44 v2(170.09,38.98)
  BOTTOM w0.079: U400.AU37 115.8,79.11 115.9,79.01 115.9,77.04 v1(116.09,76.85)
  BOTTOM w0.102: v2(170.09,38.98) 170.3,38.98 170.52,38.77 170.52,38.16 170.32,37.96 JDIM2801.170
M_B_DQ13: length 84.9
  IN2 w0.127: v2(171.32,38.34) 170.85,38.34 170.72,38.47 170.72,40.93 171.1,41.31 171.1,44.88 165.11,50.88 160.1,50.88 159.08,51.89 153.93,51.89 152.55,53.27 148.84,53.27 147.08,55.03 135.93,55.03 133.93,57.03 130.98,57.03 125.9,62.11 124.61,62.11 121.65,65.07 120.24,65.07 119.23,66.08 119.23,68.29 116.7,70.82 116.7,73.82 v1(116.08,74.43)
  BOTTOM w0.079: v1(116.08,74.43) 115.73,74.78 115.73,78.94 115.54,79.13 115.54,79.66 115.61,79.85 115.66,79.94 U400.AU36
  BOTTOM w0.102: v2(171.32,38.34) JDIM2801.174
M_B_DQ14: length 85.6
  IN2 w0.127: v2(174.32,38.32) 173.77,38.86 173.77,39.86 174.4,40.5 174.4,45.33 165.96,53.77 164.24,53.77 164.07,53.95 164.07,54.31 163.8,54.58 161.95,54.58 161.45,55.07 155.02,55.07 154.12,55.98 149.85,55.98 147.96,57.88 139.27,57.88 138.74,58.41 136.94,58.41 135.61,59.73 132,59.73 124.95,66.78 124.95,68.56 122.66,70.85 120.56,70.85 119.57,71.84 119.57,74.99 v1(117.84,76.72)
  BOTTOM w0.079: v1(117.84,76.72) 118.09,76.97 118.09,77.47 117.18,78.39 117.18,79.25 117.36,79.43 117.36,79.65 117.29,79.87 U400.AW36
  BOTTOM w0.102: v2(174.32,38.32) JDIM2801.186
M_B_DQ15: length 85.1
  IN2 w0.127: v2(117.83,74.87) 117.97,75 118.44,75 118.8,74.64 118.8,74.46 118.68,74.33 118.38,74.33 118.26,74.21 118.26,73.95 118.38,73.82 118.7,73.82 118.85,73.67 118.85,73.44 118.73,73.32 118.45,73.32 118.32,73.19 118.32,72.94 118.45,72.81 118.73,72.81 118.85,72.68 118.85,72.43 118.73,72.3 118.37,72.3 118.24,72.17 118.24,71.92 118.37,71.79 118.75,71.79 118.88,71.67 118.88,71.33 120.25,69.96 122.13,69.96 124.19,67.9 124.19,66.46 131.68,58.97 134.95,58.97 136.79,57.13 136.97,57.13 137.1,57.26 137.1,57.54 137.2,57.64 137.45,57.64 137.55,57.54 137.55,57.18 137.71,57.02 137.92,57.02 138.04,57.15 138.04,57.52 138.17,57.64 138.43,57.64 138.55,57.52 138.55,57.15 138.68,57.02 147.73,57.02 149.53,55.22 153.4,55.22 154.81,53.82 155.02,53.82 155.15,53.94 155.15,54.18 155.28,54.31 155.55,54.31 155.65,54.21 155.65,53.98 155.82,53.82 157.98,53.82 158.11,53.94 158.11,54.18 158.23,54.31 158.49,54.31 158.61,54.18 158.61,53.94 158.74,53.82 158.99,53.82 159.12,53.94 159.12,54.13 159.25,54.26 159.48,54.26 159.6,54.13 159.6,53.97 159.76,53.82 160.69,53.82 161.24,53.27 163.66,53.27 163.93,53.01 165.65,53.01 173.57,45.09 v2(173.57,43.84)
  BOTTOM w0.079: v2(117.83,74.87) 117.45,74.87 117.37,74.94 117.37,77.96 117.01,78.32 117.01,79.49 U400.AW37
  BOTTOM w0.102: v2(173.57,43.84) 173.57,43.84 JDIM2801.183
M_B_DQ16: length 58.8
  IN1 w0.079: 110.55,81.29 110.46,81.5 110,81.96 110,84.18 110.24,84.49 v1(110.53,84.84)
  IN1 w0.127: 110.55,81.29 110.77,80.56 111.96,79.37 112.81,79.02 113.45,78.87 114.47,78.78 114.65,78.71 114.74,78.51 114.88,77.77 115.01,76.69 115.11,75.33 115.15,74.48 115.15,74.07 116.14,73.08 116.14,70.44 115.6,69.58 115.6,64.68 116.6,63.69 116.6,59.47 131.6,44.46 131.6,41.59 131.43,39.78 131.43,39.6 131.51,39.38 v2(131.82,39.07)
  BOTTOM w0.079: v1(110.53,84.84) 110.79,84.66 U400.AJ29
  BOTTOM w0.102: v2(131.82,39.07) JDIM2801.24
M_B_DQ17: length 58.5
  IN1 w0.079: 110.96,81.11 110.96,81.31 110.17,82.1 110.17,83.67 110.35,83.85 110.78,83.85 111.12,84.19 v1(111.44,84.19)
  IN1 w0.127: v2(132.04,43.49) 132.04,44.57 117.72,58.88 117.72,59.29 117.6,59.42 117.19,59.42 116.98,59.63 116.98,59.9 117.11,60.03 117.6,60.03 117.72,60.16 117.72,60.41 117.6,60.54 117.11,60.54 116.98,60.67 116.98,60.92 117.11,61.05 117.6,61.05 117.72,61.17 117.72,61.43 117.6,61.56 117.11,61.56 116.98,61.68 116.98,61.94 117.11,62.06 117.6,62.06 117.72,62.19 117.72,62.44 117.6,62.57 117.11,62.57 116.98,62.7 116.98,63.85 116.01,64.82 116.01,69.58 116.39,69.96 116.39,73.18 115.43,74.15 115.43,78.36 114.56,79.23 113.22,79.23 112.83,79.62 112.19,79.62 110.96,80.85 110.96,81.11
  BOTTOM w0.079: U400.AJ30 111.11,83.87 v1(111.44,84.19)
  BOTTOM w0.102: v2(132.04,43.49) 132.29,43.74 132.29,44.08 132.07,44.3 JDIM2801.25
M_B_DQ18: length 59.3
  IN1 w0.127: v1(112.39,82.23) 112.39,81.83 112.51,81.71 112.8,81.71 113.96,80.55 115.6,80.55 117.06,79.09 117.06,78.63 118.3,77.39 118.3,71.49 118.45,71.35 118.45,68.94 118.35,68.84 118.35,65.68 119.97,64.06 119.97,63.61 120.14,63.44 120.54,63.44 120.68,63.3 120.68,62.99 120.56,62.86 120.1,62.86 119.97,62.74 119.97,62.48 120.1,62.36 120.56,62.36 120.68,62.23 120.68,59.1 127.71,52.08 127.85,52.08 127.97,52.2 128.17,52.2 128.29,52.08 128.29,51.49 128.97,50.82 129.15,50.82 129.63,51.3 129.81,51.3 129.99,51.12 129.99,50.94 129.51,50.46 129.51,50.28 129.69,50.1 129.87,50.1 130.37,50.6 130.54,50.6 130.72,50.42 130.72,50.24 130.23,49.74 130.23,49.56 134.52,45.27 134.52,44.23 134.62,44.13 134.62,42.52 134.48,42.37 v2(134.24,42.37)
  BOTTOM w0.079: v1(112.39,82.23) 112.56,82.4 112.63,82.4 U400.AM32
  BOTTOM w0.102: v2(134.24,42.37) 134.96,43.1 134.96,44.09 135.07,44.19 JDIM2801.37
M_B_DQ19: length 59.8
  IN1 w0.079: 113.33,81.6 112.78,82.15 112.78,82.46 v1(112.35,82.89)
  IN1 w0.127: 113.33,81.6 114.13,80.81 115.73,80.81 117.28,79.25 117.97,79.25 118.19,79.02 118.19,78.19 118.69,77.69 118.69,71.62 118.91,71.4 118.91,68.88 118.73,68.7 118.73,65.84 121.06,63.51 121.06,59.26 127.57,52.76 129.03,52.76 129.87,51.92 129.87,51.81 131.16,50.52 131.16,49.17 135,45.33 135,41.51 135.12,41.38 135.41,41.38 135.54,41.25 135.54,41 135.41,40.88 135,40.88 134.88,40.75 134.88,40.5 135,40.37 135.34,40.37 135.46,40.24 v2(135.46,39.7)
  BOTTOM w0.079: U400.AM31 112.64,83.06 112.51,83.06 v1(112.35,82.89)
  BOTTOM w0.102: JDIM2801.38 135.32,37.98 135.1,38.19 135.1,39.33 v2(135.46,39.7)
M_B_DQ20: length 60.1
  IN1 w0.079: v1(112.35,83.54) 112.71,83.19 112.71,82.79 113.32,82.17 113.32,82.12 113.42,82.02
  IN1 w0.127: v2(135.43,43.02) 135.83,43.42 135.83,45.03 131.54,49.33 131.54,50.68 130.26,51.96 130.26,52.08 129.19,53.14 127.72,53.14 122.08,58.78 122.08,60.51 121.89,60.7 121.58,60.7 121.45,60.84 121.45,61.4 121.85,61.8 121.85,62.54 121.45,62.95 121.45,63.66 121.28,63.83 121.28,64.01 121.91,64.64 121.91,64.82 121.73,65 121.55,65 120.93,64.37 120.75,64.37 119.11,66.02 119.11,68.1 119.29,68.28 119.29,68.44 119.41,68.57 120.25,68.57 120.38,68.69 120.38,68.95 120.25,69.07 119.41,69.07 119.29,69.2 119.29,71.63 119.03,71.89 119.03,77.82 118.6,78.25 118.6,79 117.81,79.79 117.18,79.79 115.37,81.59 113.85,81.59 113.42,82.02
  BOTTOM w0.079: U400.AM30 112.65,83.72 112.52,83.72 v1(112.35,83.54)
  BOTTOM w0.102: JDIM2801.41 136.07,43.65 135.81,43.4 v2(135.43,43.02)
M_B_DQ21: length 60.6
  IN1 w0.079: 113.42,82.5 113.27,82.5 112.94,82.83 112.94,83.61 v1(112.35,84.19)
  IN1 w0.127: v2(136.25,39.07) 135.92,39.4 135.92,42.27 136.25,42.6 136.25,45.15 131.92,49.49 131.92,50.84 130.64,52.12 130.64,52.23 130.44,52.43 129.12,53.75 127.65,53.75 122.46,58.94 122.46,64.3 122.67,64.5 122.67,67.69 119.72,70.64 119.72,71.66 119.39,71.99 119.39,77.88 119.5,78 119.5,78.73 118.14,80.09 117.36,80.09 115.53,81.92 113.99,81.92 113.72,82.19 113.72,82.38 113.6,82.5 113.42,82.5
  BOTTOM w0.079: U400.AM29 112.61,84.33 112.48,84.33 v1(112.35,84.19)
  BOTTOM w0.102: JDIM2801.42 136.32,38.07 136.25,38.13 v2(136.25,39.07)
M_B_DQ22: length 57.5
  IN1 w0.079: 111.51,81.31 111.51,81.56 111.08,82 111.08,82.68 111.08,82.68 111.08,83.42 110.83,83.67 110.73,83.67 v1(110.53,83.47)
  IN1 w0.127: v2(133.07,43.01) 132.9,43.17 132.9,44.78 119.2,58.49 119.2,58.93 119.07,59.06 118.63,59.06 118.49,59.2 118.49,59.38 118.61,59.51 119.07,59.51 119.2,59.63 119.2,59.89 119.07,60.01 118.61,60.01 118.49,60.14 118.49,60.34 118.61,60.47 118.97,60.47 119.07,60.56 119.07,60.74 118.49,61.32 118.49,63.44 116.86,65.07 116.86,69.39 117.36,69.88 117.36,70.82 116.92,71.25 116.92,74 116.65,74.27 116.65,77.2 116.57,77.27 116.14,77.27 116.04,77.37 116.04,77.86 116.21,78.03 116.21,78.54 114.99,79.76 113.47,79.76 113.05,80.18 112.37,80.18 111.51,81.03 111.51,81.31
  BOTTOM w0.079: v1(110.53,83.47) 110.71,83.65 110.8,83.65 110.98,83.47 U400.AJ31
  BOTTOM w0.102: JDIM2801.29 v2(133.07,43.01)
M_B_DQ23: length 57.5
  IN1 w0.079: v1(110.53,82.84) 110.9,82.46 110.9,81.84 111.25,81.5 111.25,81.21
  IN1 w0.127: v2(132.85,39.07) 132.74,39.07 132.32,39.49 132.32,41.84 132.52,42.04 132.52,44.63 118.11,59.04 118.11,63.27 116.48,64.89 116.48,69.53 116.98,70.02 116.98,70.78 116.65,71.11 116.65,73.31 115.68,74.27 115.68,78.59 114.79,79.48 113.37,79.48 112.95,79.9 112.29,79.9 111.25,80.94 111.25,81.21
  BOTTOM w0.079: U400.AJ32 110.79,82.76 110.61,82.76 v1(110.53,82.84)
  BOTTOM w0.102: v2(132.85,39.07) 132.79,39.01 132.79,37.05 JDIM2801.28
M_B_DQ24: length 92.4
  IN2 w0.079: v1(114.17,83.54) 114.49,83.23 114.49,82.63 114.54,82.58 114.54,82.23
  IN2 w0.127: 114.54,82.23 114.54,82.02 114.36,81.84 114.36,80.62 115.55,79.43 117.58,79.43 118.88,78.14 119.82,78.14 121.24,76.71 121.24,72.52 121.6,72.17 123.17,72.17 126.35,68.99 126.35,67.36 132.58,61.13 136.19,61.13 137.19,60.13 140.89,60.13 141.76,59.27 148.54,59.27 150.43,57.38 154.69,57.38 155.6,56.47 162.03,56.47 162.52,55.97 164.73,55.97 165.28,55.42 166.29,55.42 176.22,45.49 176.22,44.56 176.13,44.47 176.13,42.3 175.85,42.02 v2(175.85,40.26)
  BOTTOM w0.079: U400.AR31 114.45,83.4 114.32,83.4 v1(114.17,83.54)
  BOTTOM w0.102: JDIM2801.194 176.32,38.62 176.41,38.71 176.41,39.7 v2(175.85,40.26)
